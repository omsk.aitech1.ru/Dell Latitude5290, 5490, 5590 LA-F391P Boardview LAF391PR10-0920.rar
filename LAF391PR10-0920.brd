# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BAT2_LED#_R: length 22.9
  TOP w0.102: v1(281.01,36.74) 281.01,37.28 QZ2.6 281.6,37.31 281.96,37.66 281.96,37.99 282.52,38.56 282.88,38.56 QZ2.3 282.88,39.56 v2(282.17,40.27) ; QZ3.2 268.1,32.48 268.36,32.74 269.35,32.74 v1(270.31,33.7)
  IN1 w0.089: v1(281.01,36.74) 281.01,36.97 280.68,37.3 279.76,37.3 278.28,35.81 276.74,35.81 276.28,35.35 270.51,35.35 269.9,34.74 269.9,33.98 270.18,33.7 v1(270.31,33.7)
BATT_WHITE#: length 68.9
  TOP w0.254: JLED1.3 272.3,8.89 271.96,8.56 v1(271.96,8.3) ; v1(271.96,27.66) 271.96,29.38 271.71,29.64 271.71,30.5 v3(271.35,30.86) 270.95,31.26 RZ361.2 269.4,31.26 269.04,30.91 269.04,30.59 268.67,30.22 266.42,30.22 266.17,30.48 QZ3.3
  IN3 w0.254: v1(271.96,8.3) 271.96,9.44 272.47,9.95 275.77,9.95 276.41,10.59 276.41,11.48 274.97,12.91 269.13,12.91 268.43,12.21 261.95,12.21 260.14,14.03 260.14,15.5 261.7,17.06 261.7,21.51 259.54,23.67 256.39,23.67 256.11,23.95 256.11,24.58 257.84,26.31 258.27,26.31 258.55,26.59 266.89,26.59 267.33,27.02 271.42,27.02 271.96,27.56 v1(271.96,27.66)
BATT_YELLOW#: length 3.9
  TOP w0.254: JLED1.2 271.8,10.46 v3(272.21,10.87) 272.6,11.26 272.6,11.73 272.97,12.1 RZ28.2
BBS_BIT6: length 16.5
  TOP w0.102: RC184.1 152.06,54.4 148.81,54.4 148.76,54.34 148.11,54.34 147.87,54.1 140.34,54.1 139.16,55.27 138.53,55.27 v2(138.38,55.42) v1(137.42,56.38)
  BOTTOM w0.076: v1(137.42,56.38) 137.77,56.74 UC1.AN5
BC_CLK_ECE1117: length 118.3
  TOP w0.076: v1(272.23,51.32) v3(271.68,51.86) 271.56,51.99 269.17,51.99 268.91,51.73 UE1.D13
  TOP w0.102: CZ87.1 202.29,21.26 202.75,20.8 202.75,20.24 203.03,19.96 203.35,19.96 203.66,19.65 203.66,19.07 203.65,19.06 JKBTP1.10 203.65,17.63 203.42,17.4 203.42,16.61 203.75,16.28 206.18,16.28 v1(207.1,15.35)
  IN2 w0.122: v1(272.23,51.32) 272.6,50.95 272.6,46.43 272.84,46.19 272.84,44.76 273.54,44.06 273.54,35.03 272.25,33.74 272.25,32.98 271.12,31.85 268.15,31.85 265.71,29.41 264.22,29.41 263.3,28.49 262.31,28.49 261.93,28.11 261.93,26.84 260.41,25.32 260.41,22.49 260.79,22.11 260.79,21.18 260.27,20.67 260.27,19.34 259.37,18.44 258.35,18.44 256.87,16.96 256.87,15.1 256.45,14.68 255.99,14.68 255.39,14.08 253.48,14.08 252.4,13 250.69,13 249.62,14.07 247.91,14.07 247.81,13.97 244.15,13.97 242.6,12.42 242.6,12.04 241.55,10.99 231.9,10.99 230.86,12.03 230.86,13.83 230.04,14.65 229.65,14.65 228.86,15.44 219.19,15.44 218.88,15.13 216.6,15.13 216.2,14.74 207.71,14.74 v1(207.1,15.35)
BC_DAT_ECE1117: length 119.3
  TOP w0.076: v1(271.42,51.32) 271,51.74 269.3,51.74 268.98,51.42 268.59,51.42 268.28,51.73 UE1.D12
  TOP w0.102: v1(206.51,15.35) 206.19,15.67 203.38,15.67 202.65,16.4 JKBTP1.8 202.65,19.29 202.34,19.6 202.34,20.61 v3(202.05,20.9) 201.86,21.09 201.86,21.79 CZ86.1 ; v1(271.42,51.32) 271.42,50.81 RE365.1
  IN2 w0.122: v1(271.42,51.32) 272.08,50.65 272.08,46.23 272.33,45.98 272.33,44.25 273.04,43.55 273.04,35.79 271.84,34.59 271.84,34.26 270.64,33.07 268.41,33.07 268.13,32.79 268.13,32.58 266.07,30.53 263.96,30.53 263.69,30.26 263.69,29.75 263.55,29.6 262.15,29.6 261.42,28.87 261.42,27.22 259.74,25.55 259.74,19.52 259.16,18.94 258.09,18.94 257.11,17.96 256.35,17.96 255.33,16.94 255.33,15.54 255.07,15.29 252.19,15.29 251.25,14.35 250.05,14.35 249.83,14.58 247.91,14.58 246.58,15.91 245.2,15.91 243.57,14.28 242.66,14.28 241.33,12.94 241.33,12.56 240.27,11.5 232.12,11.5 231.36,12.26 231.36,14.04 230.24,15.16 229.85,15.16 229.01,16 219.03,16 218.67,15.64 216.39,15.64 215.99,15.24 209.88,15.24 209.07,16.05 207.2,16.05 v1(206.51,15.35)
BC_INT#_ECE1117: length 90.2
  TOP w0.076: UE1.E2 260.02,50.98 259.75,51.25 258.74,51.25 258.63,51.35 257.95,51.35 v1(257.72,51.13)
  TOP w0.102: v1(196.25,29.15) v3(196.7,28.7) 196.7,26.29 197.67,25.32 197.97,25.32 199.18,24.11 199.69,24.11 200.03,23.77 200.03,22.73 CZ85.1 200.59,22.27 201.35,21.51 201.35,21.03 201.93,20.44 201.93,19.43 202.15,19.21 JKBTP1.7
  IN3 w0.122: v1(196.25,29.15) 196.74,28.66 198.39,28.66 199.19,27.86 204.33,27.86 204.71,28.24 206.67,28.24 207.46,27.45 212.02,27.45 212.94,28.37 214.58,28.37 215.17,27.78 217.22,27.78 217.81,28.37 221.04,28.37 222.8,30.13 224.86,30.13 225.15,29.84 227.84,29.84 229.43,31.43 232.62,31.43 233.47,32.27 237.11,32.27 240.17,35.33 240.17,35.99 241.61,37.44 241.61,37.92 244.53,40.84 244.53,41.35 244.83,41.65 245.5,41.65 246.7,42.86 247.77,42.86 251.73,46.82 251.73,46.83 251.98,47.07 251.98,47.07 252.08,47.17 253.47,47.17 253.52,47.23 253.56,47.23 254.82,48.48 255.2,48.48 257.69,50.97 257.69,51.1 v1(257.72,51.13)
BCM5882_ALERT#: length 77.2
  TOP w0.102: v2(280.01,37.22) 279.73,36.94 v1(279.73,36.69) ; v1(257.48,7.92) 257.6,8.04 JUSH1.14 ; UE1.G10 266.82,48.93 v1(266.85,48.93)
  IN1 w0.089: v1(279.73,36.69) 280.04,36.39 280.62,36.39 280.71,36.3 280.71,35.8 280.67,35.77 280.67,31.4 279.34,30.07 279.31,30.07 275.72,26.48 273.98,26.48 273.73,26.23 267.86,26.23 264.16,22.53 261.95,22.53 261.57,22.91 261.57,23.08 261.09,23.56 258.36,23.56 258.1,23.3 258.1,22.72 259.95,20.87 259.95,20.42 261.49,18.87 261.49,16.97 259.52,14.99 259.52,12.95 258.04,11.48 258.04,8.48 v1(257.48,7.92)
  BOTTOM w0.102: v1(266.85,48.93) 267.22,49.3 271.06,49.3 271.8,48.56 273.74,48.56 274.71,47.6 276.1,47.6 276.36,47.34 276.36,45.94 276.52,45.78 RE532.1 276.52,42.22 277.05,41.69 277.05,39.62 279.73,36.94 v1(279.73,36.69)
BEEP: length 45.9
  TOP w0.076: UE1.H11 267.58,48.89 v1(267.59,48.89)
  TOP w0.102: RA13.2 273.23,24.14 v1(273.23,23.87)
  IN3 w0.122: v1(273.23,23.87) 273.66,24.3 275.39,24.3 276.53,25.45 276.53,27.18 274.76,28.95 267.16,28.95 266.5,28.29 264.69,28.29 264.63,28.24 262.7,28.24 262.16,28.77 262.16,29.36 262.84,30.04 262.84,30.32 266.25,33.73 266.25,35.72 267.39,36.86 267.39,39.09 267.94,39.64 267.94,47.41 268.1,47.57 268.1,48.38 v1(267.59,48.89)
  BOTTOM w0.102: v1(273.23,23.87) v2(272.67,23.87)
BEEP_R: length 6
  TOP w0.254: RA45.1 CA62.1 275.04,21.89 275.04,24.86 274.5,25.4 CA28.1 RA13.1
BGATE_ISL9538: length 49.2
  IN3 w0.508: v1(35.87,22.78) 35.23,22.78 33.84,24.18 22.38,24.18 19.46,27.1 19.46,32.79 20.72,34.04 20.72,39.12 22.53,40.94 28.97,40.94 29.48,41.45 30.28,41.45 30.6,41.77 32.12,41.77 33.25,42.9 v1(33.25,47.21)
  vias: v2(35.51,23.88)
BIA_PWM: length 3.7
  TOP w0.102: DV1.1 69.91,95.22 69.68,95.45 68.87,95.45 LV1.2 68.84,94.57 RV1.1 v2(69.79,94.53)
BIA_PWM_EC: length 262.7
  TOP w0.076: UE1.N1 258.73,44.53 258.28,44.08 258.28,43.74 v1(258.12,43.58)
  TOP w0.102: DV1.2 71.5,94.57 71.14,94.2 69.76,94.2 69.42,93.86 67.48,93.86 67.34,93.72 v2(66.62,93.72) 66.06,93.72 65.83,93.95 65.83,95.08 v1(66.02,95.27)
  IN1 w0.089: v1(258.12,43.58) 256.19,43.58 255.71,43.1 254.69,43.1 253.48,44.31 252.09,44.31 251.74,43.96 249.13,43.96 247.18,45.91 v1(247.18,45.94)
  IN2 w0.122: v1(247.18,45.94) 246.21,45.94 244.89,44.62 244.01,44.62 241.39,42.01 240.65,42.01 238.68,40.04 238.68,39.46 237.02,37.8 236.22,37.8 234.46,36.04 233.09,36.04 232.71,35.66 226.97,35.66 226.34,35.03 225.69,35.03 224.87,34.21 212.92,34.21 211.62,35.51 206.93,35.51 206.04,36.39 205.32,36.39 204.02,37.69 195.83,37.69 193.36,40.16 193.36,41.72 185.87,49.22 185.87,54.28 181.43,58.72 181.43,61.22 179.83,62.82 179.83,63.53 166.16,77.2 166.16,78.23 163.88,80.51 163.3,80.51 160.58,83.22 160.58,88.41 158.97,90.01 156.87,90.01 152.1,94.79 142.27,94.79 140.36,96.69 130.93,96.69 130.7,96.47 124.36,96.47 121.57,99.26 121.57,101.42 117.35,105.63 108.51,105.63 107.85,106.3 105.01,106.3 104.68,105.96 104.11,105.96 103.59,106.49 100.38,106.49 97.34,109.53 94.03,109.53 92.62,108.12 84.53,108.12 81.92,105.51 79.8,105.51 78.81,106.51 69.63,106.51 67.71,104.59 67.71,101.1 66.15,99.54 66.15,95.4 v1(66.02,95.27)
BL_PWR_SRC_ON: length 4.4
  TOP w0.102: v3(78.8,103.6) 79.54,103.6 79.99,103.16 79.99,101.04 79.63,100.68 CV13.1
BLUE: length 12.7
  TOP w0.102: JCRT1.3 293.9,52.28 292.79,53.39 292.28,53.39 v2(290.89,54.78) 290.89,55.93 289.92,56.89 287.02,56.89 DV6.2 286.63,57.29 CV131.1 LV18.2
BLUE_CRT: length 9.4
  TOP w0.102: LV18.1 283.14,56.54 CV128.1 RV118.1 v2(282.12,55.29) 282.31,55.1 282.88,55.1 283.03,54.96 283.03,54.6 282.92,54.5 282.54,54.5 282.44,54.4 282.44,54.09 282.54,53.99 282.92,53.99 283.03,53.89 283.03,52.99 283.57,52.44 UV6.21
BOARD_ID: length 6.9
  TOP w0.102: CE40.1 RE79.1 274.02,46.68 272.66,46.68 v2(272.39,46.95) 272.15,47.19 270.29,47.19 269.85,47.62 268.94,47.62 UE1.J13
BOOT1_ISL9538:
  vias: v2(30.98,40.88)
BOOT2_ISL9538:
  vias: v2(34.23,44.29)
BREATH_LED#: length 27.4
  TOP w0.076: UE1.C11 267.3,52.53 267.77,53.01 272.74,53.01 v1(272.83,53.09)
  TOP w0.102: v3(276.53,67.43) v1(276.13,67.84) 276.07,67.89 QZ7.4
  IN1 w0.089: v1(276.13,67.84) 276.13,64.47 277.08,63.52 277.08,53.55 277.33,53.3 277.33,52.94 276.89,52.5 273.42,52.5 v1(272.83,53.09)
BREATH_LED#_Q: length 2.2
  TOP w0.102: v2(274.9,70.4) QZ7.3 276.07,71.29 RZ32.1
BREATH_WHITE_LED_SNIFF#: length 35.4
  TOP w0.102: RZ32.2 277.3,71.37 v1(277.68,70.99) ; LED3.1 294.5,94.16 v2(294.15,93.81) 294.15,93.18 v1(294.19,93.14)
  IN2 w0.122: v1(294.19,93.14) 289.74,88.69 283.38,88.69 281.23,86.55 281.23,74.55 v1(277.68,70.99)
BST_3V:
  vias: v1(141.47,108.85)
BST_5V: length 2.3
  BOTTOM w0.102: 44.79,45.36 PR111.1 44.79,45.09 45.86,44.01 v2(45.86,43.49)
BST_+1VALWP: length 1.2
  BOTTOM w0.102: PC304.1 v2(157.8,104.56)
BST_+1VALWP_C: length 1.8
  BOTTOM w0.102: v3(154.4,101.08) 155.22,101.9 PR304.1
BT_RADIO_DIS#: length 58.5
  TOP w0.076: 258.8,53.01 259.32,53.01 259.79,52.53 UE1.C2
  TOP w0.102: v2(221.07,27.48) 220.92,27.33 v1(220.56,27.33) 220.36,27.52 DZ2.1 ; 258.8,53.01 258.53,53.29 v1(257.23,53.29) 257.17,53.22 RE11.1
  IN2 w0.122: v1(220.56,27.33) 220.92,26.97 223.52,26.97 223.88,27.33 226.85,27.33 227.58,28.06 232.66,28.06 233.77,29.17 234.83,29.17 235.09,28.9 237.71,28.9 237.95,29.14 237.95,30.56 242.58,35.19 244.17,35.19 244.81,35.83 246.08,35.83 246.79,36.55 246.79,37.81 247.07,38.09 247.07,40.18 247.82,40.93 248.34,40.93 252.18,44.76 252.18,45.38 252.8,45.99 252.8,47.01 253.9,48.11 253.9,50.4 254.86,51.35 255.33,51.35 256.44,52.47 256.44,52.5 v1(257.23,53.29)
BT_RADIO_DIS#_R: length 4.8
  TOP w0.102: v1(218.88,25.71) 218.88,25.95 217.87,26.96 DZ2.2 217.18,27.52 v2(216.91,27.8)
  BOTTOM w0.102: JNGFF1.54 218.72,25.25 218.88,25.41 v1(218.88,25.71)
CAM_MIC_CBL_DET#: length 144
  TOP w0.102: RC413.1 151.21,65.3 151.46,65.05 151.46,62.66 v1(151.99,62.13) ; v2(69.14,81.45) v1(69.14,81.96)
  IN1 w0.076: 127.1,63.37 127.67,63.37 127.99,63.69 132.55,63.69 132.8,63.44 134.95,63.44 v1(135.39,62.99)
  IN1 w0.089: 127.1,63.37 126.78,63.37 126.14,64.02 126.14,65.6 125.28,66.47 115.14,66.47 114.13,67.48 114.13,68.32 113.85,68.6 107.01,68.6 106.23,69.39 106.23,70.33 105.72,70.84 105.72,71.45 106.29,72.02 106.29,75.11 103.36,78.04 103.36,78.51 102.82,79.04 102.82,82.06 101.55,83.33 101.55,88.24 99.99,89.8 86.66,89.8 83.6,86.74 82.23,86.74 81.19,85.7 75.38,85.7 75.09,85.41 74.71,85.41 71.84,82.53 71.84,82.44 71.39,82 69.49,82 69.45,81.96 v1(69.14,81.96)
  IN4 w0.089: v1(135.39,62.99) 136.21,63.81 138.96,63.81 140.47,62.3 142.78,62.3 143.44,61.64 145.03,61.64 145.41,62.02 150.91,62.02 151.19,61.74 151.6,61.74 v1(151.99,62.13)
  BOTTOM w0.076: v1(135.39,62.99) 135.35,62.99 134.83,62.47 UC1.AB11
  BOTTOM w0.102: JEDP1.14 66.86,98.85 65.82,99.89 62.31,99.89 61.52,99.11 61.52,96.19 62.03,95.68 62.03,94.28 62.54,93.77 62.54,92.05 66.22,88.37 66.22,86.03 66.86,85.39 68.88,85.39 69.14,85.12 v1(69.14,81.96)
CFG0: length 42.8
  IN2 w0.122: v1(92.42,95.43) 92.42,95.96 93.24,96.79 100.88,96.79 101.38,96.29 v1(101.38,95.98) 102.57,94.79 102.98,94.79 103.71,94.05 103.71,92.33 v1(103.28,91.89)
  BOTTOM w0.076: UC1.E68 102.54,71.94 102.6,72.03 102.68,72.29 102.72,72.55 102.77,72.74 102.82,72.89 102.82,73.11 102.79,73.18 102.79,73.19 102.79,73.44 102.82,73.5 102.82,74.02 102.69,74.15 102.69,74.39 102.36,74.72 101.38,74.72 100.62,75.48 100.62,76.48 101.17,77.03 101.17,78
  BOTTOM w0.102: JXDP1.9 101.14,96.22 v1(101.38,95.98) ; v1(92.42,95.43) 92.42,94.99 RC126.1 ; v1(103.28,91.89) 103.03,91.64 103.03,90.38 103.64,89.77 103.64,88.57 RC113.1 103.71,87.52 103.71,84.77 102.47,83.53 v2(102.47,82.77) 102.47,82.21 101.27,81.02 101.27,80.21 100.87,79.8 100.87,79.32 101.17,79.02 101.17,78
CFG1: length 34
  TOP w0.102: v1(100.79,95.98) 100.79,95.92 102.77,93.94 102.77,93.62 103.99,92.4 103.99,91.76 105.67,90.08 105.67,85.45 101.96,81.74 101.96,79.15 v2(101.18,78.37) 100.94,78.13 v1(100.61,78.13) 100.03,78.71 100.03,80.84 RC112.1
  BOTTOM w0.076: v1(100.61,78.13) 100.61,78.1 100.57,78.06 ; UC1.B67 102.03,73.36 102.03,73.77 101.46,74.34 101.15,74.34 100.23,75.26 100.23,77.72 100.36,77.85
  BOTTOM w0.102: JXDP1.11 100.64,96.14 v1(100.79,95.98) ; 100.36,77.85 100.57,78.06
CFG2: length 31.9
  TOP w0.102: v1(100.2,95.98) 100.2,94.71 102.87,92.04 102.87,91.17 104.27,89.77 104.27,84.96 101.43,82.11 101.43,79.55 v1(101.32,79.45)
  BOTTOM w0.076: 100.8,76.4 100.8,75.54 101.44,74.9 102.41,74.9 102.46,74.85 103.05,74.85 103.43,74.47 103.43,74.17 103.31,74.04 103.31,73.51 103.33,73.45 103.33,73.19 103.31,73.13 103.31,72.89 103.32,72.84 103.36,72.69 103.44,72.41 103.44,72.29 103.52,72.03 UC1.D65
  BOTTOM w0.102: v1(100.2,95.98) 99.64,96.54 JXDP1.15 ; v1(101.32,79.45) 101.4,79.37 101.4,77.01 100.8,76.4
CFG3: length 34.4
  TOP w0.102: v1(100.72,78.74) 100.64,78.81 RC110.1 100.74,79.35 101.07,79.02 101.5,79.02 101.73,79.24 101.73,81.84 105.44,85.54 105.44,89.99 103.76,91.66 103.76,92.31 102.54,93.53 102.54,93.84 101.4,94.99 v1(100.93,94.99)
  BOTTOM w0.076: v1(100.72,78.74) 100.99,78.46 100.99,77.11 100.43,76.55 100.43,75.39 101.27,74.55 102.29,74.55 102.53,74.32 102.53,74.08 102.65,73.95 102.65,73.54 102.63,73.5 102.63,73.16 102.65,73.08 102.65,72.91 102.57,72.66 102.54,72.62 UC1.D67
  BOTTOM w0.102: JXDP1.17 99.14,96.47 100.61,94.99 v1(100.93,94.99) 101.21,94.71 RC121.2
CFG4: length 40.9
  TOP w0.102: v1(96.71,95.98) 96.71,95.42 v2(96.94,95.19) 98.43,93.71 98.43,92.71 98.76,92.38 100.37,92.38 103.36,89.39 103.36,85.66 101.08,83.38 99.9,83.38 98.48,81.96 97.21,81.96 96.83,81.58 94.92,81.58 94.64,81.3 94.64,79.38 98.43,75.59 v1(98.43,71.79)
  BOTTOM w0.076: UC1.E70 100.35,71.35 100.15,71.54 99.96,71.54 99.95,71.55 99.85,71.55 99.52,71.88 98.53,71.88 v1(98.43,71.79)
  BOTTOM w0.102: RC109.1 97.26,95.44 v1(96.71,95.98) 96.64,96.06 JXDP1.27
CFG5: length 38.7
  TOP w0.102: v1(96.7,99.54) 98.51,97.73 98.51,96.08 102.65,91.94 102.65,91.07 104.04,89.67 104.04,85.21 v2(101.53,82.7) 100.18,82.7 99.8,82.32 99.8,78.72 99.62,78.53 v1(98.78,78.53)
  BOTTOM w0.076: UC1.C68 101.22,72.4 101.18,72.4 100.91,72.67 100.38,72.67 100.21,72.84 99.82,72.84 99.49,72.51 99.04,72.51 98.57,72.98
  BOTTOM w0.102: JXDP1.29 96.14,98.98 v1(96.7,99.54) ; 98.57,72.98 98.57,78.32 v1(98.78,78.53)
CFG6: length 39
  TOP w0.102: v1(96.09,99.54) 97.54,98.09 v2(97.54,97.71) 97.54,95.54 99.51,93.57 100.7,93.57 102.42,91.85 102.42,90.98 103.81,89.58 103.81,85.47 101.27,82.93 100.09,82.93 99.12,81.96 99.12,80.06 98.51,79.45 98.51,79.24 98.19,78.93 v1(98.19,78.53)
  BOTTOM w0.076: UC1.D68 100.47,71.87 100.16,72.18 99.51,72.18 99.38,72.31 98.92,72.31 98.19,73.05
  BOTTOM w0.102: JXDP1.33 95.14,99.19 95.48,99.54 v1(96.09,99.54) ; 98.19,73.05 v1(98.19,78.53)
CFG7: length 36.5
  TOP w0.102: v1(99.19,77.57) 98.51,77.57 97.77,78.3 97.77,78.86 98.2,79.29 98.2,79.47 98.78,80.06 v2(98.78,81.71) 98.78,81.95 99.99,83.16 101.18,83.16 103.59,85.56 103.59,89.48 100.81,92.26 100.81,92.95 100.42,93.34 99.42,93.34 97.31,95.45 97.31,96.01 96.88,96.44 95.98,96.44 v1(95.53,95.98)
  BOTTOM w0.076: v1(99.19,77.57) 99.19,75.34 100.77,73.77 100.77,73.54 100.99,73.31 101.37,73.31 101.8,72.88 UC1.C67
  BOTTOM w0.102: JXDP1.35 94.64,96.87 v1(95.53,95.98)
CFG8: length 63.2
  TOP w0.102: v1(98.35,80.62) v2(98.35,80.11)
  IN2 w0.122: v1(106.65,83.03) 106.39,83.28 103.94,83.28 101.52,80.86 98.6,80.86 v1(98.35,80.62)
  IN4 w0.089: v1(106.65,83.03) 106.62,83.05 106.62,85.56 106.98,85.91 106.98,87.55 106.3,88.22 106.3,90.5 105.6,91.2 105.6,92.06 103.39,94.28 103.06,94.28 102.82,94.52 101.52,94.52 101.18,94.18 98.99,94.18 97.58,95.59 97.58,97.01 95.2,99.39 95.2,104.36 v1(94.31,105.25)
  BOTTOM w0.076: 97.67,71.55 98.34,70.88 99.67,70.88 99.76,70.79 100.36,70.79 UC1.F71
  BOTTOM w0.102: v1(98.35,80.62) 97.72,79.98 97.03,79.98 96.8,79.75 96.8,76.99 97.67,76.13 97.67,71.55 ; v1(94.31,105.25) 95.23,106.17 100.23,106.17 101.14,105.26 JXDP1.10
CFG9: length 53.8
  IN2 w0.122: v1(108.41,84.25) 108.41,84.43 107.91,84.93 102.93,84.93 100.41,82.4 97.31,82.4 96.26,81.35 v1(96.26,81.11)
  IN4 w0.089: v1(108.41,84.25) 107.84,84.82 107.84,87.9 107.17,88.58 107.17,90.86 106.47,91.56 106.47,92.42 103.75,95.14 103.52,95.14 102.66,96 102.66,100.13 100.64,102.15 v1(100.64,102.26)
  BOTTOM w0.076: UC1.G69 101.17,69.89 100.92,69.89 100.73,69.83 100.54,69.83 100.41,69.86 100.16,69.86 100.08,69.83 99.78,69.83 99.39,70.22 98.93,70.22 98.86,70.15
  BOTTOM w0.102: 98.86,70.15 97.53,70.15 96.24,71.44 96.24,76.27 94.8,77.71 v2(94.8,79.02) 94.8,79.65 v1(96.26,81.11) ; JXDP1.12 v1(100.64,102.26)
CFG10: length 53.1
  IN2 w0.122: v1(97.21,79.5) 97.21,79.65 97.49,79.94 98.63,79.94 99.06,80.36 101.76,80.36 103.43,82.03 104.8,82.03 105.41,82.64 106.08,82.64 106.37,82.35 107.31,82.35 107.83,82.87 v1(107.83,83.03)
  IN4 w0.089: v1(99.93,105.25) 102.28,102.9 102.28,101.13 103.09,100.31 103.09,96.18 103.7,95.58 103.92,95.58 106.9,92.6 106.9,91.74 107.6,91.04 107.6,88.76 108.88,87.47 108.88,85.07 109.4,84.55 109.4,84.07 109.12,83.79 108.59,83.79 v1(107.83,83.03)
  BOTTOM w0.076: UC1.F70 100.74,70.99 100.14,70.99 100.13,70.97 99.81,70.97 99.74,71.04 98.45,71.04 98,71.5
  BOTTOM w0.102: 98,71.5 98,76.45 97.67,76.78 v2(97.67,77.54) 97.21,78 v1(97.21,79.5) ; JXDP1.16 99.64,104.96 v1(99.93,105.25)
CFG11: length 54.1
  TOP w0.102: v1(97.77,80.62) 97.36,80.2 v2(96.77,80.2)
  IN2 w0.122: v1(97.77,80.62) 97.77,80.44 98.02,80.18 98.53,80.18 98.96,80.61 101.66,80.61 103.33,82.28 104.69,82.28 105.31,82.89 106.18,82.89 106.47,82.6 106.81,82.6 v1(107.24,83.03)
  IN4 w0.089: v1(99.14,99.54) 99.14,95.88 100.63,94.4 101.09,94.4 101.43,94.74 102.91,94.74 103.15,94.5 103.48,94.5 105.82,92.15 105.82,91.29 106.52,90.59 106.52,88.31 107.19,87.64 107.19,85.82 106.84,85.47 106.84,83.44 v1(107.24,83.03)
  BOTTOM w0.076: UC1.G68 101.56,70.36 100.52,70.36 100.24,70.48 99.96,70.61 99.7,70.61 99.6,70.71 98.17,70.71 97.32,71.56
  BOTTOM w0.102: v1(97.77,80.62) 97.36,80.21 96.94,80.21 96.58,79.85 96.58,76.9 97.32,76.15 97.32,71.56 ; JXDP1.18 v1(99.14,99.54)
CFG12: length 60.9
  IN2 w0.122: v1(97.64,81.48) 98.07,81.91 99.42,81.91 99.72,81.61 101.21,81.61 103.85,84.25 v1(107.24,84.25)
  IN4 w0.089: v1(107.24,84.25) 107.24,85.57 107.41,85.73 107.41,87.73 106.74,88.4 106.74,90.68 106.04,91.38 106.04,92.24 103.57,94.71 103.34,94.71 103.01,95.04 101.83,95.04 101.45,95.42 100.07,95.42 99.59,95.9 99.59,99.74 98.24,101.09 97.72,101.09 96.68,102.13 96.68,105.23 v1(96.64,105.27)
  BOTTOM w0.076: UC1.H70 100.72,69.2 100.5,69.2 100.46,69.19 100.4,69.17 100.21,69.17 100.13,69.19 99.91,69.24 99.15,69.24 99.09,69.19
  BOTTOM w0.102: JXDP1.28 v1(96.64,105.27) ; v1(97.64,81.48) 97.11,82.01 95.08,82.01 94.24,81.17 94.24,77.62 95.58,76.28 v2(95.58,72.87) 95.58,71.02 97.41,69.19 99.09,69.19
CFG13: length 56.4
  IN2 w0.122: v1(107.83,84.25) 107.83,84.45 107.6,84.68 103.04,84.68 100.51,82.16 97.44,82.16 96.84,81.55 v1(96.84,81.11)
  IN4 w0.089: v1(107.83,84.25) 107.62,84.45 107.62,87.81 106.95,88.49 106.95,90.77 106.25,91.47 106.25,92.33 103.66,94.93 103.43,94.93 103.01,95.35 102.11,95.35 101.78,95.68 101.78,97.85 98.23,101.4 98.23,102.94 97.06,104.11 97.06,105.51 96.88,105.69 96.45,105.69 v1(96.04,105.27)
  BOTTOM w0.076: UC1.G71 99.79,70.27 99.57,70.27 99.46,70.38 97.79,70.38
  BOTTOM w0.102: JXDP1.30 96.14,105.17 v1(96.04,105.27) ; v1(96.84,81.11) v2(95.91,80.18) 95.86,80.13 95.86,76.96 96.61,76.22 96.61,71.57 97.79,70.38
CFG14: length 64.8
  IN2 w0.122: v1(109,84.25) 109,84.04 108.73,83.78 103.73,83.78 101.31,81.36 99.62,81.36 99.49,81.48 v1(98.25,81.48)
  IN4 w0.089: v1(99.34,105.25) 101.16,103.43 101.16,101.94 102.87,100.22 102.87,96.09 103.61,95.36 103.83,95.36 106.68,92.51 106.68,91.65 107.38,90.95 107.38,88.67 108.06,87.99 108.06,85.19 v1(109,84.25)
  BOTTOM w0.076: UC1.H69 101.33,69.7 100.86,69.7 100.76,69.66 100.5,69.66 100.38,69.7 100.2,69.7 100.15,69.68 100.12,69.66 99.72,69.66 99.34,70.04 99.06,70.04 98.92,69.9
  BOTTOM w0.102: 98.92,69.9 97.21,69.9 95.91,71.2 v2(95.91,74.66) 95.91,76.27 94.47,77.71 94.47,81.08 95.17,81.78 96.75,81.78 97.46,81.07 97.85,81.07 v1(98.25,81.48) ; v1(99.34,105.25) 98.88,105.71 95.7,105.71 95.14,105.15 JXDP1.34
CFG15: length 61.2
  IN2 w0.122: v1(108.41,83.03) 108.41,83.08 107.96,83.53 103.84,83.53 101.41,81.11 98.46,81.11 98.4,81.05 97.41,81.05 97.18,80.82 v1(97.18,80.62)
  IN4 w0.089: v1(108.41,83.03) 108.96,83.57 109.21,83.57 109.62,83.98 109.62,84.64 109.1,85.16 109.1,87.56 107.81,88.85 107.81,91.13 107.12,91.83 107.12,92.69 104.23,95.57 104.23,96.27 103.31,97.2 103.31,100.4 102.49,101.22 102.49,103.29 v1(100.53,105.25)
  BOTTOM w0.076: UC1.G70 100.47,70.1 100.32,70.25 99.91,70.44 99.64,70.44 99.53,70.55 98.08,70.55 97.1,71.54
  BOTTOM w0.102: JXDP1.36 94.64,104.99 95.58,105.94 99.84,105.94 v1(100.53,105.25) ; 97.1,71.54 97.1,76.05 96.24,76.91 v2(96.24,78.36) 96.24,79.84 97.02,80.62 v1(97.18,80.62)
CFG16: length 65.6
  TOP w0.102: v1(104.53,70.58) 104.21,70.58 103.86,70.93 103.86,71.45 103.36,71.95 102.72,71.95 95.67,79 v2(95.67,79.24) v1(95.67,81.11)
  IN2 w0.122: v1(113.54,82.85) 111.92,82.85 110.09,84.68 108.51,84.68 108.01,85.18 102.83,85.18 100.31,82.65 97.11,82.65 95.67,81.22 v1(95.67,81.11)
  IN4 w0.089: v1(113.54,82.85) 113.54,85.59 112.39,86.75 111.75,86.75 109.07,89.43 109.07,90.79 107.76,92.1 107.76,93.43 107.75,93.44 107.75,94.03 107.04,94.74 106,94.74 104.88,95.85 104.88,97.99 104.55,98.32 104.55,99.56 103.95,100.16 103.95,101.53 103.14,102.35 103.14,104.15 v1(102.04,105.25)
  BOTTOM w0.076: UC1.E63 104.56,70.58 v1(104.53,70.58)
  BOTTOM w0.102: v1(102.04,105.25) 102.14,105.15 JXDP1.6
CFG17: length 68.6
  TOP w0.102: v1(95.09,81.11) v2(95.09,80.54) 95.09,79.26 100.28,74.07 100.28,73.22 103.51,70 v1(104.37,70)
  IN2 w0.122: v1(95.09,81.11) 95.09,81.26 96.73,82.9 100.2,82.9 102.73,85.43 108.11,85.43 108.61,84.93 110.19,84.93 111.63,83.49 114.43,83.49 v1(114.66,83.26)
  IN4 w0.089: v1(102.64,105.25) 103.36,104.53 103.36,102.44 104.19,101.6 104.19,100.23 104.77,99.65 104.77,98.41 105.1,98.08 105.1,95.94 106.09,94.95 107.56,94.95 108.56,93.95 108.56,93.38 108.08,92.9 108.08,92.09 109.29,90.88 109.29,89.52 111.84,86.97 112.48,86.97 114.66,84.78 v1(114.66,83.26)
  BOTTOM w0.076: v1(104.37,70) 104.63,70 UC1.F63
  BOTTOM w0.102: JXDP1.4 v1(102.64,105.25)
CFG18: length 55.9
  TOP w0.102: v2(99.45,78.89) 99.45,79.11 v1(99.12,79.45)
  IN2 w0.122: v1(109.58,83.03) 109.58,82.83 108.97,82.22 107.88,82.22 107.19,81.53 103.64,81.53 101.97,79.86 99.53,79.86 v1(99.12,79.45)
  IN4 w0.089: v1(97.54,105.25) 98.17,105.89 101.17,105.89 101.63,105.43 101.63,105.05 102.93,103.75 102.93,102.26 103.74,101.44 103.74,98.83 104.67,97.9 104.67,95.76 105.91,94.52 106.95,94.52 107.54,93.94 107.54,93.35 107.55,93.34 107.55,92.01 108.86,90.7 108.86,88.42 109.53,87.74 109.53,85.34 110.05,84.82 110.05,83.5 v1(109.58,83.03)
  BOTTOM w0.076: UC1.E66 102.71,71.22 102.59,71.22 102.54,71.25 102.27,71.41 102.13,71.54 102.1,71.61 102.1,71.77 102.13,71.93 102.12,72.07 102.12,72.17 102.09,72.2 102.09,72.88 101.44,73.53 101.44,73.72 101.19,73.98 100.83,73.98 99.57,75.23 99.57,77.85
  BOTTOM w0.102: v1(97.54,105.25) 97.64,105.15 JXDP1.24 ; 99.57,77.85 99.57,78.65 99.12,79.11 v1(99.12,79.45)
CFG19: length 58.8
  TOP w0.102: v2(97.42,78.65) 97.42,79.02 97.79,79.4 v1(97.79,79.5)
  IN2 w0.122: v1(109,83.03) 109,82.83 108.64,82.46 107.77,82.46 107.41,82.1 106.27,82.1 105.97,82.39 105.52,82.39 104.9,81.78 103.53,81.78 101.87,80.11 99.16,80.11 98.74,79.69 97.98,79.69 v1(97.79,79.5)
  IN4 w0.089: v1(109,83.03) 109.83,83.87 109.83,84.73 109.31,85.25 109.31,87.65 108.64,88.33 108.64,90.61 107.33,91.92 107.33,93.25 107.32,93.26 107.32,93.85 106.86,94.31 105.82,94.31 104.45,95.67 104.45,96.36 103.52,97.29 103.52,100.49 102.71,101.31 102.71,103.67 101.41,104.96 101.41,105.34 101.08,105.67 98.56,105.67 v1(98.14,105.25)
  BOTTOM w0.076: UC1.F66 102.94,70.49 102.01,71.41 101.93,71.57 101.93,71.79 101.96,71.92 101.96,72.08 101.69,72.34 101.52,72.34 100.91,72.95 100.91,73.15 100.72,73.33 100.3,73.33 100.27,73.37 100.13,73.51 99.13,73.51 98.8,73.83
  BOTTOM w0.102: JXDP1.22 v1(98.14,105.25) ; 98.8,73.83 98.8,77.82 99.19,78.22 99.19,78.71 98.91,78.99 98.3,78.99 v1(97.79,79.5)
CFG_RCOMP: length 16.9
  TOP w0.381: RC114.1 96.27,65.07 97.26,66.06 v1(97.26,66.16)
  IN4 w0.381: v1(105.36,70.66) 105.54,70.66 105.92,70.28 105.92,69.74 104.91,68.73 98.66,68.73 97.26,67.33 v1(97.26,66.16)
  BOTTOM w0.254: v1(105.36,70.66) 105.37,70.66 105.64,71.22 105.74,71.32 106.15,71.32 106.54,70.93 UC1.E60
CLK_DDC2_CRT: length 7.6
  TOP w0.102: v1(286.95,49.58) 286.71,49.81 UV6.15
  BOTTOM w0.102: v1(286.95,49.58) 287.08,49.45 288.35,49.45 RV120.1 289.54,48.26 291.86,48.26 JCRT1.15
CLK_ITPXDP_N: length 14.4
  TOP w0.094: RC297.1 115.89,81.52 115.89,81.19 115.92,81.16 115.92,80.56 115.89,80.52 115.89,80.14 116.03,79.99 v4(116.03,79.4) 116.03,78.28 116.9,77.42 116.9,76.5 115.14,74.75 115.14,73.94 116.54,72.54 116.54,71.01 116.29,70.76 115.8,70.76 v1(115.61,70.57)
  BOTTOM w0.102: v1(115.61,70.57) 115.9,70.28 UC1.F43
CLK_ITPXDP_N_R: length 48.4
  TOP w0.094: RC297.2 115.85,83.21 v4(115.85,83.96) 115.85,84.79 114.03,86.61 114.03,90.47 109.3,95.2 107.78,95.2 106.76,96.22 106.76,96.73 106.56,96.93 106.3,96.93 v1(106.1,97.13)
  IN4 w0.089: v1(106.1,97.13) 106.36,97.13 106.44,97.04 106.44,96.78 106.51,96.72 106.63,96.72 106.86,96.95 106.86,100.83 104.19,103.5 104.19,104.49 101.6,107.08 99.07,107.08 97.34,108.81 94.04,108.81 93.48,108.25 93.48,105.86 93.13,105.52 92.84,105.52 v1(92.65,105.33)
  BOTTOM w0.094: JXDP1.42 93.14,104.92 93.22,105 93.37,105 93.45,105.09 93.45,105.41 93.23,105.63 92.95,105.63 v1(92.65,105.33)
CLK_ITPXDP_P: length 14.4
  TOP w0.094: RC298.1 115.7,81.45 v4(115.7,80.86) 115.7,80.06 115.85,79.92 115.85,79.73 115.81,79.7 115.81,79.1 115.85,79.06 115.85,78.2 116.71,77.34 116.71,76.58 114.96,74.83 114.96,73.86 116.35,72.46 116.35,71.09 116.21,70.95 116.07,70.95 116.01,71.01 116.01,71.22 115.9,71.32 115.72,71.32 v1(115.59,71.19)
  BOTTOM w0.102: UC1.E43 115.84,70.93 v1(115.59,71.19)
CLK_ITPXDP_P_R: length 48.5
  TOP w0.094: v1(106.1,96.55) 106.3,96.74 106.48,96.74 106.58,96.65 106.58,96.14 107.7,95.02 109.22,95.02 113.85,90.39 113.85,86.53 115.67,84.71 115.67,84.28 115.63,84.25 115.63,83.66 115.67,83.63 115.67,83.21 RC298.2
  IN4 w0.089: v1(106.1,96.55) 106.11,96.54 106.71,96.54 107.04,96.87 107.04,100.91 104.37,103.58 104.37,104.57 101.68,107.26 99.14,107.26 97.41,108.99 93.96,108.99 93.3,108.33 93.3,105.94 93.06,105.7 92.87,105.7 v1(92.65,105.92)
  BOTTOM w0.094: v1(92.65,105.92) 92.75,105.82 93.3,105.82 93.64,105.48 JXDP1.40
CLK_PCIE_N0: length 209.8
  IN4 w0.089: v1(254.84,38.49) 255.04,38.29 255.04,38.1 254.92,37.97 249.54,37.97 248.85,37.29 247.07,37.29 246.59,37.77 244.91,37.77 244.1,36.95 240.24,36.95 239.27,37.92 237.41,37.92 235.77,39.56 235.77,41.83 235.18,42.42 227.28,42.42 226.98,42.11 220.4,42.11 219.87,41.58 218.04,41.58 216.21,43.41 212.42,43.41 211.08,44.75 209.63,44.75 208.69,45.69 206.35,45.69 205.06,46.99 203.43,46.99 200.84,49.58 199.47,49.58 195.31,53.74 195.31,54.12 189.08,60.34 189.08,64 183.33,69.76 181.42,69.76 178.34,72.84 176.17,72.84 174.85,74.16 174.85,78.04 171.94,80.94 171.94,81.73 170.64,83.04 170.64,83.28 170.12,83.79 169.88,83.79 168.25,85.42 160.33,85.42 157.49,88.26 142.35,88.26 140.2,90.41 135.69,90.41 135.68,90.42 135.45,90.42 135.12,90.42 135.11,90.41 128.45,90.41 124.36,86.32 117.84,86.32 115.95,84.44 115.95,79.94 115.57,79.56 v1(115.57,76.58)
  BOTTOM w0.076: 115.71,75.8 115.71,75.43 115.92,75.21 115.92,74.15 115.7,73.92 115.7,73.51 115.73,73.42 115.73,73.22 115.7,73.13 115.7,72.89 115.83,72.41 115.83,72.29 115.91,72.03 UC1.D42
  BOTTOM w0.094: v1(254.84,38.49) 255.04,38.29 255.04,36.9 255.83,36.11 255.83,34.78 257.47,33.14 258.71,33.14 258.96,33.39 260.59,33.39 261.41,32.57 262.68,32.57 262.83,32.57 263.2,32.2 265.52,32.2 266.34,32.2 266.47,32.33 268,32.33 268.36,32.69 269.42,32.69 270.72,31.39 270.97,31.39 271.91,30.45 271.91,30 271.75,29.85 JNGFF2.53 ; v1(115.57,76.58) 115.71,76.44 115.71,76.43 115.71,75.8
CLK_PCIE_N1: length 152.5
  IN4 w0.089: v1(117.5,78.49) 117.5,84.9 118.16,85.57 124.88,85.57 127.65,88.34 139.48,88.34 140.34,87.47 154.77,87.47 157.57,84.67 157.57,84.34 158.25,83.66 168.04,83.66 169.28,82.42 170.06,82.42 171.17,81.3 171.17,80.64 174.07,77.75 174.07,73.83 175.89,72.02 178.1,72.02 188.27,61.84 188.27,60.07 194.21,54.12 194.21,53.13 198.1,49.25 198.1,49.22 198.56,48.76 200.39,48.76 203.25,45.89 204.78,45.89 205.85,44.82 207.43,44.82 208.37,43.89 209.88,43.89 212.96,40.81 213.64,40.81 213.82,40.99 v1(213.82,41.56)
  BOTTOM w0.076: UC1.B42 116.38,73.49 116.42,73.71 116.42,75.14 116.67,75.38 116.67,75.72 116.67,75.73 116.67,75.78 116.69,75.79 116.69,75.8
  BOTTOM w0.094: v1(117.5,78.49) 117.5,77.1 116.69,76.28 116.69,75.8 ; v1(213.82,41.56) 213.82,40.84 213.09,40.11 213.09,38.21 211.92,37.04 211.92,33.34 212.25,33.02 212.25,30.31 211.46,29.52 211.46,26.67 211.29,26.5 JNGFF1.49
CLK_PCIE_N3: length 255.4
  IN2 w0.122: v1(268.14,8.48) 267.97,8.65 267.97,9.21 266.46,10.73 262.59,10.73 262.25,10.38 260.84,10.38 260.57,10.65 260.57,12.16 259.57,13.17 259.57,16.99 262.3,19.72 262.3,22.06 263.15,22.91 263.15,25.27 265.23,27.35 265.23,27.96 265.46,28.19 266.58,28.19 267.54,29.15 270.86,29.15 272.24,30.53 273.49,30.53 274.06,31.1 275.07,31.1 275.94,31.96 275.94,39.25 274.97,40.22 274.97,40.95 275.21,41.19 275.5,41.19 v1(275.68,41.02)
  IN4 w0.089: v1(118.8,74.44) 118.8,74.57 119.2,74.98 120.07,74.98 122.27,77.18 122.27,77.97 124.74,80.43 124.74,81.93 129.95,87.14 136.35,87.14 137.22,86.28 142.7,86.28 143.11,86.68 149.08,86.68 149.71,86.05 153.88,86.05 157,82.92 161.94,82.92 162.49,82.38 163.95,82.38 165.31,81.02 169.91,81.02 173.49,77.44 173.49,73.01 175.64,70.86 178.44,70.86 186.9,62.4 186.9,59.78 192.61,54.07 192.61,51.41 196.53,47.49 199.07,47.49 201.96,44.6 204.17,44.6 205.21,43.55 206.74,43.55 208.39,41.9 210.17,41.9 212.51,39.55 214.06,39.55 214.73,40.23 220.25,40.23 221.21,41.19 227.77,41.19 228.22,41.65 233.28,41.65 234.7,40.23 234.7,39.16 234.13,38.59 234.13,37.69 234.5,37.31 235.33,37.31 235.55,37.53 236.17,37.53 236.95,36.75 238.82,36.75 239.93,35.63 249.69,35.63 250.42,36.37 255.07,36.37 256.54,37.84 257.69,37.84 258.37,38.53 260.07,38.53 260.3,38.3 261.83,38.3 264.06,40.53 268.38,40.53 268.91,41.07 272.85,41.07 272.95,40.97 274.88,40.97 275.14,41.22 275.48,41.22 v1(275.68,41.02)
  BOTTOM w0.076: v1(118.8,74.44) 118.59,74.65 118,74.65 117.69,74.34 117.69,73.5 117.67,73.48 117.65,73.42 117.65,73.23 117.65,73.22 117.69,73.13 117.69,72.89 117.68,72.86 117.55,72.44 117.55,72.36 117.54,72.28 117.54,72.24 UC1.D40
  BOTTOM w0.094: JNGFF3.53 268.1,9.1 267.93,8.93 267.93,8.69 v1(268.14,8.48)
CLK_PCIE_N4: length 204.2
  TOP w0.094: UL1.45 257.64,69.7 257.58,69.65 257.58,69.33 257.44,69.19 257.44,68.83 257.52,68.75 v1(257.99,68.75)
  IN1 w0.089: v1(257.99,68.75) 256.59,68.75 252.86,65.02 252.86,59.43 248.72,55.29 247.45,55.29 245.42,53.26 244.73,53.26 243.97,52.5 241.36,52.5 240.39,51.54 240.01,51.54 238.46,49.98 237.24,49.98 234.55,47.29 233.23,47.29 232.08,46.15 231.07,46.15 230.43,45.51 228.65,45.51 227.84,44.7 225.59,44.7 225.23,44.34 223.54,44.34 223.12,43.92 218.35,43.92 217.72,44.55 212.3,44.55 211.92,44.93 210.75,44.93 210.42,45.26 209,45.26 208.38,45.87 205.69,45.87 203.89,47.67 202.75,47.67 200.68,49.74 199.72,49.74 188.79,60.68 188.79,62.74 187.22,64.32 187.22,68.62 178.77,77.06 178.77,85.47 176.43,87.8 164.91,87.8 161.76,90.95 160.79,90.95 159.49,92.25 155.76,92.25 154.43,93.57 143.11,93.57 141.97,92.43 139.26,92.43 138.12,93.57 128.89,93.57 127.49,92.18 123.58,92.18 122.76,91.36 v1(122.76,90.6)
  BOTTOM w0.076: 117.99,75.8 117.98,75.79 117.98,75.77 117.59,75.38 116.96,74.75 116.96,73.52 117.25,73.22 UC1.B40
  BOTTOM w0.094: v1(122.76,90.6) 122.76,89.61 119.32,86.17 118.69,86.17 117.34,84.82 117.34,79.53 118.45,78.43 118.45,76.25 117.99,75.8
CLK_PCIE_N5: length 62.4
  IN1 w0.089: v1(118.28,71.13) 118.05,71.13 117.96,71.04 117.96,70.81 117.84,70.68 117.28,70.68 116.77,71.19 116.77,71.75 115.77,72.74 110.31,72.74 109.02,74.04 109.02,74.32 108.23,75.11 108.23,75.74 105.69,78.28 105.69,80.31 104.7,81.3 104.7,83.1 103.2,84.6 103.2,88.95 100.68,91.47 93.55,91.47 92.98,92.05 89.16,92.05 88.47,91.36 85.78,91.36 83.39,88.97 79.79,88.97 78.77,87.96 v1(78.77,86.99)
  BOTTOM w0.076: UC1.E40 118.08,70.93 v1(118.28,71.13)
  BOTTOM w0.094: UR1.6 78.77,91.11 78.87,91 78.87,90.23 78.97,90.14 78.97,87.19 v1(78.77,86.99)
CLK_PCIE_P0: length 209.8
  IN4 w0.089: v1(116.15,76.61) 115.75,77.01 115.75,79.48 116.13,79.87 116.13,84.36 117.91,86.14 124.44,86.14 128.53,90.23 135.19,90.23 135.2,90.24 135.27,90.24 135.27,90.24 135.53,90.24 135.6,90.24 135.61,90.23 140.13,90.23 142.27,88.08 157.41,88.08 160.25,85.24 168.18,85.24 169.81,83.61 170.05,83.61 170.46,83.2 170.46,82.96 171.76,81.66 171.76,80.87 174.66,77.96 174.66,74.09 176.09,72.66 178.26,72.66 181.35,69.58 183.26,69.58 188.9,63.93 188.9,60.27 195.13,54.05 195.13,53.67 199.4,49.4 200.77,49.4 203.36,46.81 204.98,46.81 206.28,45.51 208.61,45.51 209.56,44.57 211,44.57 212.35,43.23 216.13,43.23 217.96,41.4 219.94,41.4 220.48,41.93 227.05,41.93 227.36,42.24 235.11,42.24 235.59,41.76 235.59,39.48 237.33,37.74 239.2,37.74 240.16,36.77 244.17,36.77 244.99,37.59 246.51,37.59 246.99,37.11 248.92,37.11 249.61,37.79 254.99,37.79 255.22,38.02 255.22,38.29 v1(255.43,38.49)
  BOTTOM w0.076: UC1.C42 116.27,72.35 116.36,72.44 116.36,72.54 116.23,72.67 115.98,72.67 115.92,72.72 115.86,72.91 115.86,73.08 115.92,73.28 115.92,73.43 115.86,73.54 115.86,73.85 116.09,74.08 116.09,75.31 115.9,75.5 115.9,75.8
  BOTTOM w0.094: JNGFF2.55 272.25,29.85 272.09,30 272.09,30.53 271.05,31.58 270.79,31.58 269.5,32.87 268.28,32.87 267.92,32.52 266.4,32.52 266.27,32.38 266.26,32.38 265.59,32.38 265.59,32.38 263.28,32.38 262.91,32.75 262.68,32.75 261.49,32.75 260.67,33.57 258.88,33.57 258.63,33.33 257.55,33.33 256.02,34.86 256.02,36.18 255.23,36.98 255.23,38.29 v1(255.43,38.49) ; 115.9,75.8 115.9,76.34 115.97,76.42 115.97,76.43 v1(116.15,76.61)
CLK_PCIE_P1: length 152.5
  IN4 w0.089: v1(116.86,78.49) 116.92,78.49 117.32,78.88 117.32,84.98 118.09,85.75 124.81,85.75 127.58,88.52 139.55,88.52 140.41,87.65 154.84,87.65 157.75,84.74 157.75,84.41 158.32,83.84 168.12,83.84 169.36,82.6 170.13,82.6 171.36,81.38 171.36,80.72 174.25,77.82 174.25,73.91 175.96,72.2 178.17,72.2 188.45,61.92 188.45,60.14 194.39,54.2 194.39,53.21 198.28,49.32 198.28,49.3 198.63,48.94 200.46,48.94 203.33,46.07 204.85,46.07 205.92,45 207.51,45 208.45,44.07 209.96,44.07 213.04,40.99 213.57,40.99 213.64,41.07 213.64,41.15 213.24,41.55 213.22,41.55 v1(213.21,41.56)
  BOTTOM w0.076: 116.5,75.8 116.5,75.45 116.26,75.21 116.26,73.73 116.18,73.65 UC1.A42
  BOTTOM w0.094: 116.5,75.8 116.5,76.36 117.31,77.17 117.31,78.06 116.89,78.49 v1(116.86,78.49) ; JNGFF1.47 210.8,27 211.11,26.69 211.22,26.69 211.27,26.74 211.27,29.6 212.06,30.39 212.06,32.94 211.74,33.26 211.74,37.11 212.91,38.28 212.91,40.19 213.64,40.92 213.64,41.13 213.21,41.55 v1(213.21,41.56)
CLK_PCIE_P3: length 255.3
  IN2 w0.122: v1(275.68,41.6) 275.5,41.42 275.11,41.42 274.74,41.05 274.74,40.12 275.71,39.16 275.71,32.06 274.98,31.33 273.96,31.33 273.39,30.76 272.14,30.76 270.77,29.38 267.44,29.38 266.48,28.42 265.36,28.42 265,28.06 265,27.45 262.92,25.37 262.92,23.01 262.07,22.15 262.07,19.82 259.34,17.08 259.34,13.07 260.34,12.06 260.34,10.55 260.74,10.15 262.34,10.15 262.69,10.5 266.36,10.5 267.74,9.12 267.74,8.67 v1(267.56,8.48)
  IN4 w0.089: v1(275.68,41.6) 275.48,41.4 275.06,41.4 274.81,41.15 273.03,41.15 272.93,41.25 268.84,41.25 268.31,40.71 263.99,40.71 261.75,38.48 260.38,38.48 260.15,38.71 258.3,38.71 257.61,38.02 256.47,38.02 254.99,36.55 250.35,36.55 249.61,35.81 240.01,35.81 238.89,36.93 237.03,36.93 236.24,37.72 235.48,37.72 235.25,37.49 234.58,37.49 234.31,37.76 234.31,38.52 234.88,39.09 234.88,40.31 233.35,41.83 228.15,41.83 227.69,41.38 221.14,41.38 220.17,40.41 214.66,40.41 213.99,39.73 212.59,39.73 210.24,42.08 208.46,42.08 206.81,43.73 205.29,43.73 204.24,44.78 202.03,44.78 199.14,47.67 196.6,47.67 192.79,51.48 192.79,54.15 187.08,59.86 187.08,62.47 178.52,71.04 175.72,71.04 173.67,73.09 173.67,77.52 169.98,81.2 165.38,81.2 164.02,82.56 162.56,82.56 162.02,83.1 157.08,83.1 153.95,86.23 149.79,86.23 149.15,86.86 143.03,86.86 142.63,86.46 137.29,86.46 136.43,87.32 129.88,87.32 124.56,82 124.56,80.51 122.09,78.04 122.09,77.25 119.99,75.16 v1(118.8,75.16)
  BOTTOM w0.076: v1(118.8,75.16) 118.85,75.1 118.85,74.92 118.75,74.82 117.93,74.82 117.52,74.4 117.52,73.54 117.46,73.43 117.46,73.28 117.52,73.08 117.52,72.91 117.44,72.66 117.4,72.59 117.4,72.49 UC1.C40
  BOTTOM w0.094: JNGFF3.55 267.6,9.1 267.74,8.96 267.74,8.67 v1(267.56,8.48)
CLK_PCIE_P4: length 204.2
  TOP w0.094: UL1.44 257.24,69.75 257.4,69.6 257.4,69.41 257.26,69.26 257.26,68.75 257.44,68.56 257.59,68.56 v1(257.99,68.17)
  IN1 w0.089: v1(123.34,90.6) 122.94,91.01 122.94,91.28 123.65,91.99 127.56,91.99 128.96,93.39 138.04,93.39 139.18,92.25 142.04,92.25 143.19,93.39 154.36,93.39 155.68,92.07 159.42,92.07 160.71,90.77 161.69,90.77 164.84,87.62 176.36,87.62 178.59,85.39 178.59,76.98 187.03,68.54 187.03,64.25 188.61,62.67 188.61,60.6 199.65,49.56 200.6,49.56 202.67,47.49 203.82,47.49 205.62,45.69 208.31,45.69 208.92,45.08 210.34,45.08 210.67,44.75 211.84,44.75 212.22,44.37 217.65,44.37 218.28,43.73 223.19,43.73 223.61,44.16 225.3,44.16 225.67,44.52 227.92,44.52 228.73,45.33 230.51,45.33 231.14,45.97 232.16,45.97 233.3,47.11 234.62,47.11 237.32,49.8 238.53,49.8 240.09,51.35 240.47,51.35 241.43,52.32 244.05,52.32 244.81,53.08 245.49,53.08 247.52,55.11 248.8,55.11 253.04,59.35 253.04,64.94 256.66,68.57 257.59,68.57 v1(257.99,68.17)
  BOTTOM w0.076: 118.13,75.67 118.11,75.65 118.1,75.65 117.66,75.22 117.12,74.68 117.12,73.78 UC1.A40
  BOTTOM w0.094: v1(123.34,90.6) 122.94,90.2 122.94,89.53 119.39,85.98 118.77,85.98 117.53,84.75 117.53,79.61 118.63,78.5 118.63,76.17 118.13,75.67
CLK_PCIE_P5: length 62.5
  IN1 w0.089: v1(118.27,70.5) 117.2,70.5 116.59,71.12 116.59,71.68 115.7,72.56 110.24,72.56 108.84,73.96 108.84,74.24 108.05,75.03 108.05,75.67 105.51,78.2 105.51,80.24 104.52,81.23 104.52,83.03 103.02,84.53 103.02,88.87 100.6,91.29 93.48,91.29 92.9,91.87 89.24,91.87 88.55,91.18 85.86,91.18 83.47,88.79 79.86,88.79 78.95,87.88 78.95,87.49 79.04,87.4 79.47,87.4 79.56,87.31 79.56,87.19 v1(79.35,86.99)
  BOTTOM w0.076: UC1.E38 118.31,70.5 v1(118.27,70.5)
  BOTTOM w0.094: v1(79.35,86.99) 79.15,87.19 79.15,90.21 79.06,90.31 79.06,91 79.17,91.11 UR1.5
CLK_TP_SIO_I2C_DAT: length 116.7
  TOP w0.076: UE1.E10 266.84,50.51 v1(266.87,50.51)
  TOP w0.102: RZ23.2 203.69,26.51 RZ346.2 CZ81.1 203.51,28.27 203.51,29 203.69,29.18 204.73,29.18 205.29,28.62 205.29,28.47 206.99,26.77 206.99,24.42 207.7,23.71 v2(207.7,22.97) 207.7,21.76 210.75,18.72 211.13,18.72 211.66,18.18 211.66,17.52 211.27,17.13 v1(211.27,16.56)
  IN2 w0.076: 268.76,50.51 268.33,50.95 267.3,50.95 v1(266.87,50.51)
  IN2 w0.122: v1(211.27,16.56) 212.32,17.61 217.19,17.61 218.29,18.71 220.97,18.71 221.2,18.47 223.13,18.47 224.57,17.03 229.4,17.03 230.13,16.3 230.81,16.3 234.06,13.05 238.73,13.05 239.45,13.76 240.26,13.76 241.27,14.77 241.74,14.77 243.05,16.09 243.96,16.09 244.78,16.91 246.99,16.91 247.73,16.18 249.7,16.18 250.42,15.46 250.92,15.46 251.75,16.29 253.26,16.29 255.93,18.96 256.59,18.96 257.29,19.67 257.29,22.82 258.7,24.23 258.7,28.27 260.31,29.87 260.51,29.87 261.8,31.16 262.95,31.16 263.33,31.54 265.59,31.54 267.11,33.07 267.11,33.8 268.72,35.42 269.1,35.42 270.41,36.73 270.41,40.66 270.69,40.94 270.69,42.42 270.81,42.54 270.81,43.53 271.33,44.06 271.33,45.51 271.07,45.77 271.07,48.43 268.99,50.51 268.76,50.51
CLK_TP_SIO_R: length 7.9
  TOP w0.102: JKBTP1.14 205.65,19.09 v2(204.78,19.96) 204.17,20.57 CZ89.1 204.65,21.31 204.65,22.5 RZ19.2 204.63,23.44 204.63,24.66 RZ23.1
CLKDET#: length 16.1
  TOP w0.102: v1(142.67,46.09) 142.67,45.98 143.13,45.51 144.52,45.51 145.42,44.61 145.42,43.39 T258.1
  BOTTOM w0.076: 139.32,49.94 138.63,49.94 138.55,50.02 137.34,50.02 136.46,50.9 136.46,51.73 136.56,51.83 136.56,51.88 136.56,52.12 136.56,52.14 136.27,52.44 UC1.AY8
  BOTTOM w0.102: 139.32,49.94 140.23,49.94 142.09,48.08 142.09,48.08 142.09,46.67 v1(142.67,46.09)
CLKREQ_PCIE#0: length 168.6
  TOP w0.102: v1(138.36,45.89) 138.42,45.83 RC373.2 ; v1(187.95,26.08) v2(187.95,26.59)
  IN1 w0.089: v1(138.36,45.89) 138.36,45.2 143.83,39.72 150.69,39.72 159.82,30.59 183.43,30.59 v1(187.95,26.08) 189.72,24.3 196.78,24.3 197.45,23.63 199.31,23.63 201.19,21.75 201.99,21.75 203.71,20.03 203.71,19.67 206.07,17.31 206.07,15.01 206.67,14.41 213.51,14.41 214.59,15.5 216.65,15.5 220.36,19.2 225.14,19.2 225.26,19.33 232.12,19.33 232.24,19.45 237.44,19.45 237.56,19.33 239.08,19.33 239.15,19.41 243.83,19.41 243.98,19.56 246.07,19.56 246.78,20.27 247.58,20.27 247.84,20.52 250.47,20.52 251.43,21.47 252.62,21.47 254.18,23.04 254.18,24.66 253.93,24.91 253.93,26.08 254.21,26.36 255.27,26.36 256.28,27.36 257.12,27.36 257.54,26.94 262.67,26.94 263.53,27.8 263.53,28.06 264.75,29.28 266.51,29.28 266.78,29.55 271.62,29.55 271.94,29.87 271.94,30.48 272.44,30.98 273.18,30.98 273.79,31.59 v1(273.79,32.97)
  BOTTOM w0.102: v1(273.79,32.97) 273.44,33.32 273.44,33.78 272.24,34.97 271.96,34.97 271.5,35.43 JNGFF2.52
CLKREQ_PCIE#0_R: length 14.7
  TOP w0.102: v1(135.66,54.97) 136.09,54.54 136.09,54.24 136.38,53.95 v2(136.38,53.47) 136.38,52.58 137.09,51.86 137.09,47.67 138.05,46.71 138.05,46.22 137.58,45.75 137.58,43.98 137.95,43.61 RC373.1 138.42,42.77 RC189.1
  BOTTOM w0.076: v1(135.66,54.97) 135.65,54.97 135.2,55.41 UC1.AR10
CLKREQ_PCIE#1: length 101.1
  TOP w0.102: v1(205.68,14.27) 207.57,14.27 207.93,14.63 207.93,15.77 209.19,17.03 210.42,17.03 210.75,16.7 210.75,16.3 210.91,16.14 212.28,16.14 212.45,16.3 212.45,16.86 212.65,17.06 v2(212.65,17.95) 212.65,18.5 213.01,18.86 213.01,21 v1(212.91,21.1) ; RC374.2 140.2,41.41 v1(139.95,41.16)
  IN1 w0.089: v1(139.95,41.16) 141.61,41.16 143.48,39.29 150.47,39.29 159.62,30.15 182.94,30.15 189.18,23.9 196.6,23.9 197.31,23.19 199.2,23.19 201.02,21.36 201.82,21.36 202.65,20.54 202.65,19.52 203.98,18.18 204.64,18.18 205.67,17.16 205.67,14.28 v1(205.68,14.27)
  BOTTOM w0.102: v1(212.91,21.1) 212.87,21.14 212.87,25 212.32,25.55 210.88,25.55 210.82,25.5 JNGFF1.53
CLKREQ_PCIE#1_R: length 14.8
  TOP w0.102: v1(136.57,54.39) 136.57,54.16 136.71,54.02 136.71,52.64 137.99,51.35 137.99,48.95 137.84,48.8 137.84,47.43 138.89,46.38 138.89,44.46 v2(139.51,43.84) 140.2,43.15 RC374.1 RC47.1
  BOTTOM w0.076: v1(136.57,54.39) 136.65,54.39 137.03,54.76 UC1.AT7
CLKREQ_PCIE#2_R: length 15.6
  TOP w0.102: RC50.1 135.98,40.6 135.98,52.03 v2(135.88,52.14) 135.69,52.32 135.69,53.13 135.18,53.64 135.18,53.87 v1(135.69,54.38)
  BOTTOM w0.076: v1(135.69,54.38) 135.7,54.38 UC1.AT8
CLKREQ_PCIE#3: length 150.7
  TOP w0.102: RC376.2 138.68,36.43 139.18,36.43 139.25,36.37 v1(139.25,36.39)
  IN1 w0.089: v1(259.64,5.63) 259.01,5 253.04,5 252.37,5.67 250.04,5.67 247.59,8.12 245.6,8.12 244.4,9.32 244.4,9.64 242.2,11.84 239.74,11.84 238.78,12.8 237.93,12.8 237.19,13.53 233.76,13.53 232.75,14.54 230.94,14.54 230.59,14.89 225.86,14.89 225.06,14.09 223.3,14.09 222.34,13.14 221.47,13.14 219.34,11.01 213.88,11.01 213.49,11.4 204.22,11.4 201.29,14.33 201.29,16.32 200.46,17.14 198.08,17.14 197.57,17.65 197.57,18.72 196.99,19.3 196.63,19.3 195.98,19.95 194.72,19.95 194.33,20.34 192.89,20.34 192.7,20.53 186.84,20.53 181.79,25.57 160.22,25.57 151.33,34.46 141.16,34.46 139.25,36.37 v1(139.25,36.39)
  BOTTOM w0.102: JNGFF3.52 268.35,3.66 267.64,4.36 263.8,4.36 262.3,5.86 259.87,5.86 v1(259.64,5.63)
CLKREQ_PCIE#3_R: length 22.1
  TOP w0.102: v2(139.37,37.26) 139.32,37.31 138.15,37.31 138.11,37.26 RC376.1 137.77,37.26 137.31,37.73 RC59.1 137.21,38.22 136.54,38.22 135.41,39.35 135.41,39.87 135.75,40.22 135.75,50.7 135.43,51.03 135.43,53.01 135.12,53.32 134.64,53.32 134.33,53.64 134.33,53.98 v1(134.75,54.4)
  BOTTOM w0.076: v1(134.75,54.4) 135.14,54.79 UC1.AT10
CLKREQ_PCIE#4: length 216.4
  TOP w0.102: RC377.2 136.45,41.07 v1(136.69,40.83) ; UL1.48 258.84,70.06 v2(259.84,69.07) 260.41,68.5 RL4.1 259.8,67.1 259.8,63.79 260.35,63.23 v1(260.35,62.59)
  IN1 w0.089: v1(136.69,40.83) 137.53,40.83 142.9,35.46 151.75,35.46 160.06,27.15 182.25,27.15 187.39,22.01 194.25,22.01 195.29,20.97 196.48,20.97 197.15,20.3 197.8,20.3 198.94,19.16 200.28,19.16 201.67,17.77 201.67,17.43 202.29,16.81 202.29,15.36 204.42,13.23 204.43,13.23 205.05,12.61 214.26,12.61 214.98,13.33 218.02,13.33 218.41,13.72 218.9,13.72 219.13,13.96 219.13,14.5 221.41,16.78 229.04,16.78 229.16,16.66 230.34,16.66 230.81,17.13 232.88,17.13 233.28,17.53 239.34,17.53 240.16,16.7 240.82,16.7 241.03,16.91 242.04,16.91 242.6,16.35 244.1,16.35 244.82,17.07 249.82,17.07 250.52,17.78 252.68,17.78 253.93,19.02 253.93,19.66 254.77,20.49 255.83,20.49 256.46,21.13 256.46,23.44 258.62,25.61 264.34,25.61 265.56,26.83 266.54,26.83 267.04,27.33 267.04,27.83 267.43,28.22 272.48,28.22 274.98,30.72 v1(274.98,32.05)
  IN3 w0.122: v1(260.35,62.59) 260.82,62.12 262.58,62.12 263.05,61.65 270.68,61.65 272.6,59.74 272.6,57.83 274.76,55.67 274.76,47.67 274.5,47.42 274.5,43.93 273.67,43.09 273.67,41.53 273.87,41.33 273.87,33.77 274.45,33.19 274.45,32.64 274.98,32.1 v1(274.98,32.05)
CLKREQ_PCIE#4_R: length 15.1
  TOP w0.102: v1(135.69,53.77) 135.99,53.47 135.99,52.59 136.45,52.13 v2(136.45,43.62) RC377.1 136.83,42.72 137.31,42.24 RC51.1
  BOTTOM w0.076: UC1.AU8 136.06,54.14 v1(135.69,53.77)
CLKREQ_PCIE#5: length 180.2
  TOP w0.102: v1(141.09,39.58) 141.22,39.71 RC378.2
  IN2 w0.122: v1(141.09,39.58) 141.25,39.42 161.74,39.42 166.93,44.61 166.93,46.06 168.49,47.62 168.49,48.16 167.68,48.97 167.68,52.73 166.88,53.53 166.88,57.19 165.16,58.92 165.16,60.37 165.23,60.45 165.23,65.89 163.59,67.52 163.59,68.67 162.73,69.52 160.4,69.52 159.45,70.48 159.45,71.35 159.07,71.73 159.07,78.65 153.82,83.9 153.82,88.05 151.43,90.44 151.18,90.44 149.23,92.38 140.47,92.38 138.33,94.51 131.84,94.51 131.54,94.21 121.36,94.21 118.93,96.64 118.93,99.67 116.65,101.94 109.49,101.94 108.98,102.45 105.24,102.45 104.07,103.63 100.56,103.63 100.33,103.39 88.29,103.39 87.48,102.59 85.52,102.59 84.05,104.05 v1(81.51,104.05)
  IN4 w0.089: v1(81.51,104.05) 81.51,102.77 80.3,101.56 79.57,101.56 78.59,100.58 78.59,95.7 81.82,92.48 v1(81.82,91.86)
  BOTTOM w0.102: UR1.2 80.37,91.26 80.65,90.98 81.18,90.98 81.82,91.61 v1(81.82,91.86)
CLKREQ_PCIE#5_R: length 17.2
  TOP w0.102: v1(137.48,54.29) 137.83,54.29 138.06,54.06 138.06,52.9 138.4,52.56 138.4,48.75 138.29,48.65 138.29,47.35 139.18,46.47 139.18,45.23 141.22,43.2 v2(141.22,42.6) RC378.1 140.94,41.51 140,40.58 RC190.1
  BOTTOM w0.076: v1(137.48,54.29) 137.33,54.14 UC1.AU7
CLKRUN#: length 20.8
  TOP w0.102: RC27.1 140.08,39.14 142.24,39.14 v2(142.36,39.25) 142.36,39.98 141.72,40.61 141.72,43.01 139.48,45.26 139.48,46.38 v1(139.69,46.59)
  BOTTOM w0.076: 138.3,48.55 138.03,48.81 136.71,48.81 134.74,50.78 134.74,52.51 134.43,52.83 UC1.AW11
  BOTTOM w0.102: 138.3,48.55 138.75,48.55 139.83,47.47 139.83,46.73 v1(139.69,46.59)
CMOUT: length 24.8
  TOP w0.102: v1(33.41,50.14) 33.41,50.66 v2(33.13,50.93) 32.25,51.81 PR951.1 ; PQ1210.3 PQ1210.2 44.02,57.96 v1(44.38,57.6)
  IN1 w0.089: v1(36.22,48.37) 35.82,48.37 34.05,50.14 v1(33.41,50.14)
  IN2 w0.122: v1(44.38,57.6) 44.02,57.6 43.36,56.94 39.17,56.94 38.32,56.09 38.32,54.56 36.47,52.7 34.87,52.7 33.41,51.24 v1(33.41,50.14)
  BOTTOM w0.102: v1(36.22,48.37) 36.07,48.37 PQ1216.2
COMP_GT: length 4.7
  TOP w0.203: PU602.16 71.96,67.21 v1(72.06,67.1)
  TOP w0.254: PR639.2 73.11,66.51 72.52,67.1 v1(72.06,67.1)
  BOTTOM w0.254: v1(72.06,67.1) 71.92,67.25 PC636.2
COMP_ISL9538: length 2.9
  TOP w0.203: PR934.1 30.92,47.54 v1(31.04,47.42) 31.04,46.89 PC943.1
  BOTTOM w0.203: PU901.28 30.85,47.04 31.04,47.23 v1(31.04,47.42)
COMP_VSA: length 3.7
  TOP w0.203: PU602.24 68.97,70.79 v1(69.09,70.91) 69.07,70.94 69.07,71.51 PR630.1
  BOTTOM w0.102: v1(69.09,70.91) 69.09,71.22 v2(68.91,71.4)
  BOTTOM w0.254: PC628.1 69.02,70.38 69.02,70.84 v1(69.09,70.91)
CONTACTLESS_DET#: length 167.8
  TOP w0.102: v1(151.36,62.14) 151.11,62.14 150.63,62.62 v2(150.63,62.86) 150.56,62.92 150.56,65.58 RC278.1
  IN4 w0.089: v1(253.72,10.94) 254.11,11.32 254.11,12.89 254.35,13.13 255.65,13.13 256.46,13.93 256.46,14.47 256.93,14.95 256.93,16.75 256.36,17.32 255.45,17.32 254.09,15.96 251.67,15.96 250.96,15.26 250.38,15.26 249.49,16.15 247.89,16.15 246.55,17.48 241.35,17.48 240.69,16.82 240.25,16.82 237.74,19.34 232.48,19.34 231.41,20.41 222.97,20.41 220.97,22.41 217.67,22.41 216.85,23.23 213.56,23.23 213.18,22.85 208.5,22.85 207.6,21.94 202.87,21.94 200.6,24.22 200.6,25.74 199.44,26.9 199.44,28.44 195.1,32.79 193.8,32.79 188.14,38.44 188.14,38.88 181.54,45.48 181.54,51.68 178.85,54.37 173.89,54.37 172.93,53.41 172.93,52.93 172.72,52.73 172.36,52.73 170.95,54.14 167.17,54.14 165.84,55.47 164.17,55.47 163.63,56 163.63,56.46 162.51,57.58 162.04,57.58 161.45,58.18 160.36,58.18 159.76,58.78 156.36,58.78 154.96,60.18 154.96,61.15 154.46,61.65 153.99,61.65 153.09,62.55 151.78,62.55 v1(151.36,62.14) 151.16,62.14 151.06,62.24 145.32,62.24 144.97,61.88 143.54,61.88 142.9,62.52 140.56,62.52 139.05,64.03 135.85,64.03 v1(134.8,62.98)
  BOTTOM w0.076: UC1.W11 134.62,63.4 134.8,63.22 v1(134.8,62.98)
  BOTTOM w0.102: DZ8.2 253.43,10.65 v1(253.72,10.94)
CONTACTLESS_DET#_R: length 1.8
  TOP w0.102: JUSH1.4 v1(252.6,8.84)
  BOTTOM w0.102: DZ8.1 253.02,9.25 v1(252.6,8.84)
CORE_VID0: length 90.9
  IN1 w0.152: v1(163.73,96.72) 163.58,96.87 163.58,97.06 163.77,97.25 165.21,97.25 165.71,97.76 165.71,101.55 165.46,101.8 165.46,104.38 166.17,105.09 170.1,105.09 172.21,102.97 173.85,102.97 174.18,103.3 174.18,104 v1(174.32,104.14)
  IN2 w0.152: v1(134.72,56.39) 135.03,56.39 135.18,56.54 135.18,57.07 135.42,57.31 136.06,57.31 136.34,57.59 137.33,57.59 141.06,53.86 144.02,53.86 146.96,56.79 147.86,56.79 148.67,57.6 148.67,58.85 147.3,60.22 147.3,61.01 147.81,61.51 149.05,61.51 149.83,62.29 149.83,63.6 149.74,63.69 149.74,65.94 151.81,68 152.65,68 153.38,68.74 153.38,69.43 153.19,69.62 153.19,77.24 153.44,77.49 v1(153.64,77.49)
  BOTTOM w0.152: v1(163.73,96.72) 163.63,96.62 163.63,90.98 162.23,89.58 158.7,89.58 155.68,86.56 155.68,82.09 156.47,81.3 156.47,79.75 155.55,78.84 154.79,78.84 153.64,77.68 v1(153.64,77.49) ; v1(174.32,104.14) 174.76,103.7 PR408.1 ; v1(134.72,56.39) 134.63,56.39 UC1.AN11
