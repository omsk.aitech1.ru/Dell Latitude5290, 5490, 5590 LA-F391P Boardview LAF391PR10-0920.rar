# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IMVP_VR_ON_EC: length 25.2
  TOP w0.076: 264.56,42.85 264.56,43.54 264.3,43.79 264.3,43.9 264.02,44.18 UE1.N7
  TOP w0.102: RPE10.2 265.23,37.26 v1(264.72,37.77) 264.08,38.41 v2(264.08,39.24) 264.14,39.3 264.14,41.73 264.56,42.15 264.56,42.85 ; RE304.2 275.37,34.11 275.37,35.43 274.54,36.26 UE3.1 274.09,36.47 274.36,36.75 274.36,37.35 v1(274.63,37.61)
  IN4 w0.089: v1(264.72,37.77) 265.61,36.88 269.85,36.88 270.77,37.79 271.94,37.79 272.14,37.59 272.8,37.59 273.36,38.15 274.1,38.15 v1(274.63,37.61)
INT_SPK_L+:
  vias: v2(265.1,24.65)
INT_SPK_R+:
  vias: v2(262.37,24.9)
INT_SPK_R-:
  vias: v2(263.71,24.66)
INT_SPKR_L+: length 11.6
  IN4 w1.016: 256.47,21.76 257.36,20.87 258.63,20.87 259.26,21.51 259.26,22.53 260.34,23.6 260.34,24.09 261.56,25.31 263.34,25.31 264.47,26.44
  vias: v1(254.89,21.84) v1(255.48,21.84) v1(265.65,27.76) v1(266.23,27.76) v3(265.6,28.32)
INT_SPKR_L-: length 13.4
  TOP w0.127: v1(254.82,19.73) 254.75,19.73 254.44,20.05 254.44,20.13 v3(254.42,20.13)
  IN4 w1.016: 253.98,21.05 253.98,22.53 254.74,23.29 257.29,23.29 260.6,26.59 262.95,26.59 263.45,27.1
  vias: v1(255.3,20.09) v1(263.96,27.78) v1(264.55,27.78)
INT_SPKR_R+: length 11.9
  IN4 w1.016: 252.65,19.72 252.65,20.74 252.4,20.98 252.4,23.49 253.75,24.84 255.6,24.84 255.99,25.22 256.87,25.22 258.88,27.22
  vias: v1(252.56,18.33) v1(252.9,19.01) v1(259.77,27.73) v1(260.41,27.73) v3(260.09,28.2)
INT_SPKR_R-: length 18.7
  IN4 w1.016: 249.99,19.58 249.43,20.14 249.43,21.51 250.02,22.09 250.02,23.49 253.37,26.84 255.07,26.84 257.1,28.88 261.09,28.88 261.47,28.49 261.93,28.49
  vias: v1(250.96,19.17) v1(250.96,18.59) v1(262.36,27.78) v1(262.95,27.78) v3(262.18,28.37)
INTRUDER#: length 13.4
  TOP w0.102: v1(131.07,55.62) 131.07,55.05 v2(131.09,55.04) 132.07,54.06 132.07,52.81 132.39,52.49 132.39,51.74 133.96,50.16 133.96,49.65 133.53,49.22 133.53,48.4 134.21,47.73 RC69.1
  BOTTOM w0.076: v1(131.07,55.62) 131.35,55.85 131.35,55.88 131.53,56.03 131.54,56.04 UC1.AP16
IR_CAM_DET#: length 133.2
  TOP w0.102: RC345.1 143.31,79.24 v1(142.88,78.81) 143.24,78.45 v2(143.24,78.25) 143.24,76.55 143.01,76.32 143.01,72.85 144.28,71.58 144.28,70.56 143.83,70.12 143.83,69.68 143.58,69.42 138.65,69.42 v1(138.52,69.29)
  IN2 w0.122: v1(142.88,78.81) 142.57,79.12 142.57,81.55 142.06,82.06 138.84,82.06 138.73,81.96 135.06,81.96 131.96,85.06 128.78,85.06 127.97,85.88 113.94,85.88 112.83,86.99 111.69,86.99 110.64,88.04 109.41,88.04 108.75,88.7 101.79,88.7 100.23,90.26 94.53,90.26 93,91.79 92.02,91.79 89.74,94.08 87.84,94.08 85,91.24 80.74,91.24 75.19,96.79 74.04,96.79 73.79,96.54 71.82,96.54 70.64,95.36 70.64,93.31 68.61,91.28 55.63,91.28 v1(55.43,91.49)
  BOTTOM w0.076: v1(138.52,69.29) 138.21,68.98 UC1.H5
  BOTTOM w0.102: JIR1.1 47.05,96.44 47.48,96.01 48.59,96.01 49.47,95.13 50.5,95.13 50.64,95.27 53.55,95.27 55.43,93.39 v1(55.43,91.49)
ISEN1_IA: length 39.6
  TOP w0.102: v2(74.87,72.84) 75.33,72.39 v1(75.33,72.31)
  TOP w0.203: v1(70.82,63.92) 70.71,63.81 70.02,63.81 69.77,64.06 PU602.9
  TOP w0.254: PR634.1 PC635.2 88.49,80.18 89.08,79.59 v1(89.08,79.41)
  IN2 w0.254: v1(76.38,64.37) 75.24,65.52 75.24,70.79 75.46,71 75.46,72.18 v1(75.33,72.31)
  IN4 w0.254: v1(75.33,72.31) 76.28,72.31 79.12,75.15 86.66,75.15 87.18,75.68 87.18,78.64 87.72,79.18 88.85,79.18 v1(89.08,79.41) ; v1(76.38,64.37) 76.01,64.74 74.82,64.74 73.82,63.74 71,63.74 v1(70.82,63.92)
  BOTTOM w0.254: PR668.2 77.27,64.37 v1(76.38,64.37) ; v1(89.08,79.41) 88.4,79.41 PR670.1
ISEN2_IA: length 40.9
  TOP w0.102: v1(86.71,79.75) v2(86.71,78.19)
  TOP w0.203: PU602.10 70.68,64.53 v1(70.69,64.55)
  TOP w0.254: v1(86.71,79.75) 87.13,80.17 PC638.2 87.55,80.18 PR615.1
  IN4 w0.254: v1(70.69,64.55) 70.41,64.83 70.41,66.37 70.81,66.76 70.81,69.95 71.99,71.13 72.37,71.13 74.06,72.82 74.63,72.82 76.28,74.47 77.8,74.47 78.87,75.53 86.5,75.53 86.8,75.83 86.8,79.66 v1(86.71,79.75)
  BOTTOM w0.254: v1(70.69,64.55) 70.87,64.55 71.3,64.12 74.43,64.12 74.69,63.86 76.51,63.86 PR677.2 ; v1(86.71,79.75) 87.81,79.75 PR675.2
ISH_I2C2_SCL: length 164.2
  TOP w0.102: RZ76.1 267.64,34.97 v1(267.64,35.3)
  IN1 w0.076: 140.11,64.32 140.1,64.32 139.48,63.69
  IN1 w0.089: v1(267.64,35.3) 267.62,35.33 267.62,35.9 267.25,36.27 262.41,36.27 261.9,35.76 261.38,35.76 260.98,36.17 258.16,36.17 258.03,36.3 256.65,36.3 254.78,34.43 252.75,34.43 251.31,35.86 246.44,35.86 246.08,36.22 240.19,36.22 238.89,34.92 236.77,34.92 236.31,34.46 234.29,34.46 232.92,33.09 227.79,33.09 226.6,34.29 217.3,34.29 216.83,33.81 215.02,33.81 214.35,33.14 213.7,33.14 211.43,35.42 209.01,35.42 207.08,37.35 205,37.35 204.04,38.3 201.76,38.3 199.74,40.32 197.45,40.32 194.95,42.82 192.97,42.82 191.72,44.08 190.78,44.08 178.59,56.26 178.59,56.97 176.1,59.46 176.1,60.98 175.42,61.67 175.42,62.54 174.62,63.34 174.62,64.22 170.84,68 165.24,68 164.19,69.06 162.29,69.06 161.93,68.69 161.93,68.34 v1(161.87,68.27) 161.87,68.24 161.46,67.83 161.14,67.83 158.17,70.81 156.26,70.81 152.85,67.4 151.57,67.4 151.31,67.13 144.22,67.13 142.97,65.88 142.97,64.96 142.33,64.32 140.11,64.32 ; v1(134.39,62) 134.79,62.4 135.15,62.4 135.35,62.61 138.39,62.61 139.48,63.69
  BOTTOM w0.076: UC1.AD12 133.97,61.58 v1(134.39,62)
  BOTTOM w0.102: v1(161.87,68.27) 161.87,69.17 RC362.1
ISH_I2C2_SCL_R: length 3.5
  TOP w0.102: v1(268.66,33.75) RZ76.2
  BOTTOM w0.102: JNGFF2.40 268.5,35.46 268.51,35.45 268.51,34.88 268.71,34.68 268.71,33.8 v1(268.66,33.75)
ISH_I2C2_SDA: length 162.5
  TOP w0.102: RZ77.1 267.16,34.77 267.16,35.2 v1(267.06,35.3)
  IN1 w0.076: 140.12,63.85 139.89,63.85 139.53,63.49
  IN1 w0.089: v1(135,62) 135.43,62.43 138.46,62.43 139.53,63.49 ; 140.12,63.85 142.52,63.85 143.44,64.77 143.44,65.68 144.42,66.66 151.5,66.66 151.77,66.93 153.04,66.93 156.45,70.34 157.97,70.34 160.95,67.36 161.66,67.36 162.45,68.16 v1(162.45,68.27) 162.4,68.32 162.4,68.5 162.49,68.59 163.99,68.59 165.05,67.53 170.64,67.53 174.15,64.03 174.15,63.14 174.95,62.34 174.95,61.47 175.63,60.79 175.63,59.26 178.12,56.77 178.12,56.07 190.58,43.61 191.52,43.61 192.78,42.35 194.75,42.35 197.26,39.85 199.54,39.85 201.56,37.83 203.85,37.83 204.8,36.88 206.88,36.88 208.81,34.95 211.23,34.95 213.5,32.67 214.55,32.67 215.22,33.34 217.02,33.34 217.5,33.82 226.4,33.82 227.6,32.62 233.11,32.62 234.48,33.99 236.51,33.99 236.97,34.45 239.09,34.45 240.38,35.75 245.88,35.75 246.24,35.39 251.12,35.39 252.55,33.96 254.97,33.96 256.47,35.45 258.12,35.45 258.36,35.7 260.78,35.7 261.19,35.29 262.1,35.29 262.61,35.8 267.06,35.8 267.15,35.71 267.15,35.39 v1(267.06,35.3)
  BOTTOM w0.076: UC1.AD11 134.62,61.42 135,61.8 v1(135,62)
  BOTTOM w0.102: RC363.1 162.45,69.1 v1(162.45,68.27)
ISH_I2C2_SDA_R: length 5.5
  TOP w0.102: v1(269.24,33.75) 269.24,33.65 268.81,33.22 267.59,33.22 RZ77.2
  BOTTOM w0.102: v1(269.24,33.75) 269.19,33.8 269.19,34.88 268.99,35.08 268.99,35.45 269,35.46 JNGFF2.42
ISH_UART0_CTS#: length 111.4
  TOP w0.102: v1(209.41,36.22) 207.85,34.65 v2(207.85,33.88) 207.85,31.8 208.71,30.94 209.98,30.94 211.91,29.01 211.91,27.81 212.32,27.4 212.32,26.67 212.6,26.39 215.22,26.39 215.42,26.18 215.42,25.7 216.06,25.07 216.06,24.33 216.26,24.13 RZ80.1
  IN1 w0.089: v1(209.41,36.22) 209.41,36.8 208.72,37.49 207.62,37.49 207.29,37.82 205.29,37.82 204.32,38.78 201.95,38.78 199.94,40.79 197.67,40.79 195.15,43.3 193.4,43.3 192.08,44.62 190.91,44.62 179.07,56.46 179.07,57.15 178.07,58.15 178.07,59.27 177,60.33 177,61.64 176.76,61.88 176.76,62.38 175.3,63.84 175.3,64.51 171.12,68.69 165.53,68.69 164.47,69.74 160.27,69.74 158.19,71.83 156.2,71.83 154.75,70.38 152.48,70.38 151.59,69.49 147.91,69.49 147.5,69.08 145.04,69.08 144.63,68.68 141.51,68.68 138.17,65.34 v1(138.17,65.2)
  BOTTOM w0.076: UC1.U4 138.29,65.2 v1(138.17,65.2)
ISH_UART0_CTS#_R: length 3.5
  TOP w0.102: v1(216.18,23.67) 217.3,23.67 RZ80.2
  BOTTOM w0.102: v1(216.18,23.67) 216.6,23.25 JNGFF1.62
ISH_UART0_RTS#: length 101.6
  TOP w0.102: v1(215.6,23.67) 216.06,23.21 RZ81.1
  IN4 w0.089: v1(215.6,23.67) 215.2,24.07 214.08,24.07 213.08,23.07 206.54,23.07 203.51,26.1 202.96,26.1 201.03,28.03 200.83,28.03 194.75,34.11 194.75,34.72 193.91,35.56 192.66,35.56 189.22,38.99 189.22,39.35 183.3,45.27 183.3,46.95 182.69,47.56 182.69,52.05 179.3,55.45 176.7,55.45 176.11,56.03 175.28,56.03 174.84,55.6 171.36,55.6 171.15,55.81 167.09,55.81 164.01,58.89 162.27,58.89 161.9,59.26 160.81,59.26 159.45,60.61 157.73,60.61 156.37,61.97 155.74,61.97 154.93,62.77 154.4,62.77 153.49,63.69 153.02,63.69 150.65,66.06 146.21,66.06 145.34,65.2 144.5,65.2 v1(144.01,65.68)
  BOTTOM w0.076: v1(144.01,65.68) 143.58,65.25 v2(143.26,65.25) 143.21,65.21 139.68,65.21 139.31,64.84 UC1.U3
ISH_UART0_RTS#_R: length 8.9
  TOP w0.102: RZ81.2 217.71,23.21 217.26,22.75 215.93,22.75 v1(215.02,23.67)
  BOTTOM w0.102: v2(220.05,23.06) 219.74,22.75 JNGFF1.64 216.72,22.75 216.2,23.26 215.42,23.26 v1(215.02,23.67)
ISH_UART0_RXD: length 97.2
  TOP w0.102: v1(192.97,35.15) 192.97,35.35 193.27,35.66 v2(194.34,35.66) 196.96,35.66 200.16,32.46 207.52,32.46 207.62,32.36 207.62,31.69 208.61,30.71 209.88,30.71 211.68,28.91 211.68,27.71 212.09,27.29 212.09,26.51 212.45,26.16 213.59,26.16 RZ78.1
  IN4 w0.089: v1(141.1,64.84) 141.74,65.47 143.37,65.47 143.86,64.98 145.43,64.98 146.3,65.85 150.56,65.85 152.93,63.47 153.4,63.47 154.31,62.56 154.84,62.56 155.65,61.75 156.26,61.75 157.61,60.4 159.36,60.4 160.72,59.04 161.81,59.04 162.18,58.67 163.92,58.67 167,55.59 171.06,55.59 171.27,55.38 174.93,55.38 175.37,55.82 176.02,55.82 176.61,55.23 179.21,55.23 182.48,51.96 182.48,47.47 183.09,46.86 183.09,45.18 189,39.26 189,38.88 192.79,35.09 192.91,35.09 v1(192.97,35.15)
  BOTTOM w0.076: UC1.U1 v1(141.1,64.84)
ISH_UART0_RXD_R: length 4
  TOP w0.102: RZ78.2 215.64,25.03 v1(215.64,24.9) v2(215.64,24.32)
  BOTTOM w0.102: v1(215.64,24.9) 216.08,24.46 216.68,24.46 216.89,24.25 JNGFF1.58
ISH_UART0_TXD: length 95.9
  TOP w0.102: v1(193.63,35.15) 193.65,35.12 197.16,35.12 200.05,32.23 206.63,32.23 v2(206.94,31.92) 208.38,30.48 209.78,30.48 211.45,28.81 211.45,27.62 211.84,27.22 211.84,26.01 RZ79.1
  IN4 w0.089: v1(193.63,35.15) 193.63,34.97 193.17,34.51 193.04,34.51 188.79,38.76 188.79,39.17 182.2,45.76 182.2,51.93 179.12,55.02 174.95,55.02 174.81,55.16 171.18,55.16 170.97,55.37 166.88,55.37 163.8,58.46 162.09,58.46 161.72,58.83 160.63,58.83 160.03,59.43 157.4,59.43 156.92,59.91 156.92,60.18 156.39,60.7 156.13,60.7 155.67,61.16 155.67,61.43 154.77,62.33 154.23,62.33 153.33,63.23 152.87,63.23 150.47,65.63 146.39,65.63 145.52,64.77 143.77,64.77 143.28,65.25 142.11,65.25 v1(141.69,64.84)
  BOTTOM w0.076: v1(141.69,64.84) 141.32,64.47 140.87,64.47 140.38,64.61 140.08,64.7 UC1.U2
ISH_UART0_TXD_R: length 5.5
  TOP w0.102: RZ79.2 213.86,24.9 v1(215.03,24.9)
  BOTTOM w0.102: JNGFF1.60 216.79,23.75 216.39,24.15 215.78,24.15 v1(215.03,24.9)
ISPSCL: length 2.7
  TOP w0.102: UV6.30 v2(280.39,48.22) 280,48.22 279.84,48.05 RV106.1
ISPSDA: length 6
  TOP w0.102: RV107.1 276.8,48.2 276.98,48.37 278.19,48.37 v2(278.78,48.97) 280.7,48.97 281.05,48.61 UV6.29
ISUMN_GT: length 35.3
  TOP w0.254: PR640.2 73.91,70.23 PR644.2 74.26,69.88 74.85,69.88 PC645.1 74.87,70.52 v2(75.07,70.72) 75.07,70.9 74.15,71.83 73.79,71.83 v1(73.74,71.78)
  IN2 w0.254: v1(73.74,71.78) 73.74,70.85 74.48,70.11 74.48,67.86 74.13,67.51 74.13,64.41 71.87,62.15 71.87,59.8 73.33,58.34 73.33,54.2 v1(73.09,53.96)
  BOTTOM w0.254: PH605.2 73.05,54 v1(73.09,53.96) 74.07,53.96 74.91,53.12 74.91,51.94 75.16,51.69 77.11,51.69 PL612.2 ; v1(73.74,71.78) 73.74,71.34 73.97,71.12 PR656.2 73.95,70.68 PC646.2 72.22,70.68 PC642.2
ISUMN_IA: length 46.8
  TOP w0.254: v1(72.38,61.51) 72.43,61.47 72.43,60.85 v2(72.46,60.81) 72.11,60.46 71.55,60.46 PR632.1 70.6,61.39 PR633.2 ; v1(89.07,78.41) 88.43,79.04 PC635.1 88.42,79.26 PC638.1
  IN2 w0.254: v1(72.38,61.51) 72.38,62.12 74.86,64.6 74.86,71.65 v1(74.93,71.73)
  IN4 w0.254: v1(89.07,78.41) 87.82,78.41 87.56,78.16 87.56,75.52 86.81,74.77 79.28,74.77 76.34,71.83 75.04,71.83 v1(74.93,71.73)
  BOTTOM w0.254: PH602.2 85.83,75.03 86.92,76.12 86.92,76.37 88.18,77.63 PR673.2 88.93,78.28 v1(89.07,78.41) ; PR666.2 76.98,62.15 75.56,62.15 PC641.1 74.63,62.22 PR638.1 73.75,62.21 PC624.2 72.89,62.22 PC626.2 72.71,62.22 72.38,61.9 v1(72.38,61.51)
ISUMN_VSA: length 57
  TOP w0.254: v1(64.06,72.5) 64.06,72.63 63.56,73.14 63.56,73.71 63.81,73.96 65.65,73.96 66.04,73.56 PR641.2 65.62,72.9 PR636.2 66.5,72.47 PC633.2
  IN2 w0.254: v1(96.19,83.36) 96.07,83.36 95.56,83.87 88.77,83.87 87.97,84.67 84.19,84.67 84.06,84.79 73.7,84.79 73.52,84.62 73.52,82.88 71.74,81.1 69.66,81.1 69.02,80.46 69.02,76.72 64.79,72.5 v1(64.06,72.5)
  BOTTOM w0.102: PC644.1 v2(65.95,74.32)
  BOTTOM w0.254: PC644.1 65.95,72.51 PR643.1 65.63,72.49 PC637.2 64.89,71.87 64.25,72.5 v1(64.06,72.5) ; v1(96.19,83.36) 96.07,83.23 96.07,82.58 PH604.2 96.83,83.12 96.83,85.26 97.31,85.75 PL614.2
ISUMP_GT: length 27.5
  TOP w0.102: v1(72.12,68.69) v2(72.12,69.27)
  TOP w0.203: v1(72.12,68.69) 71.84,68.41 PU602.19
  TOP w0.254: v1(73.75,53.17) 73.8,53.22 PR661.2 PR657.1
  IN2 w0.254: v1(73.75,53.17) 73.46,53.46 72.89,53.46 72.61,53.74 72.61,54.16 72.95,54.5 72.95,58.18 71.48,59.66 71.48,62.3 73.71,64.53 73.71,67.76 74.1,68.14 74.1,68.75 73.69,69.16 v1(73.61,69.16)
  BOTTOM w0.254: v1(73.61,69.16) 73.97,69.52 PR656.1 73.11,69.78 PC646.1 72.22,69.77 PC642.1 ; v1(72.12,68.69) 72.22,68.79 PC642.1 ; PC642.1 71.91,70.08 PR653.2
ISUMP_IA: length 52.1
  TOP w0.203: PR633.1 69.77,62.67 v1(69.45,62.98) 69.4,63.04 69.4,63.52 68.97,63.95 PU602.7
  TOP w0.254: v1(86.66,83.04) 86.16,82.55 86.16,75.48 85.83,75.15 PR628.1
  IN2 w0.254: v1(77.84,65.07) 77.37,65.54 77.37,76.26 80.84,79.73 81.51,79.73 84.93,83.15 86.55,83.15 v1(86.66,83.04)
  IN4 w0.254: v1(69.45,62.98) 69.49,62.98 69.66,62.81 70.84,62.81 71.07,63.04 74.86,63.04 75.58,63.76 77.32,63.76 77.84,64.29 v1(77.84,65.07)
  BOTTOM w0.254: v1(86.66,83.04) 86.96,82.74 PR674.1 ; v1(69.45,62.98) 69.57,62.86 70.13,62.86 70.31,63.04 71.74,63.04 71.79,63.09 v2(71.79,63.09) 72.83,63.09 PC626.1 73.74,63.14 PC624.1 ; PR658.2 76.69,65.12 76.89,65.32 PR667.1 77.59,65.32 v1(77.84,65.07)
ISUMP_VSA: length 9.6
  TOP w0.203: PU602.27 67.77,70.18 67.31,70.63 v1(67.31,70.91) 67.16,70.91 66.51,71.56 PC633.1
  BOTTOM w0.102: v2(61.21,70.66) 61.4,70.85 PR624.2
  BOTTOM w0.254: v1(67.31,70.91) 67.26,70.96 66.3,70.96 65.93,71.33 PR643.2 65.81,71.58 65.07,70.84 PC637.1 PR642.1 63.42,70.84 63.4,70.85 PR624.2
ITP_PMODE: length 80.1
  TOP w0.102: v1(94.75,102.26) 95.2,101.8 99.5,101.8 101.81,104.11 105.2,104.11 105.68,104.59 106.18,104.59 107.45,103.32 107.6,103.32 108.13,102.79 108.13,100.05 109.1,99.08 109.1,97.61 111.15,95.55 112.32,95.55 113.59,94.28 v1(113.59,94.03) ; RC115.1 116.45,86.39 v1(116.7,86.39) 118.23,84.87 v2(120.82,84.87) 124.22,84.87 125.86,83.23 128.66,83.23 129.49,84.07 133.45,84.07 134.93,82.59 134.93,82.59 137.86,79.66 139.31,79.66 139.76,79.22 139.76,78.67 v1(139.27,78.18)
  BOTTOM w0.076: 137.77,75.8 135.94,73.96 135.84,73.96 135.66,73.78 135.66,71.38 UC1.E8
  BOTTOM w0.102: 137.77,75.8 138.18,76.2 138.68,76.2 138.96,76.47 138.96,76.91 139.27,77.22 v1(139.27,78.18) ; v1(94.75,102.26) 94.34,101.85 92.46,101.85 92.14,102.17 JXDP1.46 ; v1(113.59,94.03) 115.75,94.03 116.7,93.08 v1(116.7,86.39)
JCRT-11: length 2.8
  BOTTOM w0.102: T87.1 292.46,56.82 JCRT1.11
JDIMM1_EVENT#: length 3.3
  TOP w0.102: v2(82.85,10.03) 82.94,10.03 v1(83.25,10.34) 83.53,10.62 RD14.1
  BOTTOM w0.102: v1(83.25,10.34) 83.43,10.52 JDIMM1.134
JDIMM2_EVENT#: length 3.6
  TOP w0.102: v2(166.91,11.36) RD27.1 165.88,11.18 v1(165.19,10.49)
  BOTTOM w0.102: JDIMM2.134 165.43,10.73 v1(165.19,10.49)
JTAG_CLK: length 65.6
  TOP w0.076: v1(264.41,52.13) 264.81,52.53 UE1.C8
  TOP w0.102: v1(236.26,16.02) 236.26,14.72 236.04,14.49 RPE7.3
  IN2 w0.122: v1(236.26,16.02) 236.26,16.2 235.83,16.63 235.83,18.23 238.21,20.61 238.21,20.91 239.42,22.11 240.64,22.11 241.32,22.8 243.93,22.8 244.2,22.53 245.41,22.53 246.04,21.9 246.96,21.9 247.3,22.24 247.3,22.36 247.95,23.01 248.16,23.01 248.47,23.31 248.47,23.59 248.87,24 250.3,24 251.03,24.74 251.03,31.64 253.46,34.08 253.46,35.19 253.99,35.72 253.99,35.9 255.53,37.44 255.71,37.44 257.51,39.24 258.68,39.24 259.27,38.65 261.26,38.65 262.06,39.44 262.06,41.27 261.88,41.45 261.88,43.35 261.6,43.63 261.6,44.27 261.85,44.52 262.23,44.52 263.5,45.79 263.94,45.79 264.24,46.1 264.24,46.8 263.69,47.34 263.69,48.07 263.21,48.55 263.21,49.13 263.4,49.32 263.88,49.32 264.01,49.45 264.01,51.74 v1(264.41,52.13)
  BOTTOM w0.102: JDEG1.4 235.91,13.77 236.26,14.12 v1(236.26,16.02)
JTAG_RST#: length 11.9
  TOP w0.102: v3(275.52,55.03) 275.05,54.56 274.63,54.56 274.01,53.94 RE63.1 273.99,53.83 JTAG1.1 274.01,52.75 RE65.1 CE30.1 273.41,50.83 272.9,50.33 272.9,49.22 272.64,48.95 270.5,48.95 270.12,49.33 UE1.G13
JTAG_TDI: length 66.3
  TOP w0.102: v1(237.82,15.62) 237.82,14.91 237.04,14.12 RPE7.1 237.04,13.52 237.96,12.59 237.96,11.79 v3(238.41,11.35) ; UE1.E9 265.62,50.91 v1(265.24,50.53)
  IN2 w0.122: v1(237.82,15.62) 237.94,15.62 238.79,16.47 238.79,18.43 240.03,19.67 250.03,19.67 250.62,20.25 252.29,20.25 253.13,21.09 253.13,22.24 254.16,23.26 254.16,25.62 254.97,26.44 254.97,27.61 255.43,28.07 255.43,30.38 259.28,34.22 260.67,34.22 260.91,34.46 260.91,34.97 261.24,35.3 262.21,35.3 263.78,36.88 264.44,36.88 265.23,37.66 265.23,38.53 265.89,39.19 265.89,40.93 266.55,41.59 266.55,43.89 267.26,44.6 267.26,45.13 267.47,45.34 267.47,47.6 267.24,47.82 267.24,48.4 267.1,48.54 265.82,48.54 265.61,48.74 265.61,50.15 v1(265.24,50.53)
  BOTTOM w0.102: JDEG1.2 236.91,13.56 237.32,13.97 237.32,15.11 v1(237.82,15.62)
JTAG_TDO: length 64.7
  TOP w0.102: RPE7.4 235.54,14.17 235.13,14.58 v2(235.13,15.16) 235.13,15.26 235.65,15.78 v1(235.65,16.05) ; UE1.F6 v1(262.86,50.5)
  IN2 w0.076: v1(262.86,50.5) 262.75,50.5 262.44,50.19 262.44,47.93 262.64,47.72 263,47.72
  IN2 w0.122: 263,47.72 263.15,47.72 263.33,47.54 263.33,47.35 263.99,46.69 263.99,46.25 263.81,46.07 263.02,46.07 262.06,45.11 261.17,45.11 260.86,44.8 260.86,42.9 261.32,42.44 261.32,41.27 261.52,41.07 261.52,40.51 261.09,40.07 260.74,40.07 260.41,39.75 257.48,39.75 257.1,40.13 256.47,40.13 256.06,39.72 256.06,38.53 255.48,37.94 255.32,37.94 253.75,36.37 252.79,36.37 251.63,35.22 251.63,33.25 250.07,31.68 250.07,28.98 249,27.91 249,25.47 248.55,25.02 248.55,24.53 247.88,23.85 247.68,23.85 247.34,23.51 247.34,23.39 246.8,22.86 246.12,22.86 245.94,23.03 244.41,23.03 244.07,23.37 243.23,23.37 242.94,23.66 239.78,23.66 238.21,22.1 238.21,21.62 237.71,21.12 237.71,20.82 235.13,18.24 235.13,16.57 v1(235.65,16.05)
  BOTTOM w0.102: JDEG1.5 235.42,14.02 235.65,14.26 v1(235.65,16.05)
JTAG_TMS: length 67.6
  TOP w0.076: UE1.C5 262.79,52.17 262.82,52.17 v1(262.84,52.14)
  TOP w0.102: RPE7.2 236.54,14.2 237.32,14.99 v2(237.32,15.15) 237.32,15.62 v1(236.95,16)
  IN2 w0.076: v1(262.84,52.14) 263.33,52.62 264.6,52.62 264.85,52.37 264.85,51.61 264.82,51.58 264.82,48.83 265.08,48.57 265.38,48.57 265.61,48.35 265.61,47.9 265.76,47.75 266.22,47.75 266.42,47.54 266.42,47.09 266.37,47.04
  IN2 w0.122: v1(236.95,16) 236.95,16.23 236.73,16.44 236.73,17.8 240.09,21.15 244,21.15 244.47,20.68 248.71,20.68 250.23,22.2 251.42,22.2 252.51,23.29 252.51,23.97 252.98,24.43 252.98,26.12 253.42,26.56 253.42,32.25 257.69,36.52 260.94,36.52 261.09,36.67 262.11,36.67 263.19,37.76 263.19,38.88 263.76,39.44 263.76,40.22 265.04,41.5 265.04,43.67 266.37,45 266.37,47.04
  BOTTOM w0.102: v1(236.95,16) 236.95,14.11 236.42,13.57 JDEG1.3
KB_DET#: length 113.2
  TOP w0.102: v1(195.79,29.51) 195.79,28.39 196.45,27.73 196.45,26.16 197.54,25.07 197.9,25.07 199.57,23.39 CZ84.1 199.57,23.11 199.11,22.65 199.11,21.33 199.62,20.82 199.62,19.54 199.15,19.07 JKBTP1.1 ; RC288.1 144.66,80.95 143.87,80.16 143.87,79.47 v1(143.97,79.37)
  IN1 w0.089: v1(190.35,47.44) 180.73,57.06 180.73,57.86 179.71,58.87 179.71,62.29 178.82,63.18 178.82,64.28 172.83,70.28 167.64,70.28 166.59,71.33 162.27,71.33 161.88,71.73 160.23,71.73 158.51,73.44 155.63,73.44 149.89,79.18 147.77,79.18 146.92,80.03 145.4,80.03 145.06,79.69 144.67,79.69 144.35,79.37 v1(143.97,79.37) 143.97,79.24 141.57,76.83 141.57,76.63 139.81,74.87 138.76,74.87 138.07,74.18 138.07,73.57 136.8,72.3 136.8,71.41 v1(136.73,71.34)
  BOTTOM w0.076: UC1.D8 136.51,71.56 v1(136.73,71.34)
  BOTTOM w0.102: v1(195.79,29.51) 195.79,31.14 189.59,37.33 189.59,39.72 191.95,42.08 191.95,44.65 190.89,45.72 190.89,45.84 190.35,46.38 v1(190.35,47.44)
LAN_ACTLED_YEL#: length 3.2
  TOP w0.102: QL1.6 268.73,64 269.56,63.17 RL14.1 269.93,62.56 v2(270.27,62.21)
LAN_ACTLED_YEL_R#: length 32.6
  TOP w0.102: RL14.2 270.84,61.82 272.09,60.58 273.56,60.58 274.63,61.64 v3(274.63,62.28) 274.17,62.73 274.17,64.08 274.58,64.49 274.58,64.97 275.14,65.53 275.14,67.23 275.44,67.53 275.85,67.53 276.38,67 v1(277.83,67)
  IN1 w0.089: JLOM1.10 280.61,77.97 280.61,73.47 280.28,73.14 280.28,69.79 277.83,67.34 v1(277.83,67)
LAN_DISABLE#_R: length 11.5
  TOP w0.102: RL5.1 RL7.2 RL9.1 262.28,64.79 262.28,70.11 v2(261.99,70.41) 261.83,70.57 261.44,70.57 260.09,71.92 UL1.3
LAN_MDIN0: length 6.5
  TOP w0.089: RL72.1 260.14,81.36 260.14,80.81 v4(259.02,79.69) 258.71,79.38 258.71,77.51 258.54,77.35 258.54,77.07 258.44,76.97 UL1.14
LAN_MDIN0_L: length 21.1
  TOP w0.089: RL72.2 260.05,83.26 260.28,83.49 260.28,84.09 259.46,84.91 257.23,84.91 256.17,85.98 256.17,96 255.96,96.21 255.7,96.21 v1(255.41,95.92)
  BOTTOM w0.089: v1(255.41,95.92) 255.52,96.03 256.47,96.03 256.82,96.38 257.41,96.38 257.76,96.03 TL1.11
LAN_MDIN1: length 6.1
  TOP w0.089: UL1.18 256.84,76.93 256.88,76.97 256.88,77.39 256.99,77.5 256.99,80.43 v4(257.37,80.81) 257.59,81.03 257.59,81.37 RL74.1
LAN_MDIN1_L: length 15.4
  TOP w0.089: RL74.2 257.59,83.74 257.59,83.9 257.47,84.02 256.86,84.02 v4(255.77,85.1) 254.9,85.98 v1(254.9,91.66)
  BOTTOM w0.089: TL1.5 255.64,90.03 254.9,90.77 v1(254.9,91.66)
LAN_MDIN2: length 6.1
  TOP w0.089: RL76.1 255.05,81.37 255.05,80.09 255.58,79.56 v4(255.58,79.27) 255.58,78.39 255.69,78.28 255.69,77.05 255.64,77 UL1.21
LAN_MDIN2_L: length 18.5
  TOP w0.089: v1(253.75,94.73) 253.79,94.69 253.79,85.78 255.05,84.52 255.05,83.74 RL76.2
  BOTTOM w0.089: v1(253.75,94.73) 253.75,94.09 254.81,93.03 TL1.8
LAN_MDIN3: length 6.6
  TOP w0.089: UL1.24 254.44,77 254.49,77.05 254.49,77.15 v4(253.47,78.17) 252.51,79.14 252.51,81.37 RL78.1
LAN_MDIN3_L: length 13.6
  TOP w0.089: RL78.2 252.51,83.74 252.51,84.52 252.2,84.83 v1(252.2,88.69)
  BOTTOM w0.089: v1(252.2,88.69) 252.23,88.67 252.23,88.03 253.23,87.03 TL1.2
LAN_MDIP0: length 6.4
  TOP w0.089: RL71.1 260.44,81.39 260.44,80.68 v4(260.2,80.44) 259.01,79.25 259.01,77.39 258.84,77.22 UL1.13
LAN_MDIP0_L: length 21.1
  TOP w0.089: v1(255.41,96.51) 256.08,96.51 256.47,96.12 v4(256.47,87.37) 256.47,86.1 257.36,85.21 259.58,85.21 260.58,84.21 260.58,83.59 RL71.2
  BOTTOM w0.089: v1(255.41,96.51) 255.59,96.33 256.34,96.33 256.69,96.68 257.41,96.68 257.77,97.03 TL1.12
LAN_MDIP1: length 6.1
  TOP w0.089: RL73.1 257.89,81.37 257.89,80.91 257.29,80.31 v4(257.29,79.42) 257.29,77.38 257.18,77.27 257.18,76.99 257.24,76.93 UL1.17
LAN_MDIP1_L: length 15.4
  TOP w0.089: RL73.2 257.89,83.74 257.89,84.02 257.59,84.32 256.98,84.32 255.99,85.31 255.2,86.1 255.2,91.38 v1(255.48,91.66)
  BOTTOM w0.089: TL1.6 257.76,91.03 257.06,90.33 255.76,90.33 255.2,90.89 255.2,91.38 v1(255.48,91.66)
LAN_MDIP2: length 6.1
  TOP w0.089: UL1.20 256.04,77 255.99,77.05 255.99,78.41 255.88,78.52 255.88,79.68 255.35,80.21 v4(255.35,80.67) 255.35,81.37 RL75.1
LAN_MDIP2_L: length 18.5
  TOP w0.089: RL75.2 255.35,83.74 255.35,84.65 254.09,85.91 254.09,94.48 v1(254.33,94.73)
  BOTTOM w0.089: TL1.9 257.71,94.03 257.01,93.33 254.93,93.33 254.05,94.21 254.05,94.44 v1(254.33,94.73)
LAN_MDIP3: length 6.6
  TOP w0.089: UL1.23 254.84,77 254.79,77.05 254.79,77.28 252.81,79.26 v4(252.81,80.31) 252.81,81.37 RL77.1
LAN_MDIP3_L: length 13.6
  TOP w0.089: RL77.2 252.81,83.74 252.81,84.65 252.5,84.96 252.5,88.41 v1(252.79,88.69)
  BOTTOM w0.089: v1(252.79,88.69) 252.53,88.43 252.53,88.15 253.35,87.33 257.26,87.33 257.96,88.03 TL1.3
LAN_TEST_EN: length 2.7
  TOP w0.102: v2(251.18,73.28) 251.62,73.71 RL12.1 252.34,73.52 UL1.30
LAN_WAKE#: length 235.2
  TOP w0.076: v1(261.29,43.22) 261.14,43.37 261.14,45.46 260.86,45.74 260.86,46.09 UE1.L3
  TOP w0.102: v1(261,62.59) 260.84,62.76 260.84,64.87 v2(261.4,65.43) 262.06,66.09 262.06,69.63 260.17,71.52 UL1.2 ; RL70.1 RC323.1 140.56,36.24 v1(140.12,36.67)
  IN1 w0.089: v1(256.06,20.04) 256.06,18.91 ; v1(133.83,57.21) 133.37,56.74 133.37,53.58 133.75,53.19 133.75,52.21 136.07,49.89 136.07,45.26
  IN1 w0.091: 256.06,18.91 254.49,17.34 251.98,17.34 251.11,16.47 250.7,16.47 249.36,15.14 249.03,15.14 247.71,16.46 245.07,16.46 244.2,15.59 242.92,15.59 241.42,14.09 238.44,14.09 237.6,14.93 234.36,14.93 233.36,15.93 231.67,15.93 231.41,16.19 228.95,16.19 228.75,16.38 221.57,16.38 219.53,14.34 219.53,13.79 219.06,13.33 218.58,13.33 218.19,12.93 215.15,12.93 214.43,12.21 204.88,12.21 201.9,15.2 201.9,16.64 201.27,17.27 201.27,17.61 200.12,18.77 198.78,18.77 197.64,19.91 196.98,19.91 196.32,20.57 195.13,20.57 194.08,21.61 187.15,21.61 182.22,26.54 160.11,26.54 151.59,35.07 142.74,35.07 141.13,36.67 v1(140.12,36.67) 140.12,37.68 137.7,40.1 136.83,40.1 136.28,40.66 136.28,41.21 136.71,41.64 136.71,44.62 136.07,45.26
  IN3 w0.122: v1(256.06,20.04) 256.06,21.15 255.79,21.42 254.72,21.42 254.41,21.73 254.41,26.77 256.46,28.81 256.46,30.77 258.88,33.19 258.88,34.54 258.34,35.09 258.34,37.98 259.55,39.2 259.55,41.48 v1(261.29,43.22)
  IN4 w0.089: v1(261.29,43.22) 261.85,42.67 263.22,42.67 264.67,44.12 268.23,44.12 268.85,44.74 268.85,46.19 268.26,46.79 266.73,46.79 266.47,47.05 266.47,47.45 266.21,47.71 265.92,47.71 265.64,47.99 265.64,49.91 265.4,50.15 265,50.15 264.85,50.3 264.85,50.71 264.63,50.92 264.15,50.92 263.96,51.11 263.96,56.51 263.9,56.57 263.9,58.84 262.18,60.55 262.18,61.55 261.61,62.12 261.47,62.12 v1(261,62.59)
  BOTTOM w0.076: v1(133.83,57.21) 133.7,57.07 132.77,57.07 UC1.AM15
LCD_CBL_DET#: length 159.6
  IN1 w0.076: v1(138.47,61.53) 139.89,62.95 140.12,62.95
  IN1 w0.089: v1(150.98,63.31) 150.01,63.31 149.72,63.6 144.17,63.6 143.52,62.95 140.12,62.95
  IN2 w0.122: v1(63.56,93.52) 63.73,93.34 64.7,93.34 65,93.65 67.5,93.65 69,95.15 69,98.93 70.16,100.08 70.16,101.52 73.9,105.26 77.42,105.26 80.4,102.28 83.56,102.28 85.72,100.12 87.66,100.12 87.89,100.35 92.46,100.35 92.6,100.21 99.11,100.21 100.37,98.96 103.18,98.96 103.46,98.68 104.66,98.68 105.19,99.21 106.76,99.21 107.07,98.9 110.49,98.9 113.09,96.31 113.09,95.68 117.73,91.03 120.76,91.03 121.95,89.84 133.63,89.84 134.4,90.6 137.8,90.6 139,89.4 142.85,89.4 144.32,87.93 148.42,87.93 150.64,85.71 150.64,81.88 154.72,77.8 154.72,75.54 155.06,75.19 155.06,69.33 152.95,67.22 152.15,67.22 151.46,66.53 151.46,66.13 150.99,65.66 150.99,65.17 151.49,64.68 151.49,63.82 v1(150.98,63.31)
  BOTTOM w0.076: v1(138.47,61.53) 138.5,61.5 138.95,61.5 UC1.AC3
  BOTTOM w0.102: v1(63.56,93.52) 63.94,93.14 63.94,90.98 66.53,88.39 66.53,86.36 67.03,85.85 JEDP1.40 ; RC287.1 153.12,62.51 v2(152.9,62.72) 152.44,62.72 151.85,63.31 v1(150.98,63.31)
LCD_TST: length 276.8
  TOP w0.076: 256.8,52.35 v1(257.18,52.35) ; UE1.M2 v1(260.46,45.77)
  TOP w0.102: RE20.1 256.77,52.35 256.8,52.35
  IN2 w0.122: v1(247.45,50.08) 247.45,50.31 246.79,50.97 245.06,50.97 244.01,49.92 244.01,49.16 241.77,46.92 241.11,46.92 239.86,45.67 238.23,45.67 237.21,44.65 237.21,44.23 235.56,42.59 234.81,42.59 232.89,40.66 232.54,40.66 232.39,40.51 229.56,40.51 228.21,39.16 226.29,39.16 225.41,38.27 213.71,38.27 212.44,39.54 209.26,39.54 208.7,40.1 207.07,40.1 206.24,40.93 203.78,40.93 202.37,42.34 199.55,42.34 188.9,52.98 188.9,55.42 185.33,58.99 185.33,61.63 183.32,63.64 183.32,65.73 177.25,71.8 177.25,74.57 176.59,75.23 175.55,75.23 170.26,80.51 169.69,80.51 166.17,84.04 166.17,86.49 163.85,88.81 163.85,91.89 162.85,92.89 158.07,92.89 152.87,98.09 143.69,98.09 142.19,99.59 138.66,99.59 138.19,100.06 136.02,100.06 135.55,99.59 131.81,99.59 131.28,100.12 129.59,100.12 129.16,100.55 127.41,100.55 118.91,109.05 113.32,109.05 111.5,110.86 107.66,110.86 106.35,109.56 105.5,109.56 104.99,109.06 101,109.06 98.68,111.37 84.97,111.37 83.56,109.97 79.2,109.97 77.59,108.36 72.71,108.36 72.4,108.67 72.11,108.96 67.66,108.96 66.78,108.96 66.55,108.96 64.44,106.85 64.44,106.83 64.13,106.51 64.13,103.11 62.04,101.02 62.04,99.22 v1(62.56,98.7)
  IN4 w0.089: v1(257.18,52.35) 256.32,51.48 253.55,51.48 252.79,50.72 248.11,50.72 247.45,50.06 v1(247.45,50.08)
  BOTTOM w0.102: v1(257.18,52.35) 257.74,51.79 258.17,51.79 258.72,51.24 258.72,49.28 257.46,48.02 257.46,47.15 258.18,46.43 259.8,46.43 v1(260.46,45.77) ; v1(62.56,98.7) 63.43,97.84 63.43,94.53 63.76,94.2 64.52,94.2 64.75,93.98 64.75,91.69 65.14,91.3 67.7,91.3 67.75,91.35 JEDP1.29
LCD_VCC_TEST_EN: length 274.8
  TOP w0.076: UE1.E1 258.34,50.93 v1(258.3,50.97)
  TOP w0.102: DV3.2 74.4,95.73 73.66,95.73 73.16,95.22 72.22,95.22 72.04,95.04 71.51,95.04 71.28,95.27 71.28,95.63 71.04,95.87 67.66,95.87 67.21,96.31 66.74,96.31 66.11,95.68 65.08,95.68 64.47,96.29 64.47,96.75 64.72,97 64.72,97.82 64.22,98.32 63.58,98.32 63.24,98.66 v2(63.24,99.03) 62.92,99.35 v1(62.59,99.35)
  IN2 w0.122: v1(62.59,99.35) 62.59,101.19 64.38,102.98 64.38,106.41 66.68,108.71 66.99,108.71 72.01,108.71 72.15,108.56 72.61,108.11 77.7,108.11 79.31,109.72 83.66,109.72 85.07,111.13 98.58,111.13 100.89,108.81 105.1,108.81 105.6,109.31 106.45,109.31 107.76,110.61 111.4,110.61 113.21,108.8 118.81,108.8 127.31,100.3 129.07,100.3 129.49,99.87 129.5,99.87 129.56,99.81 131.23,99.81 131.71,99.34 135.65,99.34 136.12,99.81 138.09,99.81 138.56,99.34 141.83,99.34 143.46,97.71 152.9,97.71 157.96,92.65 162.75,92.65 163.6,91.79 163.6,88.7 165.92,86.39 165.92,83.05 168.71,80.26 170.16,80.26 175.44,74.98 176.49,74.98 176.99,74.47 176.99,71.7 183.07,65.62 183.07,63.54 185.08,61.53 185.08,58.89 188.65,55.32 188.65,52.82 199.39,42.09 202.26,42.09 203.68,40.68 206.1,40.68 206.94,39.83 208.56,39.83 209.1,39.29 212.32,39.29 213.6,38.01 225.5,38.01 226.35,38.86 228.26,38.86 229.66,40.26 232.49,40.26 232.64,40.41 233.14,40.41 235.07,42.34 235.69,42.34 236.76,43.41 238.13,43.41 238.46,43.73 238.46,45.16 238.72,45.42 240.07,45.42 241.31,46.67 241.88,46.67 244.37,49.16 244.37,49.54 244.78,49.96 245.39,49.96 246.04,50.61 246.59,50.61 246.87,50.33 v1(246.87,50.08)
  IN4 w0.089: v1(258.3,50.97) 259.26,51.94 259.26,52.37 258.75,52.88 256.85,52.88 256.6,52.62 254.31,52.62 253.8,52.12 252.53,52.12 251.9,51.48 248.26,51.48 v1(246.87,50.08)
LED_10_GRN#: length 6.9
  TOP w0.102: QL2.6 269.04,67.43 269.39,67.78 269.39,69.68 RL19.1 271.12,72.2 v2(271.78,72.86)
LED_10_GRN_R#: length 13.2
  TOP w0.102: JLOM1.11 280.37,72.28 279.63,73.02 v3(275.34,73.02) 273.64,73.02 RL19.2
LED_100_ORG#: length 5.7
  TOP w0.102: RL20.1 270.49,70.28 v2(270.15,69.94) 269.8,69.59 269.8,66.69 QL1.3
LED_100_ORG_R#: length 14.3
  TOP w0.102: RL20.2 274.4,72.64 278.58,72.64 v3(279.7,71.53) 282.74,71.53 JLOM1.13
LED_MASK#: length 32.1
  TOP w0.076: UE1.A12 268.2,54.13 269.3,55.22 269.48,55.22 269.93,55.67
  TOP w0.102: v1(271.15,69.52) 271.15,68.3 270.93,68.08 QL2.2 270.35,68.08 270.06,67.79 270.06,67.12 271.12,66.05 271.12,65.5 270.84,65.22 QL1.2 QL1.5 268.43,65.22 268.15,64.94 268.15,63.93 269.17,62.91 269.17,61.69 v2(269.9,60.96) 269.9,59.48 269.55,59.13 269,59.13 RE21.1 270.18,57.49 270.18,55.93 269.93,55.67 ; UZ10.1 v1(278.81,67.74)
  IN2 w0.122: v1(271.15,69.52) 271.7,70.06 274.6,70.06 276.93,67.74 v1(278.81,67.74)
LG1_ISL9538: length 8.6
  TOP w0.102: v1(33.9,33) 33.9,33.49 v2(34.04,33.63)
  IN1 w0.762: 33.37,33.52 33.37,37.5 32.34,38.53 32.34,39.61 33.09,40.36 33.09,40.71
  vias: v1(33.04,41.42) v1(33.9,32.42)
LG2_ISL9538: length 18
  IN1 w0.762: 34.66,41.51 34.03,40.88 34.03,39.39 34.54,38.88 35.49,38.88 36.03,38.34 36.03,33.01 34.44,31.42 33.82,31.42 33.06,30.66 33.06,28.09 32.33,27.35 32.33,27.02
  vias: v1(31.98,26.31) v1(32.57,26.31) v1(34.1,42.46)
LID_CL#: length 107.6
  TOP w0.102: v1(274.35,27.61) 273.92,28.04 273.56,28.04 v3(272.83,28.77) 272.34,29.26 272.34,30.65 272.6,30.91 272.6,32.05 272.24,32.41 272.24,35.2 RE26.1 ; v1(273.3,8.3) JLED1.5 ; UZ10.2 v1(279.46,67.74)
  IN2 w0.122: v1(279.46,67.74) 279.46,65.53 280.98,64 280.98,56.56 283.39,54.15 283.39,49.58 282.88,49.07 282.88,48.56 284.03,47.42 284.03,42.72 282.83,41.52 282.83,39.04 284.03,37.84 284.03,31.29 283.33,30.59 283.33,29.27 282.27,28.22 279.76,28.22 279.48,28.49 276.53,28.49 275.26,27.22 274.73,27.22 v1(274.35,27.61)
  IN4 w0.089: v1(274.35,27.61) 274.35,27.33 274.25,27.22 272.98,27.22 272.6,26.84 268.15,26.84 266.5,25.19 266.5,24.96 263.83,22.3 263.83,21.97 263.12,21.26 262.93,21.26 259.26,17.59 259.26,13.13 260.53,11.86 263.96,11.86 264.85,10.97 265.49,10.97 266.37,11.86 269.55,11.86 269.93,11.48 269.93,10.97 269.68,10.71 269.68,8.17 270.06,7.79 272.98,7.79 273.3,8.12 v1(273.3,8.3)
LID_CL#_PCH: length 3.6
  TOP w0.102: v1(137.67,53.72) 137.33,53.72 137.02,54.02 137.02,54.66 136.87,54.81 136.25,54.81 T268.1
  BOTTOM w0.076: UC1.AW7 136.85,53.29 137.28,53.72 v1(137.67,53.72)
LID_CL_SIO#: length 10
  TOP w0.076: 267.94,42.85 267.94,43.71 267.22,44.43 UE1.N11
  TOP w0.102: 267.94,42.85 267.94,42.25 268.69,41.5 v2(268.69,40.92) 268.69,40.59 269.86,39.42 270.31,39.42 CE8.1 270.82,38.05 RE25.2 270.79,37.56 RE26.2
LINE1_L: length 3.5
  TOP w0.203: UA1.36 268.6,22.25 268.66,22.31 v2(269.14,22.31) 269.41,22.31 269.73,21.99 271.04,21.99 CA43.1
LINE1_R: length 3.8
  TOP w0.203: UA1.35 268.36,21.85 268.43,21.92 269.34,21.92 269.6,21.65 270.12,21.65 v2(270.21,21.56) 270.27,21.56 CA44.1
LM393_P: length 57.8
  TOP w0.203: v1(59.41,75.02) PD1801.1 60.54,74.66 PC1201.2 58.65,73.88 58.31,73.54 PU1201.8 ; PU903.5 28.88,50.96 PC949.2 29.05,52.01 PR950.2 29.57,52.55 32.38,52.55 34.12,50.81 34.12,49.53 v2(34.07,49.48) 34.03,49.44 34.03,49.03 v1(33.96,48.96)
  IN4 w0.203: v1(59.41,75.02) 59.28,75.02 54.92,70.66 54.92,65.32 52.76,63.17 45.65,63.17 40.57,58.09 40.57,56.05 39.63,55.11 39.63,54.35 39.43,54.15 39.43,53.78 37.82,52.18 37.82,49.37 37.6,49.15 35.03,49.15 34.75,48.87 34.22,48.87 34.12,48.96 v1(33.96,48.96)
LOM_ACTLED_YEL#: length 25
  TOP w0.102: QL1.1 270.96,64.57 271.38,64.99 271.38,66.59 v1(271.12,66.85) ; UL1.26 254.2,75.12 254.31,75.23 v1(254.94,75.23)
  BOTTOM w0.102: v1(254.94,75.23) 255.17,75 v2(256,75) 258.69,75 260.41,73.29 260.41,71.29 263.2,68.5 266.7,68.5 268.35,66.85 v1(271.12,66.85)
LOM_CABLE_DETECT#: length 33.7
  TOP w0.076: v1(257.79,52.4) 258.17,52.02 259.06,52.02 259.09,52.05 259.59,52.05 259.9,51.73 UE1.D2
  TOP w0.102: UL2.4 272.03,65.52 v1(271.84,65.32) ; RE505.1 v1(266.76,65.71)
  IN1 w0.089: v1(257.79,52.4) 257.79,53.19 258.37,53.77 259.52,53.77 260.79,55.04 261.17,55.04 262.56,56.43 269.05,56.43 269.92,57.3 271.14,57.3 271.58,57.74 271.58,60.68 271.96,61.06 271.96,65.2 v1(271.84,65.32)
  BOTTOM w0.102: v1(266.76,65.71) 271.45,65.71 v1(271.84,65.32)
LOM_SPD10LED_GRN#: length 28.8
  TOP w0.102: v1(253.8,75.99) 253.67,75.86 UL1.25 ; UL2.2 273.49,65.29 273.08,65.69 v2(273.08,67.12) 272.76,67.43 v1(272.34,67.43) RL30.2 271.64,67.43 QL2.1
  BOTTOM w0.102: v1(253.8,75.99) 258.25,75.99 258.99,75.25 260.79,73.45 260.79,71.45 263.38,68.87 266.88,68.87 268.26,67.48 272.29,67.48 v1(272.34,67.43)
LOM_SPD100LED_ORG#: length 27.1
  TOP w0.102: UL2.1 v1(273.16,64.64) ; UL1.27 v1(254.56,74.72) ; QL1.4 268.27,65.87 268.07,65.68 RL29.2 267.64,66.09 v1(267.9,66.34)
  BOTTOM w0.102: v1(273.16,64.64) 271.45,66.34 v2(269.87,66.34) v1(267.9,66.34) 267.77,66.47 267.77,67.1 266.76,68.12 263.26,68.12 259.45,71.93 258.75,71.93 258.12,72.56 257.61,72.56 257.23,72.94 257.23,73.58 256.76,74.05 255.23,74.05 v1(254.56,74.72)
LPS_PROTECT#: length 1
  TOP w0.102: PT1.1 48.25,71.42 PR1248.2
LPSS_UART2_RXD: length 43.4
  TOP w0.102: RC330.1 132,92.82 132,91.87 RC402.1 v2(134.38,89) 135.15,88.24 136.77,88.24 142.68,82.33 142.68,79.4 142.47,79.19 142.47,78.48 143.01,77.94 143.01,76.65 142.78,76.41 142.78,72.75 144.05,71.48 144.05,70.91 143.42,70.28 142.85,70.28 v1(142.43,70.7)
  IN2 w0.122: v1(142.43,70.7) 142.43,70.04 142.3,69.91 142.3,68.76 142.93,68.13 142.93,62.08 141.96,61.11 v1(141.96,60.52)
  BOTTOM w0.076: v1(141.96,60.52) 141.96,60.82 141.85,60.94 141,60.94 140.91,60.86 UC1.AD1
LPSS_UART2_TXD: length 49.1
  TOP w0.102: v2(129.82,93.44) 130.2,93.06 RC331.1 RC403.1 130.36,92.07 129.77,92.07 129.49,91.79 129.49,91.06 132.54,88.01 136.68,88.01 142.45,82.24 142.45,79.49 142.24,79.29 142.24,78.39 142.78,77.85 142.78,76.74 142.55,76.51 142.55,72.66 143.82,71.39 143.82,71.01 143.51,70.7 v1(143.03,70.7)
  IN2 w0.122: v1(141.37,60.58) 141.72,60.92 141.72,61.21 142.68,62.17 142.68,67.86 141.6,68.94 141.6,70.77 142.09,71.26 142.47,71.26 v1(143.03,70.7)
  BOTTOM w0.076: UC1.AD2 140.25,60.7 140.5,60.59 141.12,60.59 141.14,60.58 v1(141.37,60.58)
LX1_ISL9538: length 27.9
  TOP w0.102: PR923.1 v2(38.64,33.96)
  IN2 w0.508: v1(32.28,41.12) 32.61,40.79 37.05,40.79 39.58,38.26 v1(39.58,35.68)
  IN3 w0.762: v1(27.14,33.13) 27.14,37.22 28.15,38.22 33.05,38.22 33.79,37.49 33.79,37.26 34.12,36.93 v1(34.12,34.78)
  BOTTOM w0.508: v1(27.14,33.13) 27.73,33.72 PQ905.2
  vias: v1(39.55,34.95)
LX2_ISL9538: length 28.6
  TOP w0.102: PR924.1 v2(38.28,30.95)
  IN1 w0.762: 35.93,42.08 35.93,41.36 37.42,39.87 37.42,32.97 35.63,31.17 v1(35.63,30.79)
  IN3 w0.762: v1(27.09,27.77) 27.13,27.73 27.13,25.7 27.89,24.94 32.4,24.94 33.33,25.87 33.33,29.71 v1(33.82,30.21)
  BOTTOM w0.508: PQ904.2 27.61,28.29 v1(27.09,27.77)
  vias: v1(34.35,43.07)
LX_1.8VALW: length 1.1
  BOTTOM w0.102: v2(171.51,110.23) 171.51,109.14
  vias: v1(169.88,107.32)
LX_1V_PRIM: length 1.5
  TOP w0.102: PR409.1 v3(168.01,100.22)
  vias: v1(168.7,98.7)
LX_1VS_VCCIO: length 0.7
  TOP w0.102: v1(172.9,50.99) v2(172.17,50.99)
LX_3V: length 3.9
  TOP w0.102: v1(139.37,109.01) 138.42,109.01 PR106.1 138.42,108.38 v1(139.37,108.38)
  BOTTOM w0.102: v1(144.71,108.57) 144.71,109.24 v2(144.62,109.33) ; 144.48,107.96 v1(144.52,108) ; PU100.6 144.48,107.77
  vias: v1(140.26,107.93) v1(140.58,108.44)
LX_5V:
  vias: v1(43.26,43.23) v1(43.26,42.64) v1(43.41,46.38) v1(44.02,46.4) v2(44.89,46.08)
LX_DDR: length 0.6
  TOP w0.102: v1(50.54,55.29) v2(50.54,55.9)
  BOTTOM w0.102: 50.53,55.3 v1(50.54,55.29)
M2280_DEVSLP: length 179
  IN4 w0.089: v1(256.19,10.99) 256.52,10.99 257.99,12.47 257.99,13.89 257.37,14.52 257.37,16.93 256.54,17.75 255.27,17.75 253.91,16.4 250.1,16.4 249.92,16.58 248.07,16.58 246.71,17.93 239.85,17.93 238.02,19.77 232.66,19.77 231.55,20.87 227.51,20.87 226.5,21.89 223.44,21.89 221.26,24.08 219.77,24.08 219.34,24.5 213.87,24.5 212.86,23.5 207.03,23.5 203.78,26.74 203.23,26.74 201.17,28.8 200.69,28.8 195.64,33.85 195.64,34.64 194.07,36.2 192.83,36.2 190.17,38.86 190.17,39.04 183.75,45.46 183.75,47.19 183.14,47.8 183.14,52.22 178.3,57.06 177.94,57.06 175.61,59.39 174.32,59.39 173.99,59.71 173.99,60.04 174.1,60.14 174.1,60.47 173.81,60.75 173.28,60.75 172.85,61.19 172.85,62.21 172.5,62.56 171.85,62.56 170.32,64.08 169.52,64.08 168.65,64.96 168.65,66.1 166.99,67.76 165.97,67.76 165.48,67.27 161.64,67.27 161.1,67.8 160.09,67.8 159.01,68.88 153.86,68.88 152.51,67.54 145.62,67.54 143.99,69.17 143.99,69.86 143.57,70.27 142.07,70.27 v1(142.01,70.22)
  BOTTOM w0.076: UC1.J3 139.5,69.01 139.66,69.01 139.87,69.09 140.01,69.09 140.01,69.09 140.16,69.04 140.41,69.04 140.52,69.09 140.7,69.16 141.28,69.16 142.01,69.89 v1(142.01,70.22)
  BOTTOM w0.102: JNGFF3.38 271.85,3.59 270.24,5.2 264.12,5.2 262.64,6.68 259.97,6.68 259.31,7.34 259.31,8.19 258.74,8.76 258.51,8.76 v2(258.5,8.77) 258.03,9.24 256.76,9.24 RN37.2 256.28,10.91 v1(256.19,10.99)
M2280_PCIE_SATA#: length 223.2
  TOP w0.102: RN187.1 230.1,28.11 230.1,27.02 229.46,26.37 228.67,26.37 228.27,25.98 228.27,24.81 228.55,24.53 229.06,24.53 229.98,25.45 231.91,25.45 RN184.1 ; RN187.1 230.56,29.23 229.9,29.89 228.94,29.89 228.53,30.31 223.79,30.31 222.81,31.29 v1(222.81,31.57) 222.9,31.48 RN182.1 224.02,31.97 224.02,32.99 223.7,33.31 QN4.2 ; RN187.1 230.64,28.57 232.49,30.43 234.57,30.43 235.74,29.26 236.35,29.26 236.66,28.95 236.66,28.49 236.94,28.22 237.39,28.22 237.8,27.81 237.8,26.76 v1(238.64,25.92) 238.17,25.45 237.38,25.45 236.89,24.95 UN5.20 ; v1(145.9,71.37) 145.65,71.12 145.65,69.92 146.33,69.25 150.94,69.25 151.11,69.41 151.46,69.41 151.73,69.67 152.08,69.67 152.88,70.48 154.11,70.48 154.93,69.67 RPC4.4 155.31,69.67 155.84,69.13 157.01,69.13 157.34,69.47 164.13,69.47 165.35,68.25 167.47,68.25 169.55,66.17 169.55,65.2 168.33,63.98 168.33,62.95 167.92,62.54 167.92,61.09 167.45,60.62 167.45,53.94 167.89,53.5 167.89,50.45 166.54,49.09 163.64,49.09 163.15,48.6 163.15,47.8 162.82,47.47 162.82,46.47 164,45.28 164.74,45.28 166.59,43.43 182.45,43.43 v2(182.65,43.23) 184.92,40.97 194.57,40.97 v1(195,40.53) ; UN4.20 248.6,25.86 249.16,26.42 249.75,26.42 249.97,26.63 249.97,28.32 v1(250.6,28.95)
  IN3 w0.122: v1(250.6,28.95) 250.08,28.43 250.08,26.58 252.32,24.34 252.32,21.59 254.22,19.68 254.22,19.25 257.18,16.29 257.18,14.8 v1(260.99,10.99)
  IN4 w0.089: v1(250.6,28.95) 249.83,28.18 248.78,28.18 247.06,26.46 247.06,25.76 246.25,24.95 243.26,24.95 242.55,24.24 241.76,24.24 241.48,24.52 241.48,25.17 241,25.65 238.9,25.65 v1(238.64,25.92)
  BOTTOM w0.076: UC1.G4 138.92,69.87 140.04,69.87 140.17,69.92 140.36,69.92 140.38,69.91 140.51,69.87 140.76,69.87 141.08,70.2 141.08,70.74 141.82,71.48
  BOTTOM w0.102: v1(195,40.53) 195,40.94 196.96,42.9 219.26,42.9 219.82,42.34 219.82,38.26 222.37,35.71 224.66,35.71 225.12,35.24 225.12,34.87 224.74,34.49 224.46,34.49 222.71,32.74 222.71,31.67 v1(222.81,31.57) ; v1(145.9,71.37) 144.99,72.28 142.63,72.28 141.82,71.48 ; v1(260.99,10.99) 260.99,11.17 261.55,11.73 263.45,11.73 264.1,11.08 JNGFF3.69
M3042_DEVSLP: length 154.3
  TOP w0.102: v2(267.44,37.18) 267.82,37.56 v1(268.25,37.56)
  IN1 w0.089: v1(142.8,69.84) 142.8,69.88 143.2,70.28 144.75,70.28 145.3,69.73 147.23,69.73 147.64,70.14 151.32,70.14 152.21,71.03 154.48,71.03 155.95,72.5 158.12,72.5 160.23,70.39 164.74,70.39 165.8,69.34 171.81,69.34 175.95,65.2 175.95,64.11 177.14,62.91 177.76,62.91 178.74,61.93 178.74,58.47 179.75,57.46 179.75,56.7 191.13,45.32 192.42,45.32 193.76,43.99 195.46,43.99 197.95,41.5 200.15,41.5 200.92,40.73 202.09,40.73 203.3,39.52 204.6,39.52 205.59,38.53 207.57,38.53 207.93,38.17 208.95,38.17 209.4,37.73 211.37,37.73 213.38,35.71 216.14,35.71 216.44,36.01 226.9,36.01 228.72,34.2 232.07,34.2 233.63,35.76 236.19,35.76 237.45,37.02 243.96,37.02 244.49,37.55 246.25,37.55 246.77,37.03 247.14,36.66 252.67,36.66 252.96,36.37 254.06,36.37 254.46,36.77 260.23,36.77 260.26,36.74 266.62,36.74 267.44,37.56 v1(268.25,37.56)
  BOTTOM w0.076: UC1.J2 140.17,68.59 140.36,68.59 140.38,68.58 140.51,68.55 140.7,68.55 140.81,68.59 141.02,68.8 141.41,68.8 142.4,69.8 142.44,69.8
  BOTTOM w0.102: v1(142.8,69.84) 142.75,69.8 142.44,69.8 ; v1(268.25,37.56) 268,37.31 JNGFF2.38
M3042_PCIE#_SATA: length 200.1
  TOP w0.076: UE1.J12 268.33,48.04 268.97,48.04 269.22,47.8 270.06,47.8
  TOP w0.102: v1(147.07,70.15) 147.29,69.93 150.58,69.93 150.75,70.1 151.18,70.1 151.44,70.36 151.79,70.36 152.6,71.17 RPC4.1 155.12,71.36 155.66,71.89 157.29,71.89 159.26,69.92 164.32,69.92 165.54,68.7 167.66,68.7 170.01,66.36 170.01,62.3 167.91,60.21 167.91,54.13 168.35,53.69 168.35,50.26 166.73,48.64 163.83,48.64 163.61,48.41 163.61,47.61 163.28,47.28 163.28,46.66 164.16,45.77 164.9,45.77 166.78,43.89 183.04,43.89 185.42,41.51 199.85,41.51 201.93,39.42 202.65,39.42 205.52,42.29 v3(207.17,42.29) 207.65,42.29 v1(208.82,43.46) ; 270.06,47.8 270.41,47.44 272.88,47.44 v1(273.23,47.09)
  IN2 w0.122: v1(273.23,47.09) 273.9,47.09 274.12,47.3 274.12,53.01 269.8,57.32 266.25,57.32 265.74,57.83 265.61,57.83 265.1,58.34 265.1,58.85 263.33,60.63 257.23,60.63 255.83,59.23 254.18,59.23 249.61,54.66 248,54.66 244.63,51.28 243.04,51.28 242.07,50.3 240.5,50.3 239.4,49.2 238.94,49.2 237.78,48.04 237.09,48.04 235.94,46.89 235.22,46.89 234.34,46.01 233.42,46.01 233,45.59 231.88,45.59 230.75,44.46 229.95,44.46 229.65,44.76 229.03,44.76 228.16,43.88 225.32,43.88 224.8,43.36 212.28,43.36 211.75,43.89 209.25,43.89 v1(208.82,43.46)
  BOTTOM w0.076: UC1.H3 139.24,69.21 139.72,69.21 139.85,69.25 140.03,69.25 140.06,69.25 140.19,69.21 140.38,69.21 140.64,69.32 140.7,69.34 140.93,69.34 141.61,70.02 141.61,70.4 142.29,71.08
  BOTTOM w0.102: 142.29,71.08 142.81,71.6 144.3,71.6 145.88,70.02 146.94,70.02 v1(147.07,70.15)
M_ID2#: length 5.6
  TOP w0.102: CV135.1 289.31,49.32 v2(291.14,49.32) 291.52,48.94 292.93,48.94 JCRT1.4
MASK_BASE_LEDS#: length 6.2
  TOP w0.102: QZ7.5 276.72,68.82 277.3,69.39 279.46,69.39 280.11,70.04 UZ10.4 280.11,70.79 280.48,71.17 v2(281.18,71.17)
MASK_SATA_LED#: length 94.7
  TOP w0.076: 263.73,42.81 263.73,43.84 263.54,44.03 263.54,45.68 263.22,46 UE1.L6
  TOP w0.102: v1(280.36,37.77) 280.55,37.96 QZ2.5 ; 263.73,42.81 263.73,39.43 263.12,38.82 263.12,37.59 261.93,36.39 261.93,35.84 261.57,35.48 260.15,35.48 259.87,35.2 259.87,34.31 259.64,34.08 259.39,34.08 258.5,33.19 257.61,33.19 255.45,35.35 254.44,35.35 254,35.78 254,36.11 253.55,36.57 252.99,36.57 252.76,36.8 252.76,37.69 253.01,37.94 253.01,39.91 252.91,40.01 252.91,40.78 252.81,40.88 251.86,40.88 251.32,41.41 249.1,41.41 248.8,41.72 247.97,41.72 247.2,40.94 246.05,40.94 245.32,41.68 244.89,41.68 242.1,38.9 241.36,38.9 240.59,38.13 240.59,36.8 239.68,35.89 239.68,33.08 240.33,32.43 245.29,32.43 247.32,30.4 v2(248.33,30.4) 249.41,30.4 v1(249.58,30.58)
  IN1 w0.089: v1(280.36,37.77) 279.93,37.77 278.19,36.03 276.6,36.03 276.17,35.61 270.44,35.61 269.65,34.82 269.65,33.57 269.42,33.35 266.65,33.35 266.5,33.19 263.78,33.19 263.25,32.66 261.43,32.66 260.31,31.54 260.02,31.54 259.49,31.01 256.62,31.01 256.21,31.42 253.01,31.42 252.2,30.6 249.61,30.6 v1(249.58,30.58)
ME_FWP: length 64
  TOP w0.076: UE1.G12 268.02,49.33 268.33,49.02 270.05,49.02
  TOP w0.102: v1(273.35,49.44) 273.35,49.31 272.76,48.73 270.35,48.73 270.05,49.02
  IN1 w0.089: v1(287.85,91.94) 288.65,91.94 289.36,91.23 289.36,89.38 287.37,87.38 285.13,87.38 279.26,81.52 279.26,69.38 277.09,67.21 277.09,63.81 277.3,63.6 277.3,53.64 277.55,53.39 277.55,52.85 276.98,52.28 275.93,52.28 273.83,50.18 273.83,49.92 v1(273.35,49.44)
  BOTTOM w0.102: v1(287.85,91.94) 288.17,92.26 RC221.1 289.42,92.26 290.33,91.36 291.27,91.36 291.44,91.18 SW1.1
ME_FWP_PCH: length 230.7
  TOP w0.102: v1(194.75,36.98) 194.09,36.32 v2(191.56,36.32) 190.43,36.32 189.54,37.21 184.78,37.21 181.75,34.18 159.57,34.18 159.11,33.73 137.19,33.73 135.98,34.94 RC223.1
  IN3 w0.122: v1(194.75,36.98) 195.77,38 201.34,38 201.54,37.8 204.27,37.8 204.79,37.28 207.14,37.28 208.68,35.74 216.85,35.74 217.94,36.83 221.11,36.83 221.7,37.41 226.92,37.41 228.04,38.53 229.43,38.53 v1(229.51,38.6)
  IN4 w0.089: v1(287.85,91.35) 286.74,91.35 279.86,84.46 279.86,69.49 278.29,67.91 278.29,67.28 279.86,65.71 279.86,56.13 279.58,55.85 279.58,55.01 279.72,54.87 279.72,54.4 279.21,53.89 278.82,53.89 278.19,53.26 278.19,52.83 280.79,50.22 280.79,45.5 283.38,42.91 283.38,42.29 282.77,41.68 282.77,40.81 281.56,39.61 279.87,39.61 277.99,41.49 277.06,41.49 275.6,40.03 272.76,40.03 272.7,39.97 272.37,39.97 272.31,40.03 271.78,40.03 271.55,39.8 265.95,39.8 265.63,40.12 264.2,40.12 261.97,37.88 260.24,37.88 259.54,37.18 256.75,37.18 256,36.43 256,35.59 254.68,34.27 251.83,34.27 250.89,35.22 239.79,35.22 238.69,36.32 237.49,36.32 237.2,36.03 235.96,36.03 235.26,36.73 233.85,36.73 232.48,38.1 230.01,38.1 v1(229.51,38.6)
  BOTTOM w0.102: SW1.3 295.44,88.42 294.82,87.8 290,87.8 289.5,88.3 289.5,90.51 RC221.2 v1(287.85,91.35)
ME_RESET#: length 5.9
  BOTTOM w0.102: UC12.2 148.76,87.66 148.54,87.88 148.54,88.97 RC227.1 RC225.1 148.14,89.47 147.67,89.94 146.49,89.94 v2(146.19,89.65)
ME_SUS_PWR_ACK: length 179.2
  TOP w0.076: UE1.B13 270.41,53.33
  TOP w0.102: v1(275.45,55.86) 274.63,55.04 273.87,55.04 273.11,54.28 273.11,53.77 272.85,53.51 272.47,53.51 272.29,53.33 270.41,53.33 ; v1(155.81,47.36) 155.67,47.21 v2(155.67,46.85) 155.67,46.11 RC74.1 155.12,45.56 RC444.1
  IN1 w0.089: v1(155.81,47.36) 155.81,47.02 157.83,45 159.16,45 160.14,44.02 160.14,42.69 162.15,40.69 176.49,40.69 181.16,36.01 183.85,36.01 188.5,31.37 194.75,31.37 195.43,30.68 195.99,30.68 198.53,28.14 200.16,28.14 201.08,27.21 201.93,27.21 202.53,26.61 202.53,26.5 204.55,24.48 206.38,24.48 209.22,21.64 209.22,20.32 211.17,18.37 214.01,18.37 214.33,18.69 214.33,19.85 215.1,20.61 216.12,20.61 216.61,21.11 217.27,21.11 218.61,22.45 221.15,22.45 221.78,21.82 222.59,21.82 223.1,22.33 232.01,22.33 232.54,22.86 234.5,22.86 234.62,22.73 238.1,22.73 239.77,21.06 244.29,21.06 244.53,20.82 245.34,20.82 246.05,21.52 247.06,21.52 247.41,21.88 249.15,21.88 250.01,22.73 252.1,22.73 252.56,23.19 252.56,26.36 253.65,27.45 254.79,27.45 255.93,28.6 260.96,28.6 263.09,30.72 266.34,30.72 266.63,31.01 271.25,31.01 272.7,32.46 272.7,32.64 273.44,33.37 274.07,33.37 274.35,33.09 v1(274.88,33.09)
  IN3 w0.122: v1(274.88,33.09) 276.25,34.46 276.25,36.32 276.86,36.92 276.86,40.42 276.95,40.5 276.95,43.18 276.72,43.4 276.72,48.12 275.26,49.58 275.26,51.48 275.45,51.67 v1(275.45,55.86)
ME_SUS_PWR_ACK_R: length 31.5
  TOP w0.102: RC444.2 154.75,46.48 155.32,47.05 155.32,47.63 155.46,47.77 v1(155.46,47.82)
  IN4 w0.076: 137.85,53.32 138.04,53.51 138.04,53.89
  IN4 w0.089: 137.85,53.32 136.58,53.32 136.45,53.2 133.72,53.2 133.46,53.46 133.46,54.68 v1(133.84,55.06) ; 138.04,53.89 138.04,54.09 138.23,54.28 138.61,54.28 138.87,54.02 139.63,54.02 139.95,54.34 146.91,54.34 147.76,53.49 151.37,53.49 153.31,51.55 153.31,49.23 154.72,47.82 v1(155.46,47.82)
  BOTTOM w0.076: UC1.AR13 133.46,55.44 v1(133.84,55.06)
MEC_XTAL1: length 7
  TOP w0.076: UE1.A1 257.43,55.93
  TOP w0.102: 257.43,55.93 257.29,56.06 v2(257.29,56.3) 257.29,56.42 257.81,56.94 258.2,56.94 258.7,57.45 CE28.1 258.83,57.76 258.23,58.35 YE1.1
MEC_XTAL2: length 3.1
  TOP w0.102: RE290.2 259.44,57.2 CE29.1 260.73,58.49 YE1.2
MEC_XTAL2_R: length 2.6
  TOP w0.076: 260.35,55.93 v2(260.35,55.57) 260.35,54.6 UE1.A3
  TOP w0.102: RE290.1 260.35,55.93
MEDIACARD_IRQ#: length 147.8
  IN2 w0.122: v1(135.66,56.9) 135.96,56.9 136.1,56.77 137.16,56.77 137.22,56.82 137.6,56.82 138.36,56.05 138.36,54.84 139.76,53.45 139.76,52.37 140.89,51.24 142.95,51.24 143.6,51.89 145.4,51.89 147.3,53.78 152.41,53.78 154.82,56.19 154.82,59.49 154.37,59.94 154.37,61.06 151.82,63.61 151.82,64.7 151.29,65.23 151.29,65.6 151.71,66.02 151.71,66.43 152.24,66.96 153.05,66.96 155.31,69.22 155.31,75.29 154.96,75.64 154.96,77.9 150.89,81.98 150.89,86.84 150.58,87.14 149.56,87.14 148.52,88.18 144.42,88.18 142.95,89.65 139.1,89.65 137.9,90.85 134.19,90.85 133.43,90.09 122.08,90.09 120.88,91.28 117.86,91.28 113.47,95.68 113.47,97.33 111.43,99.36 107.5,99.36 107.4,99.46 105.08,99.46 104.55,98.93 103.56,98.93 103.28,99.21 100.47,99.21 99.22,100.46 92.7,100.46 92.18,100.99 86.87,100.99 v1(86.44,100.55)
  BOTTOM w0.076: UC1.AN8 135.95,56.9 v1(135.66,56.9)
  BOTTOM w0.102: UR1.32 82.25,92.35 82.35,92.25 RR19.1 83.16,91.65 83.54,91.27 v2(83.65,91.27) 83.89,91.27 84.51,91.89 84.51,93.47 85.78,94.74 85.78,95.73 86.62,96.57 86.62,100.38 v1(86.44,100.55)
