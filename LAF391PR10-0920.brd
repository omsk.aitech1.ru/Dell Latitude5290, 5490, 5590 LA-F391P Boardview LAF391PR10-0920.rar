# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW2_DP1_N3_C: length 4.2
  TOP w0.094: CT110.2 31.89,79.32 31.47,79.32 31.11,78.96 31.11,78.7 31.08,78.67 31.08,78.01 31.09,78 31.09,77.87 30.65,77.43 30.65,77.26 30.58,77.19 30.33,77.19 30.24,77.28 UT9.19
SW2_DP1_P0: length 155.4
  TOP w0.094: v1(34.5,74.6) 34.32,74.42 34.32,74.09 34.08,73.85 33.67,73.85 33.5,73.69 33.4,73.69 CT103.1 ; UV7.50 162.79,86.17 162.89,86.28 162.89,88.25 161.36,89.79 161.36,90.99 v1(160.96,91.39)
  IN1 w0.089: v1(160.96,91.39) 161.33,91.76 161.33,91.98 160.41,92.91 156.37,92.91 155.17,94.1 142.17,94.1 141.21,93.14 139.5,93.14 138.54,94.1 124.82,94.1 121.77,91.05 119.76,91.05 119.05,90.34 108.41,90.34 106.83,91.92 106.83,92.76 104.14,95.45 103.56,95.45 103.23,95.78 103.23,96.36 102.52,97.07 88.12,97.07 87.41,96.36 83.7,96.36 83.27,96.79 82.2,96.79 80.95,95.55 80.14,95.55 78.87,94.28 78.46,94.28 76.86,92.68 74.55,92.68 74.4,92.53 72.04,92.53 67.19,87.68 64.06,87.68 60.3,83.92 59.79,83.92 57.84,81.96 57.84,80.84 52.68,75.69 51.06,75.69 50.63,75.26 49.56,75.26 49.08,75.74 46.79,75.74 46.23,75.18 45.57,75.18 44.89,75.86 34.62,75.86 34.32,75.56 34.32,74.78 34.32,74.77 v1(34.5,74.6)
SW2_DP1_P0_C: length 2.5
  TOP w0.094: UT9.9 30.45,73.28 30.55,73.39 30.71,73.39 30.74,73.36 31.34,73.36 31.47,73.49 31.47,73.49 31.58,73.6 31.69,73.6 CT103.2
SW2_DP1_P1: length 155.5
  TOP w0.094: UV7.47 163.99,86.2 164.09,86.31 164.09,88.64 162.65,90.08 162.65,90.99 v1(162.26,91.39) ; v1(34.88,77.01) 34.85,77.01 34.62,76.78 34.62,76.51 33.72,75.6 33.4,75.6 CT105.1
  IN1 w0.089: v1(162.26,91.39) 162.61,91.75 162.61,92.31 161.4,93.52 156.9,93.52 155.68,94.74 124.59,94.74 121.72,91.87 119.69,91.87 118.74,90.92 109.21,90.92 107.57,92.56 107.57,93.6 107.01,94.15 106.25,94.15 104.24,96.16 104.24,96.19 102.77,97.66 84.87,97.66 84.46,97.25 83.62,97.25 83.49,97.38 81.94,97.38 80.7,96.14 79.2,96.14 78.38,95.31 76.93,95.31 76.41,94.79 74.5,94.79 74.02,94.31 73,94.31 67.64,88.95 63.94,88.95 59.49,84.5 58.5,84.5 57,83.01 57,81 52.36,76.35 51.03,76.35 50.63,76.75 43.97,76.75 43.14,77.59 34.85,77.59 34.65,77.39 34.65,77.24 v1(34.88,77.01)
SW2_DP1_P1_C: length 3.1
  TOP w0.094: UT9.12 30.41,74.48 30.54,74.61 31.02,74.61 31.07,74.67 31.13,74.67 31.55,75.08 31.55,75.14 31.61,75.2 31.61,75.54 31.65,75.58 31.81,75.58 CT105.2
SW2_DP1_P2: length 155.8
  TOP w0.094: v1(35.67,78.33) 35.34,78.01 35.34,77.88 35.06,77.59 34.07,77.59 33.8,77.33 33.47,77.33 CT107.1 ; UV7.45 164.79,86.17 164.89,86.27 164.89,89.73 165.02,89.86 165.02,90.71 v1(164.63,91.11)
  IN1 w0.089: v1(164.63,91.11) 165.03,91.52 165.03,91.71 162.52,94.23 157.46,94.23 156.32,95.37 124.29,95.37 121.42,92.5 119.18,92.5 118.17,91.49 111.02,91.49 106.68,95.83 105.39,95.83 104.83,96.39 104.83,97.15 104.31,97.67 103.57,97.67 103,98.24 83.8,98.24 83.75,98.29 80.52,98.29 78.16,95.93 76.26,95.93 75.75,95.42 74.32,95.42 73.79,94.89 72.77,94.89 67.47,89.58 63.49,89.58 62.09,88.18 59.62,88.18 54.03,82.6 54.03,80.82 52.25,79.04 50.47,79.04 49.86,78.43 41.26,78.43 40.57,79.11 37.82,79.11 37.62,78.91 35.59,78.91 35.49,78.81 35.49,78.51 v1(35.67,78.33)
SW2_DP1_P2_C: length 3.7
  TOP w0.094: UT9.15 30.49,75.68 30.59,75.78 30.94,75.78 31.49,76.33 31.49,76.46 31.52,76.49 31.52,77.09 31.49,77.12 31.49,77.17 31.68,77.36 31.89,77.36 CT107.2
SW2_DP1_P3: length 155.8
  TOP w0.094: UV7.42 165.99,86.17 166.09,86.28 166.09,90.05 166.23,90.18 166.23,90.77 v1(165.83,91.17) ; CT109.1 33.5,79.14 33.76,79.14 34.02,78.88 34.65,78.88 34.86,79.09 34.86,79.4 v1(35.06,79.6)
  IN1 w0.089: v1(35.06,79.6) 34.88,79.78 34.88,79.98 35.03,80.13 46.38,80.13 46.53,79.98 49.13,79.98 53.08,83.93 54.09,83.93 59.06,88.89 61.98,88.89 65.33,92.25 67.16,92.25 69.19,94.28 71.35,94.28 72.55,95.47 73.56,95.47 74.88,96.79 76.99,96.79 79.07,98.88 84.13,98.88 84.18,98.83 103.33,98.83 103.89,98.27 104.55,98.27 105.26,97.56 106.76,97.56 107.39,96.92 107.39,95.93 108.11,95.22 108.87,95.22 112.02,92.07 117.6,92.07 118.67,93.14 121.11,93.14 124.11,96.13 156.57,96.13 157.84,94.86 163.1,94.86 166.2,91.76 166.2,91.54 v1(165.83,91.17)
SW2_DP1_P3_C: length 4.2
  TOP w0.094: UT9.18 30.24,76.89 30.35,77 30.65,77 30.84,77.19 30.84,77.35 31.3,77.81 v4(31.3,78.29) 31.3,78.88 31.55,79.14 31.89,79.14 CT109.2
SW2_DP3_AUXN: length 144.9
  TOP w0.094: UV7.29 171.59,84.57 171.7,84.46 173.6,84.46 174.3,85.17 174.68,85.17 174.86,85.34 RV72.1 175.34,85.16 176.74,85.16 v1(176.94,85.36) ; v1(281.97,42.97) 281.8,43.14 281.8,43.33 CV112.1
  IN1 w0.089: v1(176.94,85.36) 177.14,85.16 177.34,85.16 177.54,84.97 177.54,76.51 185.96,68.09 185.96,63.7 187.48,62.18 187.48,60.22 201.58,46.12 202.52,46.12 204.78,43.86 207.67,43.86 208.48,43.06 209.89,43.06 210.15,43.32 217.12,43.32 218.51,41.93 231.16,41.93 231.5,42.26 233.51,42.26 234.11,42.87 237.95,42.87 239.81,44.73 242.35,44.73 244.36,46.74 246.74,46.74 247.02,47.01 247.86,47.01 248.16,46.71 250.55,46.71 251.19,47.34 252.99,47.34 255.51,44.82 267.13,44.82 267.45,44.5 268.66,44.5 269.5,43.66 270.97,43.66 271.2,43.89 276.94,43.89 277.35,44.3 281.28,44.3 281.97,43.61 v1(281.97,42.97)
SW2_DP3_AUXN_C: length 3.2
  TOP w0.094: CV112.2 281.77,44.92 281.77,45.14 281.86,45.23 282.38,45.23 282.44,45.3 282.49,45.3 282.96,45.77 282.96,45.82 283.07,45.92 283.07,46.19 283.17,46.3 UV6.3
SW2_DP3_AUXP: length 144.8
  TOP w0.094: UV7.28 171.6,84.17 171.71,84.28 173.68,84.28 174.38,84.98 174.68,84.98 174.86,84.81 RV78.1 175.33,84.98 176.74,84.98 v1(176.94,84.78) ; v1(281.39,42.97) 281.61,43.19 281.61,43.28 CV111.1
  IN1 w0.089: v1(281.39,42.97) 281.79,43.37 281.79,43.53 281.21,44.12 277.42,44.12 277.01,43.71 271.27,43.71 271.05,43.48 269.42,43.48 268.59,44.32 267.38,44.32 267.05,44.64 255.43,44.64 252.91,47.16 251.26,47.16 250.63,46.53 248.09,46.53 247.78,46.83 247.09,46.83 246.82,46.56 244.43,46.56 242.42,44.55 239.88,44.55 238.03,42.69 234.19,42.69 233.58,42.08 231.57,42.08 231.24,41.74 218.43,41.74 217.04,43.14 210.23,43.14 209.97,42.88 208.41,42.88 207.6,43.68 204.71,43.68 202.44,45.94 201.5,45.94 187.3,60.14 187.3,62.1 185.78,63.62 185.78,68.02 177.36,76.44 177.36,84.89 177.27,84.98 177.14,84.98 v1(176.94,84.78)
SW2_DP3_AUXP_C: length 3.2
  TOP w0.094: CV111.2 281.58,44.92 281.58,45.22 281.79,45.42 282.3,45.42 v4(282.54,45.66) 282.88,46 282.88,46.19 282.77,46.3 UV6.2
SW2_DP3_CADET: length 2.8
  TOP w0.102: v2(170.59,87.47) RV75.1 169.59,87.46 UV7.33
SW2_DP3_HPD: length 165.4
  TOP w0.102: UV7.38 167.59,88.58 168.49,89.48 171.54,89.48 173.35,87.67 177.15,87.67 v2(178.23,86.59) v1(179,85.82) ; UV6.32 280.9,47.41 RV102.1 279.84,45.84 v1(279.71,45.72)
  IN2 w0.122: v1(179,85.82) 179,83.06 181.15,80.91 181.15,76.12 187.21,70.07 187.21,65.41 189.23,63.39 189.23,60.89 192.8,57.31 192.8,56.77 201.9,47.67 204.54,47.67 206.27,45.94 209.57,45.94 210.36,45.15 212.46,45.15 213.09,44.52 224.31,44.52 224.84,45.04 227.66,45.04 228.53,45.91 230.1,45.91 230.97,46.78 232.49,46.78 232.87,47.16 233.86,47.16 234.74,48.05 235.46,48.05 236.94,49.53 237.63,49.53 238.7,50.59 239.16,50.59 240.68,52.12 242.24,52.12 242.74,52.61 244.32,52.61 247.52,55.82 249.05,55.82 255.08,61.85 257.47,61.85 258.77,63.14 261.8,63.14 263.1,61.85 266.06,61.85 267.72,60.18 269.61,60.18 272.57,57.22 275.62,57.22 277.17,55.67 277.17,52.75 277.85,52.07 277.85,48.76 279.91,46.71 279.91,46.22 279.71,46.02 v1(279.71,45.72)
SW2_DP3_N0: length 175.6
  TOP w0.094: v1(284.38,40.91) 284.18,41.11 284.18,41.61 284.82,42.24 284.82,43.31 CV108.1 ; v1(197.3,45.5) 197.02,45.5 196.02,44.5 191.06,44.5 188.19,47.37 v4(188.19,50.21) 188.19,51.44 184.58,55.05 184.58,61.65 183.06,63.17 183.06,64.25 178.52,68.8 178.52,83.59 179.48,84.55 179.48,86.15 176.61,89.02 172.67,89.02 171.17,90.52 167.7,90.52 167.08,89.9 167.08,86.29 167.19,86.18 167.19,85.66
  IN4 w0.089: v1(197.3,45.5) 197.3,45.81 197.46,45.97 198.81,45.97 201.45,43.33 203.66,43.33 204.83,42.16 206.1,42.16 207.7,40.56 208.97,40.56 210.57,38.96 211.05,38.96 212.45,37.56 220.58,37.56 220.98,37.97 226.68,37.97 227.24,37.41 232.25,37.41 233.93,35.73 235.34,35.73 235.69,35.38 236.63,35.38 236.84,35.17 238.74,35.17 239.35,34.57 250.52,34.57 251.52,33.57 255.2,33.57 256.65,35.03 256.65,35.99 257.18,36.52 259.79,36.52 260.51,37.23 262.92,37.23 263.45,37.76 263.45,38.43 264.49,39.47 265.1,39.47 265.71,38.86 267.07,38.86 267.28,38.65 267.76,38.65 267.97,38.86 271.53,38.86 271.98,39.31 272.96,39.31 272.99,39.34 275.83,39.34 277.23,40.74 277.82,40.74 278.26,40.29 278.26,39.48 278.8,38.94 282.24,38.94 283.14,39.85 283.62,39.85 284.18,40.41 284.18,40.71 v1(284.38,40.91)
SW2_DP3_N0_C: length 2.6
  TOP w0.094: UV6.6 284.37,46.3 284.27,46.19 284.27,45.96 284.75,45.48 284.75,45.43 284.82,45.36 284.82,44.92 CV108.2
SW2_DP3_N1: length 168.5
  TOP w0.094: UV7.36 168.39,86.17 168.28,86.28 168.28,88.33 168.77,88.82 171.24,88.82 173.1,86.97 176.05,86.97 177.37,85.64 177.37,68.91 182.43,63.85 182.43,62.91 183.98,61.36 183.98,54.62 187.35,51.25 187.35,47.11 v4(188.98,45.48) 190.64,43.82 197.83,43.82 198.25,44.24 v1(198.54,44.24) ; v1(286.8,42.05) 286.6,42.25 286.6,43.31 CV110.1
  IN4 w0.089: v1(198.54,44.24) 198.54,44.56 198.73,44.75 199.22,44.75 201.22,42.74 203.36,42.74 204.68,41.42 205.57,41.42 207.12,39.87 208.84,39.87 210.36,38.35 210.77,38.35 212.24,36.89 217.04,36.89 217.66,36.27 226.34,36.27 226.45,36.17 232.45,36.17 233.47,35.14 235.09,35.14 235.44,34.79 236.4,34.79 236.63,34.56 238.21,34.56 238.79,33.98 249.97,33.98 251.01,32.94 255.45,32.94 257.67,35.15 257.82,35.15 258.6,35.93 260.1,35.93 260.81,36.65 262.79,36.65 263.07,36.37 263.25,36.37 263.4,36.22 274.78,36.22 274.88,36.11 276.03,36.11 276.53,36.62 278.72,36.62 279.28,37.19 281.31,37.19 283.14,39.01 284,39.01 286.59,41.6 286.59,41.85 v1(286.8,42.05)
SW2_DP3_N1_C: length 3.6
  TOP w0.094: CV110.2 286.6,44.92 286.6,45.47 286.11,45.95 286.03,45.95 285.99,45.99 285.43,45.99 285.41,45.97 285.16,45.97 285.07,46.06 285.07,46.2 285.17,46.3 UV6.8
SW2_DP3_P0: length 175.7
  TOP w0.094: CV107.1 284.63,43.31 284.63,42.32 284,41.68 284,41.11 v1(283.8,40.91) ; UV7.40 166.79,86.18 166.89,86.29 166.89,89.98 167.63,90.71 171.25,90.71 172.75,89.21 176.69,89.21 179.67,86.23 179.67,84.48 178.7,83.51 178.7,68.87 183.25,64.33 183.25,63.24 184.76,61.73 184.76,55.13 188.38,51.51 188.38,50.54 188.41,50.5 188.41,49.92 188.38,49.89 188.38,47.44 191.14,44.68 195.94,44.68 196.89,45.63 v1(196.89,45.91)
  IN4 w0.089: v1(283.8,40.91) 284,40.71 284,40.48 283.54,40.03 283.06,40.03 282.16,39.12 278.87,39.12 278.44,39.56 278.44,40.37 277.89,40.92 277.16,40.92 275.76,39.52 272.91,39.52 272.88,39.49 271.91,39.49 271.45,39.04 267.89,39.04 267.68,38.83 267.35,38.83 267.14,39.04 265.79,39.04 265.18,39.65 264.42,39.65 263.27,38.5 263.27,37.84 262.85,37.41 260.43,37.41 259.72,36.7 257.1,36.7 256.47,36.06 256.47,35.1 255.12,33.76 251.59,33.76 250.6,34.75 239.42,34.75 238.82,35.35 236.91,35.35 236.71,35.56 235.77,35.56 235.42,35.91 234.01,35.91 232.33,37.59 227.31,37.59 226.75,38.15 220.91,38.15 220.5,37.74 212.53,37.74 211.13,39.14 210.64,39.14 209.04,40.74 207.78,40.74 206.18,42.34 204.91,42.34 203.74,43.51 201.53,43.51 198.89,46.15 197.39,46.15 197.15,45.91 v1(196.89,45.91)
SW2_DP3_P0_C: length 2.6
  TOP w0.094: CV107.2 284.63,44.92 284.63,45.28 v4(284.38,45.53) 284.08,45.83 284.08,46.19 283.97,46.3 UV6.5
SW2_DP3_P1: length 168.5
  TOP w0.094: v1(198.13,44.66) 198.13,44.38 197.75,44 190.72,44 189.34,45.38 189.34,45.43 188.93,45.84 188.88,45.84 187.53,47.19 187.53,51.33 184.16,54.7 184.16,61.44 182.61,62.99 182.61,63.93 177.56,68.98 177.56,85.72 176.13,87.15 173.17,87.15 171.32,89.01 168.69,89.01 168.09,88.41 168.09,86.27 167.99,86.17 UV7.37 ; v1(286.21,42.05) 286.41,42.25 286.41,43.31 CV109.1
  IN4 w0.089: v1(286.21,42.05) 286.41,41.85 286.41,41.68 283.92,39.19 283.06,39.19 281.24,37.37 279.21,37.37 278.64,36.8 276.46,36.8 275.95,36.3 274.96,36.3 274.86,36.4 263.47,36.4 263.32,36.55 263.15,36.55 262.87,36.83 260.74,36.83 260.02,36.11 258.53,36.11 257.74,35.33 257.59,35.33 255.38,33.12 251.08,33.12 250.04,34.16 238.86,34.16 238.28,34.74 236.71,34.74 236.48,34.97 235.51,34.97 235.16,35.33 233.55,35.33 232.53,36.35 226.52,36.35 226.42,36.45 217.73,36.45 217.11,37.07 212.31,37.07 210.85,38.53 210.44,38.53 208.92,40.05 207.19,40.05 205.65,41.6 204.76,41.6 203.43,42.92 201.3,42.92 199.29,44.93 198.66,44.93 198.38,44.66 v1(198.13,44.66)
SW2_DP3_P1_C: length 3.6
  TOP w0.094: CV109.2 286.41,44.92 286.41,45.39 286.04,45.77 v4(285.7,45.77) 285.09,45.77 284.88,45.98 284.88,46.19 284.77,46.3 UV6.7
SW2_PS8338_CFG0: length 5.5
  TOP w0.102: UV7.59 160.56,81.77 RV88.1 RV87.1 160.04,80.45 159.58,80.91 158.01,80.91 v2(157.9,80.81)
SW2_PS8338_P0: length 6.1
  TOP w0.102: v2(158.09,79.14) 158.13,79.1 159.69,79.1 RV96.1 RV95.1 160.15,79.57 161.22,80.64 161.22,81.02 161.57,81.37 UV7.60
SW2_PS8338_P1: length 4.7
  TOP w0.102: v2(160.21,77.61) 160.21,77.9 161.18,78.86 RV93.1 RV94.1 162.11,79.5 162.79,80.18 UV7.1
SW2_PS8338_PC10: length 5.7
  TOP w0.102: UV7.56 160.54,82.97 RV86.1 159.69,82.9 158.83,82.9 158.37,83.36 RV85.1 v2(157.99,82.27)
SW2_PS8338_PC11: length 4.9
  TOP w0.102: UV7.55 161.09,83.37 RV84.1 159.68,84.78 158.46,84.78 RV83.1
SW2_PS8338_PC20: length 5.4
  TOP w0.102: UV7.54 161.14,83.77 160.58,84.33 160.58,84.83 RV82.1 159.67,85.75 158.47,85.75 RV81.1
SW2_PS8338_PC21: length 7.1
  TOP w0.102: v2(157.99,87.33) RV79.1 158.49,86.71 159.66,86.71 RV80.1 160.81,85.56 160.81,84.43 161.07,84.17 UV7.53
SW2_PS8338_PEQ: length 4.9
  TOP w0.102: UV7.8 165.59,79.25 165.43,79.09 165.43,76.99 165.54,76.88 RV90.1 RV89.1
SW2_PS8338_SW: length 6.1
  TOP w0.102: RV91.1 RV92.1 169.93,76.83 170.87,77.77 170.87,78.58 v2(170.75,78.7) 170.03,79.42 169.85,79.42 169.59,79.69 UV7.18
SW_+1VALWP: length 6.4
  TOP w0.102: v3(157.15,98.14) PR303.1
  IN1 w1.016: 157.47,101.65 157.48,101.65 157.89,102.05 157.89,104.61 159.01,105.72
  vias: v1(156.54,101.22) v1(156.87,100.67) v1(159.39,107.23) v1(159.38,106.64)
SW_USB20_N9: length 2.1
  TOP w0.094: UI3.11 276.91,27.88 276.75,27.72 276.75,27.51 276.63,27.38 276.63,26.83 276.83,26.63 LI7.1
SW_USB20_P9: length 2.1
  TOP w0.094: LI7.4 276.23,26.63 276.44,26.83 276.44,27.46 276.57,27.59 276.57,27.72 276.41,27.88 UI3.10
SYS_PWROK: length 234.4
  TOP w0.102: RE56.1 254.89,42.95 RE548.1 253.95,42.95 253.55,43.35 253.55,43.46 v1(253.41,43.6) ; v1(117.81,96.03) 117.81,95.98 116.9,95.07 v3(116.9,91.99) 116.9,88.69 118.06,87.52 136.48,87.52 141.96,82.04 141.96,79.83 141.43,79.29 141.43,78.38 142.22,77.59 142.22,77.11 v1(142.38,76.96)
  IN1 w0.089: v1(117.81,96.03) 117.4,95.63 110.27,95.63 106.72,99.18 105.57,99.18 104.34,100.42 92.75,100.42 v1(92.26,99.92) ; v1(248,37.7) 247.48,37.7 245.61,39.58 244.01,39.58 243.81,39.38 241.98,39.38 240.8,38.2 236.29,38.2 234.82,36.73 233.37,36.73 232.49,35.85 227.75,35.85 227.03,36.57 213.36,36.57 211.74,38.2 209.59,38.2 209.14,38.65 208.13,38.65 207.78,39.01 206.96,39.01 205.95,40.03 203.45,40.03 202.29,41.19 201.12,41.19 200.14,42.17 197.98,42.17 195.69,44.47 193.95,44.47 192.62,45.8 191.32,45.8 180.24,56.87 180.24,57.65 179.23,58.67 179.23,62.11 178.35,62.99 178.35,64.09 172.63,69.81 165.99,69.81 164.94,70.86 160.43,70.86 158.32,72.97 155.43,72.97 149.69,78.71 147.58,78.71 146.73,79.56 145.59,79.56 145.25,79.22 144.86,79.22 142.61,76.96 v1(142.38,76.96)
  IN2 w0.122: v1(253.41,43.6) 253.25,43.44 253.25,41.51 249.51,37.77 248.65,37.77 248.58,37.7 v1(248,37.7)
  BOTTOM w0.076: 141.65,75.11 140.98,74.43 138.44,74.43 138.04,74.03 137.83,74.03 137.51,73.71 137.51,73.51 137.49,73.46 137.49,72.94 UC1.B6
  BOTTOM w0.102: v1(92.26,99.92) 91.8,100.38 88.52,100.38 88.22,100.07 88.22,95.91 87.38,95.07 87.38,94.08 87.15,93.85 87.15,92.6 87.63,92.12 88.52,92.12 88.78,92.38 88.78,93.41 RC129.1 ; 141.65,75.11 142.49,75.95 142.49,76.84 v1(142.38,76.96)
SYS_RESET#: length 129.6
  IN1 w0.089: v1(191.37,47.06) 191.37,47.74 181.69,57.42 181.69,58.95 180.74,59.9 180.74,62.23 179.76,63.21 179.76,64.69 173.49,70.96 167.93,70.96 167.09,71.8 162.77,71.8 162.16,72.41 160.26,72.41 157.92,74.75 154.98,74.75 149.02,80.72 145.11,80.72 v1(144.71,80.31)
  BOTTOM w0.076: 141.68,73.52 139.97,73.52 139.78,73.33 139.35,73.33 139.02,73 UC1.B5
  BOTTOM w0.102: 141.68,73.52 144.5,76.34 144.5,77.34 144.1,77.75 144.1,78.12 144.37,78.39 144.37,78.51 145.03,79.16 145.03,79.99 v1(144.71,80.31) 144.77,80.31 145.07,80.61 145.07,81.96 144.86,82.17 144.86,84.78 144.53,85.11 144.53,85.86 CC302.1 145.39,86.72 RC224.2 RC291.1 ; JAPS1.13 208.7,15.02 208.78,15.09 208.78,15.73 208.91,15.86 208.91,16.89 207.79,18.01 v2(207.79,19.83) 207.79,20.53 207.07,21.26 206.33,21.26 204.12,23.47 204.12,24.72 203.46,25.38 203.46,30.12 197.46,36.11 192.84,36.11 191.14,37.82 191.14,40.38 192.46,41.7 192.46,44.88 191.37,45.97 v1(191.37,47.06)
SYS_RESET#_R: length 6.3
  BOTTOM w0.102: RC290.2 151.08,87.12 151.08,86.65 v2(150.74,86.31) 149.91,86.31 149.58,86.64 148.64,86.64 148.27,87.01 UC12.4 146.87,87.01 RC224.1
SYSTEM_ID: length 13.3
  TOP w0.102: UE1.J10 266.42,47.68 v1(266.84,47.26) ; v1(275.9,46.53) 275.9,46.4 276.46,45.84 277.25,45.84 277.7,46.3 RE300.2 CE47.1
  BOTTOM w0.102: v1(266.84,47.26) 268.73,47.26 269.33,46.66 272.85,46.66 272.98,46.53 v2(274.88,46.53) v1(275.9,46.53)
TACH_FAN1: length 136.6
  TOP w0.076: UE1.E3 v1(261.2,50.56)
  TOP w0.102: v3(176.45,75.07) v1(176.45,74.38)
  IN2 w0.122: v1(246.23,50.14) 246.23,50.11 244.94,48.81 244.38,48.81 241.93,46.37 241.45,46.37 238.24,43.16 237.53,43.16 234.77,40.39 233.93,40.39 233.68,40.14 232.73,40.14 232.51,39.92 229.68,39.92 228.36,38.61 226.45,38.61 225.6,37.76 213.42,37.76 212.19,38.99 206.99,38.99 206.58,39.39 206.58,39.62 205.77,40.43 203.57,40.43 202.16,41.84 199.21,41.84 188.41,52.64 188.41,55.21 184.82,58.79 184.82,61.43 182.82,63.44 182.82,65.51 176.45,71.89 v1(176.45,74.38)
  IN4 w0.089: v1(246.23,50.14) 247.86,51.76 251.68,51.76 252.5,52.58 253.5,52.58 254.69,53.77 258.5,53.77 261.2,51.07 v1(261.2,50.56) ; v1(176.45,74.38) 176.45,79.05 179.99,82.6 179.99,88.46 v1(179.63,88.82)
  BOTTOM w0.102: v1(179.63,88.82) 179.67,88.86 RE51.2 180.01,90.1 180.01,89.2 180.11,89.1 180.11,88.68 JFAN1.3
TBT_FORCE_PWR: length 9
  BOTTOM w0.076: 141.29,75.43 140.66,74.8 138.31,74.8 137.34,73.84 137.34,73.55 137.3,73.43 137.3,73.22 UC1.B7
  BOTTOM w0.102: 141.29,75.43 141.97,76.11 141.97,77.24 142.12,77.39 142.68,77.39 143.02,77.05 T19.1
TBT_RESET_N_EC_R: length 8.6
  TOP w0.076: UE1.L8 265.31,45.65 265.31,44.4 265.48,44.22 265.73,44.22 265.87,44.22 266.47,43.62 266.47,43.14 266.77,42.85
  TOP w0.102: v2(267.14,38.83) RE95.2 266.65,40.33 266.65,41.09 266.78,41.22 266.78,42.83 266.77,42.85
TBTA_AUXN_C: length 6
  TOP w0.076: UT5.J2 25.69,63.94 25.44,64.19 25.44,64.41 23.68,66.18 23.17,66.18 23.16,66.16
  TOP w0.094: RT95.1 21.52,67.1 CT81.2 22.46,66.72 22.53,66.72 23.09,66.16 23.16,66.16
TBTA_AUXP_C: length 5.2
  TOP w0.076: 23.19,66.37 23.22,66.34 23.75,66.34 25.69,64.39 UT5.J1
  TOP w0.102: RT96.1 23.27,67.1 CT80.2 22.71,66.85 23.13,66.43 23.19,66.37
TBTA_BOT_N: length 22.3
  TOP w0.094: v1(17.78,72.41) 17.56,72.63 16.46,72.63 15.93,72.1 15.04,72.1 RT122.2 ; v1(19.8,61.11) 20.08,61.38 20.23,61.38 20.46,61.15 22.53,61.15 22.62,61.07 23.62,61.07 23.93,61.38 24.12,61.38 24.19,61.31 24.19,61.06 24.28,60.96 24.42,60.96 24.49,61.03 24.49,61.11 24.69,61.31
  IN1 w0.089: v1(19.8,61.11) 19.6,61.31 19.36,61.31 19.13,61.54 19.13,62.17 19.31,62.35 19.31,64.36 18.37,65.3 18.37,72.49 18.24,72.61 17.98,72.61 v1(17.78,72.41)
TBTA_BOT_N_R: length 8.6
  TOP w0.094: v1(6.83,71.11) 7.03,71.31 v4(9.63,71.31) 10.04,71.31 10.71,71.98 11.06,71.98 11.16,72.07 11.29,72.07 11.44,71.92 DT40.7 DT40.4 12.82,71.92 13,72.1 13.42,72.1 RT122.1
  BOTTOM w0.094: JUSBC1.B7 6.38,71.11 6.57,71.29 6.65,71.29 v1(6.83,71.11)
TBTA_BOT_P: length 22.3
  TOP w0.076: 24.41,61.56 24.94,61.56 UT5.K7
  TOP w0.094: RT123.2 15.04,72.29 15.85,72.29 16.38,72.82 17.61,72.82 v1(17.78,73) ; v1(19.8,61.69) 19.93,61.57 20.3,61.57 20.54,61.33 22.61,61.33 22.69,61.25 23.54,61.25 23.85,61.56 24.41,61.56
  IN1 w0.089: v1(19.8,61.69) 19.6,61.49 19.44,61.49 19.31,61.62 19.31,62.1 19.49,62.28 19.49,64.44 18.55,65.38 18.55,72.56 18.32,72.79 17.99,72.79 v1(17.78,73)
TBTA_BOT_P_R: length 8.6
  TOP w0.094: v1(6.82,71.7) 6.83,71.7 7.03,71.5 9.31,71.5 9.34,71.53 9.99,71.53 10.63,72.17 10.98,72.17 11.08,72.26 11.28,72.26 11.44,72.42 DT40.6 DT40.5 12.85,72.42 12.98,72.28 13.42,72.28 RT123.1
  BOTTOM w0.094: JUSBC1.B6 6.38,71.61 6.51,71.48 6.6,71.48 v1(6.82,71.7)
TBTA_CC1: length 31.6
  TOP w0.076: 20.74,58.9 v1(21.01,59.18)
  TOP w0.102: 20.74,58.9 20.35,58.52 v2(19.64,58.52)
  TOP w0.254: v1(21.01,59.18) 21.39,59.18 CT86.1 RT104.2 22.87,59.27 22.95,59.27 23.99,60.31 24.69,60.31
  IN2 w0.508: v1(21.01,59.18) 21.35,59.18 21.66,59.48 21.66,63.47 21.1,64.03 20.02,64.03 16.77,67.28 15.4,67.28 14.76,67.92 14.76,68.7 15.7,69.64 v1(15.7,72.72)
  BOTTOM w0.203: 10.75,72.13 10.93,72.32 DT39.2
  BOTTOM w0.254: JUSBC1.A5 8.13,70.86 8.34,71.07 9.68,71.07 10.75,72.13
  BOTTOM w0.508: v1(15.7,72.72) 15.3,72.31 13.52,72.31
TBTA_CC2: length 43.2
  TOP w0.254: 24.69,59.81 24.38,59.81 23.66,59.09 23.66,58.39 23.51,58.24 23.51,57.95 22.7,57.15 RT105.2 CT85.1 21.1,57.15 v1(20.74,56.78)
  IN2 w0.508: v1(14.96,70.51) 14.96,69.8 14.13,68.97 14.13,68.42 12.7,67 12.7,64.59 13.07,64.22 13.07,61.83 18.12,56.78 v1(20.74,56.78) ; v1(10.88,71.57) 11.31,71.57 11.77,71.11 11.77,69.53 10.38,68.14 9.66,68.14 9.3,68.5 9.3,68.88 8.79,69.39 8.11,69.39 7.48,70.01 7.48,71.87 7.07,72.28 v1(6.79,72.28)
  BOTTOM w0.203: v1(10.88,71.57) 11.12,71.82 DT39.1 DT39.9 12.99,71.82 13.14,71.67 13.31,71.67
  BOTTOM w0.254: JUSBC1.B5 6.56,72.11 6.73,72.28 6.79,72.28 v1(6.79,72.28)
  BOTTOM w0.508: 13.31,71.67 v2(14.8,71.67) 15.01,71.67 15.37,71.32 15.37,70.91 v1(14.96,70.51)
TBTA_DBG_CTL1: length 6.3
  TOP w0.076: UT5.E4 27.69,62.99 v1(27.99,63.29)
  TOP w0.127: RT106.1 28.71,67.79 v1(28.5,67.99)
  IN1 w0.099: v1(28.5,67.99) 28.5,64.21 28,63.7 v1(28,63.29)
TBTA_DBG_CTL2: length 8.9
  TOP w0.076: UT5.D5 28.22,62.31 v1(28.55,62.64)
  TOP w0.127: v1(28.5,68.63) 28.6,68.72 v2(29,68.72) 29.19,68.72 RT107.1
  IN1 w0.099: v1(28.55,62.64) 29.04,63.12 29.04,68.09 v1(28.5,68.63)
TBTA_DEBUG1: length 2.9
  TOP w0.102: 24.69,63.81 24.64,63.86 24.03,63.86 23.7,64.19 23.67,64.19 23.41,64.44 v2(23.19,64.44) 22.73,64.44 RT92.2
TBTA_DEBUG2: length 3.5
  TOP w0.076: 22.73,64.97 23.1,64.97 23.32,64.74 23.42,64.74 24.11,64.06 24.88,64.06 25.13,63.81 UT5.K2
  TOP w0.102: RT93.2 22.51,64.97 22.73,64.97
TBTA_DEBUG3: length 9
  TOP w0.102: 22.73,62.39 22.76,62.42 22.76,63.03 v1(22.84,63.1) 22.84,63.22 23.17,63.55 23.68,63.55 23.71,63.51 24.32,63.51 24.52,63.31 24.69,63.31 ; RT406.2 v1(20.38,66.72)
  TOP w0.127: 22.73,62.39 22.53,62.19 RT89.2
  IN2 w0.122: v1(22.84,63.1) 22.65,63.1 21.39,64.36 21.39,65.79 20.46,66.72 v1(20.38,66.72)
TBTA_DEBUG4: length 31.6
  TOP w0.076: UT5.K3 25.12,63.31 24.87,63.56 24.54,63.56 24.41,63.69 23.92,63.69 23.67,63.94 v1(23.37,63.94) 23.05,63.94 22.79,63.67
  TOP w0.102: v2(18.41,78.65) v1(18.41,78.09) 18.67,77.82 RT407.2 17.78,76.37 RT418.1
  TOP w0.127: 22.79,63.67 22.25,63.14 RT90.1
  IN3 w0.122: v1(18.41,78.09) 16.88,76.56 16.88,73.2 16.12,72.44 16.12,67.8 14.72,66.4 v1(14.72,64.37)
  BOTTOM w0.102: v1(23.37,63.94) 23.35,63.94 21.9,65.39 18.85,65.39 17.45,63.99 15.1,63.99 v1(14.72,64.37)
TBTA_LSRX_R: length 17.3
  TOP w0.076: UT5.K4 24.94,63.06 24.46,63.06 24.18,63.33 23.6,63.33 v1(23.42,63.15)
  BOTTOM w0.102: v1(23.42,63.15) 23.6,63.15 24.36,63.92 24.36,68.93 25.46,70.02 25.46,73.79 v2(23.96,75.28) 23.67,75.57 23.27,75.57 RT88.2
TBTA_LSTX_R: length 15.4
  TOP w0.102: 24.69,62.81 24.09,62.81 v1(23.97,62.94)
  BOTTOM w0.102: v1(23.97,62.94) 24.82,63.79 24.82,68.63 25.73,69.54 25.73,74.09 v2(25.12,74.71) 25.12,75.21 RT87.2
TBTA_MRESET: length 2.7
  TOP w0.076: UT5.E11 27.69,59.13 27.87,58.95 27.87,58.89
  TOP w0.102: 27.87,58.89 27.87,58.5 v2(28.32,58.05) 28.88,57.48 RT86.1
TBTA_ROM_CLK_PD: length 29.3
  TOP w0.076: UT5.A3 29.81,63.31 30.05,63.55 30.64,63.55 30.66,63.52 v1(30.78,63.52)
  IN4 w0.089: v1(49.66,75.99) 48.38,75.99 46.22,73.83 44.34,73.83 39.5,69 39.26,69 36.37,66.11 35.81,66.11 33.88,64.18 31.44,64.18 v1(30.78,63.52)
  BOTTOM w0.102: v1(49.66,75.99) v2(49.66,73.36) 49.66,72.87 RT54.2
TBTA_ROM_CLK_PD_R: length 44.3
  BOTTOM w0.102: JDB1.2 26.48,78.2 27.17,78.89 30.33,78.89 30.49,79.05 31.06,79.05 34.2,82.19 35.74,82.19 36.92,83.37 38.59,83.37 41.42,80.54 47.68,80.54 v2(48.44,79.78) 49.15,79.07 49.15,71.73 49.61,71.27 RT54.1 50.37,71.27 51.62,70.02 51.62,68.25 51.24,67.86 48.44,67.86 47.93,67.36 UT6.6
TBTA_ROM_CS#_PD: length 5.5
  TOP w0.076: UT5.B3 29.44,63.56 29.82,63.56 30.2,63.94 30.96,63.94 31.18,63.72 31.18,63.67 31.2,63.65 31.2,63.64 31.32,63.52 31.45,63.52
  TOP w0.102: RT57.2 33.77,63.84 33.14,63.84 32.82,63.52 31.45,63.52
TBTA_ROM_CS#_PD_R: length 46.2
  TOP w0.102: v1(35.54,63.85) 35.28,63.6 RT57.1
  IN1 w0.089: v1(35.54,63.85) 35.92,64.23 37.22,64.23 38.75,65.77 38.75,66.94 39.04,67.23 40.44,67.23 40.95,66.72 52.76,66.72 53.01,66.98 53.27,66.98 53.9,67.61 53.9,68.59 v1(53.45,69.05)
  BOTTOM w0.102: v1(53.45,69.05) 53.55,69.15 53.55,69.72 53.73,69.9 UT6.1 54.54,70.66 RT51.2 ; v1(35.54,63.85) 35.54,69.72 v2(34.22,71.04) 29.65,71.04 28.38,72.31 28.38,76.22 27.98,76.61 JDB1.5
TBTA_ROM_DI_PD: length 31.5
  TOP w0.076: v1(30.25,63.11) 30.19,63.06 29.44,63.06 UT5.B4
  IN4 w0.089: v1(50.25,75.92) 49.81,75.48 48.54,75.48 46.42,73.36 45.15,73.36 40.28,68.5 39.43,68.5 36.55,65.63 35.99,65.63 34.07,63.71 32.19,63.71 31.59,63.11 v1(30.25,63.11)
  BOTTOM w0.102: RT55.2 51.11,71.47 51.11,72.21 50.14,73.17 v2(50.14,75.27) 50.14,75.82 v1(50.25,75.92)
TBTA_ROM_DI_PD_R: length 46.7
  IN4 w0.089: v1(37.56,83.98) 37.18,83.6 v1(37.18,82.93)
  BOTTOM w0.102: v1(37.18,82.93) 35.95,81.7 34.4,81.7 31.26,78.57 30.69,78.57 30.53,78.4 27.37,78.4 26.98,78.02 JDB1.3 ; v1(37.56,83.98) 37.67,83.87 38.77,83.87 39.61,83.03 v2(45.24,83.03) 46.61,83.03 47.81,81.83 47.81,81.15 49.84,79.11 49.84,77.01 50.73,76.12 50.73,75.66 50.63,75.56 50.63,73.37 52.13,71.88 RT55.1 52.13,67.48 50.73,66.09 UT6.5
TBTA_ROM_DO_PD: length 30.6
  TOP w0.102: UT5.A4 29.77,62.73 30.45,62.73 30.79,63.08 31.13,63.08 31.26,63.21 31.42,63.21 33.24,63.21 v1(33.33,63.29)
  IN1 w0.089: v1(56.37,67.61) 55.3,67.61 53.52,65.83 39.55,65.83 37.44,63.72 37.01,63.72 36.33,63.04 33.93,63.04 33.67,63.29 v1(33.33,63.29)
  BOTTOM w0.102: v1(56.37,67.61) v2(56.37,68.22) 56.37,68.97 RT56.2
TBTA_ROM_DO_PD_R: length 57.1
  IN4 w0.089: v1(37.76,82.93) 37.76,83.12 38.13,83.49 v1(38.13,84.34)
  BOTTOM w0.102: JDB1.4 27.48,77.91 27.75,78.18 30.63,78.18 30.79,78.34 31.36,78.34 34.49,81.48 36.78,81.48 37.76,82.46 v1(37.76,82.93) ; UT6.2 53.01,68.63 52.63,68.25 52.63,66.09 53.23,65.49 56.23,65.49 56.57,65.83 56.57,66.39 57.37,67.19 57.37,68.36 57.5,68.49 RT56.1 RT52.2 57.5,71.46 56.65,72.31 52.73,72.31 52,73.04 52,76.12 50.86,77.26 50.86,79.82 47.32,83.36 v2(43.24,83.36) 39.61,83.36 38.63,84.34 v1(38.13,84.34)
TBTA_ROM_HOLD#_PD: length 3.3
  BOTTOM w0.102: UT6.7 45.78,68.63 RT50.2 v2(45.39,67)
TBTA_ROM_WP#_PD: length 5.9
  BOTTOM w0.102: RT53.2 55.86,70.81 55.86,68.68 UT6.3 55.54,67.36 v2(56.02,66.87)
TBTA_ROSC: length 3.5
  TOP w0.076: UT5.G2 26.44,64.06 26.44,64.7 25.89,65.25 25.89,65.36
  TOP w0.102: 25.89,65.36 v2(25.89,65.54) 25.89,65.88 26.09,66.09 26.09,66.79 RT100.1
TBTA_RX1N: length 30
  TOP w0.102: UT9.31 25.12,76.89 24.97,77.04 23.27,77.04 23.07,77.25 22.67,77.25 v1(22.36,76.93) ; v1(6.76,69.31) 7.12,68.95 7.5,68.95 8.19,68.26 10.71,68.26 DT14.1 11.1,68.25 11.26,68.25 11.37,68.35 11.37,68.86 11.97,69.46 16.43,69.46 v1(16.74,69.77)
  IN1 w0.089: v1(16.74,69.77) 16.37,69.4 16.08,69.4 15.97,69.51 15.97,70.39 15.3,71.07 15.3,73.35 19.25,77.3 21.99,77.3 v1(22.36,76.93)
  BOTTOM w0.102: JUSBC1.B10 6.37,69.61 6.66,69.31 v1(6.76,69.31)
TBTA_RX1P: length 30
  TOP w0.102: v1(22.36,77.52) 22.38,77.49 23.17,77.49 23.38,77.28 UT9.30 ; v1(16.74,69.19) 16.72,69.21 12.07,69.21 11.61,68.75 11.61,68.25 11.37,68 11.11,68 DT13.1 10.67,68.02 8.09,68.02 7.4,68.7 v1(6.79,68.7)
  IN1 w0.089: v1(16.74,69.19) 15.99,69.19 15.75,69.43 15.75,70.31 15.08,70.98 15.08,73.44 19.16,77.52 v1(22.36,77.52)
  BOTTOM w0.102: JUSBC1.B11 6.38,69.11 v1(6.79,68.7)
TBTA_RX2N: length 21.7
  TOP w0.102: v1(23.65,72.34) 23.86,72.56 23.86,72.87 24.11,73.12 24.51,73.12 25,73.6 25.29,73.6 25.37,73.68 UT9.39
  BOTTOM w0.102: v1(23.65,72.34) 23.82,72.51 23.82,72.88 23.63,73.07 20.79,73.07 19.41,74.45 15.73,74.45 14.79,75.39 11.81,75.39 DT9.1 11.39,75.37 10.38,75.37 8.49,73.48 8.18,73.48 8.06,73.36 JUSBC1.A10
TBTA_RX2P: length 21.7
  TOP w0.102: v1(24.24,72.34) 24.11,72.47 24.11,72.77 24.21,72.87 24.62,72.87 25.1,73.35 25.31,73.35 25.37,73.28 UT9.40
  BOTTOM w0.102: JUSBC1.A11 8.06,73.86 8.19,73.72 8.39,73.72 10.27,75.61 11.32,75.61 DT10.1 11.83,75.64 14.89,75.64 15.83,74.7 v4(17.64,74.7) 19.51,74.7 20.89,73.32 23.74,73.32 24.07,72.99 24.07,72.51 v1(24.24,72.34)
TBTA_SBU1: length 59.8
  TOP w0.102: v1(10.95,70.96) 10.98,70.92 DT40.8 DT40.2 13,70.92 13.37,70.55 14.1,70.55 14.24,70.68 14.24,70.89 v1(14.07,71.05) ; v1(25.84,82.01) RT132.2 ; v1(18.72,59.61) 18.85,59.48 RT108.1
  IN1 w0.089: v1(14.07,71.05) 14.25,71.24 14.25,76.16 17.13,79.04 18.88,79.04 20.78,80.95 25.92,80.95 26.17,81.2 26.17,81.68 v1(25.84,82.01)
  IN4 w0.089: v1(18.72,59.61) 18.53,59.8 18.23,59.8 18,60.03 18,63.49 19.72,65.2 19.72,66.93 20.57,67.78 20.57,80.44 21.48,81.35 26.12,81.35 26.18,81.42 26.18,81.67 v1(25.84,82.01) ; v1(10.95,70.96) 10.76,70.77 10.5,70.77 10.12,71.15 7.94,71.15 7.83,71.27 7.83,71.62 v1(8.36,72.16)
  BOTTOM w0.102: v1(8.36,72.16) 8.16,72.36 JUSBC1.A8
TBTA_SBU1_R: length 6.1
  TOP w0.076: UT5.K8 25.19,60.76 24.99,60.56 23.68,60.56 23.63,60.61 23.16,60.61 23.12,60.57 22.5,60.57 22.46,60.61 22.33,60.61 22.17,60.77 v4(21.53,60.77) 21.25,60.77 21.03,60.54 21.03,60.33 20.65,59.95 20.34,59.95 20.25,59.86 RT108.2
TBTA_SBU2: length 59.9
  TOP w0.102: RT109.1 18.85,60.37 v1(18.72,60.24) ; v1(10.95,70.37) 11,70.42 DT40.9 DT40.1 13.15,70.42 13.27,70.3 v4(13.86,70.3) 14.2,70.3 14.48,70.58 14.48,70.89 v1(14.65,71.05) ; v1(26.73,82.01) RT133.2
  IN1 w0.089: v1(14.65,71.05) 14.47,71.24 14.47,76.07 17.22,78.83 18.97,78.83 20.87,80.73 26,80.73 26.38,81.11 26.38,81.67 v1(26.73,82.01)
  IN4 w0.089: v1(10.95,70.37) 10.76,70.56 10.41,70.56 10.03,70.94 7.27,70.94 v1(6.84,70.51) ; v1(18.72,60.24) 18.5,60.02 18.32,60.02 18.22,60.12 18.22,63.4 19.93,65.11 19.93,66.84 20.78,67.69 20.78,80.35 21.57,81.14 26.21,81.14 26.39,81.33 26.39,81.68 v1(26.73,82.01)
  BOTTOM w0.102: v1(6.84,70.51) 6.74,70.61 JUSBC1.B8
TBTA_SBU2_R: length 5.2
  TOP w0.076: 24.69,60.81 24.61,60.72 23.75,60.72 23.7,60.77 v4(22.83,60.77) 22.4,60.77 22.24,60.93 21.87,60.93 21.83,60.98 21.23,60.98 20.86,60.61 20.86,60.4 20.58,60.12 20.5,60.12 RT109.2
TBTA_TOP_N: length 22.7
  TOP w0.076: 24.69,61.81 24.61,61.89 23.85,61.89 23.44,61.48 22.9,61.48 22.77,61.6 20.68,61.6 20.15,62.14 20.13,62.14 20.12,62.15
  TOP w0.094: 20.12,62.15 20.02,62.25 19.51,62.25 19.23,62.53 18.98,62.53 v1(18.72,62.28)
  IN1 w0.089: v1(18.72,62.28) 18.52,62.48 17.89,62.48 17.15,63.22 17.15,70.71 17.35,70.91 17.56,70.91 v1(17.78,71.14)
  BOTTOM w0.094: RT121.1 15.07,73.66 15.52,73.66 15.57,73.71 16.18,73.71 16.23,73.66 16.69,73.66 17.33,73.02 17.33,71.01 17.42,70.92 17.56,70.92 v1(17.78,71.14)
TBTA_TOP_N_R: length 7.6
  BOTTOM w0.094: RT121.2 13.42,73.68 12.93,73.68 12.8,73.82 DT39.6 DT39.5 11.29,73.82 11.13,73.66 10.9,73.66 10.6,73.36 10.6,72.9 v4(10.16,72.47) 9.39,71.7 9.25,71.7 9.22,71.73 8.58,71.73 8.54,71.7 8.19,71.7 8.03,71.86 JUSBC1.A7
TBTA_TOP_P: length 22.7
  TOP w0.076: UT5.K6 24.94,62.06 23.78,62.06 23.37,61.64 22.97,61.64 22.84,61.77 20.75,61.77 20.26,62.26 20.26,62.27 20.25,62.28
  TOP w0.094: 20.25,62.28 20.1,62.44 19.59,62.44 19.31,62.72 18.92,62.72 v1(18.72,62.91)
  IN1 w0.089: v1(18.72,62.91) 18.47,62.66 17.96,62.66 17.33,63.29 17.33,70.63 17.43,70.73 17.56,70.73 v1(17.78,70.51)
  BOTTOM w0.094: v1(17.78,70.51) 17.56,70.73 17.34,70.73 17.14,70.93 17.14,72.94 16.62,73.47 16.16,73.47 16.11,73.52 15.93,73.52 v4(15.88,73.47) 15.01,73.47 RT120.1
TBTA_TOP_P_R: length 7.6
  BOTTOM w0.094: RT120.2 13.42,73.5 12.95,73.5 12.77,73.32 DT39.7 DT39.4 11.29,73.32 11.13,73.48 10.98,73.48 10.78,73.28 10.78,72.83 10.52,72.56 10.52,72.52 10.11,72.11 10.06,72.11 9.47,71.51 v4(8.87,71.51) 8.2,71.51 8.04,71.36 JUSBC1.A6
TBTA_TX1N: length 18
  TOP w0.102: UT9.34 25.32,75.68 25.18,75.82 24.43,75.82 23.94,76.32 23.82,76.32 v1(23.49,75.98)
  IN1 w0.089: v1(16.69,71.6) 16.37,71.28 16.25,71.28 16.11,71.42 16.11,72.21 16.32,72.42 16.32,73.21 19,75.89 22.43,75.89 22.83,76.29 23.18,76.29 v1(23.49,75.98)
  BOTTOM w0.102: CT96.1 14.97,69.69 15.57,69.69 15.91,70.03 15.91,70.82 v4(16.16,71.07) 16.35,71.26 v1(16.69,71.6)
TBTA_TX1N_C: length 6.7
  BOTTOM w0.102: CT96.2 13.41,70.27 13.14,70.27 DT6.1 12.72,70.28 12.41,70.28 11.62,69.49 v4(9.35,69.49) 8.84,69.49 8.59,69.74 8.13,69.74 8.02,69.86 JUSBC1.A3
TBTA_TX1P: length 18
  TOP w0.102: v1(23.49,76.57) 23.71,76.57 23.72,76.56 24.04,76.56 24.53,76.07 25.31,76.07 25.32,76.08 UT9.33
  IN1 w0.089: v1(16.69,71.01) 16.64,71.07 16.16,71.07 15.89,71.33 15.89,72.3 16.11,72.51 16.11,73.3 18.91,76.1 22.34,76.1 22.74,76.5 23.42,76.5 v1(23.49,76.57)
  BOTTOM w0.102: v1(16.69,71.01) 16.46,71.01 16.16,70.72 16.16,69.93 15.68,69.45 14.86,69.45 14.48,69.84 CT95.1
TBTA_TX1P_C: length 6.7
  BOTTOM w0.102: CT95.2 13.42,70.02 13.13,70.02 DT5.1 12.72,70.03 12.51,70.03 11.72,69.24 v4(10.65,69.24) 8.74,69.24 8.49,69.5 8.2,69.5 8.06,69.36 JUSBC1.A2
TBTA_TX2N: length 15
  TOP w0.102: UT9.36 25.37,74.89 25.29,74.81 24.95,74.81 24.81,74.94 23.46,74.94 23.18,74.66 23.18,74.39 v1(23,74.21) ; v1(16.04,75.73) 15.88,75.9 14.66,75.9 14.15,75.39 13.08,75.39 CT98.1
  BOTTOM w0.102: v1(23,74.21) 23.17,74.38 23.17,74.53 23.05,74.65 20.49,74.65 19.25,75.9 16.21,75.9 v1(16.04,75.73)
TBTA_TX2N_C: length 7.6
  TOP w0.102: CT98.2 12.13,75.38 11.8,75.38 DT18.1 11.31,75.44 10.17,75.44 v4(9.32,74.59) 8.89,74.16 7.99,74.16 7.47,73.64 6.99,73.64 v1(6.8,73.45)
  BOTTOM w0.102: v1(6.8,73.45) 6.66,73.45 6.31,73.11 JUSBC1.B3
TBTA_TX2P: length 15
  TOP w0.102: v1(23.58,74.21) 23.42,74.38 23.42,74.55 23.57,74.7 24.71,74.7 24.85,74.56 25.29,74.56 25.37,74.48 UT9.37 ; CT97.1 13.1,75.64 14.05,75.64 14.56,76.15 15.88,76.15 v1(16.04,76.31)
  BOTTOM w0.102: v1(23.58,74.21) 23.42,74.38 23.42,74.49 23.42,74.63 23.15,74.9 20.6,74.9 19.35,76.15 16.21,76.15 v1(16.04,76.31)
TBTA_TX2P_C: length 7.6
  TOP w0.102: CT97.2 12.1,75.63 11.84,75.63 DT17.1 11.4,75.69 v4(10.66,75.69) 10.07,75.69 8.79,74.41 7.89,74.41 7.36,73.88 6.98,73.88 v1(6.83,74.04)
  BOTTOM w0.102: v1(6.83,74.04) 6.4,73.61 JUSBC1.B2
TDI_XDP: length 43.3
  TOP w0.102: v1(106.29,95.42) 106.29,95.51 105.92,95.88 RC229.1 105.54,95.88 104.65,96.78 UC8.5 ; v1(96.58,107.74) 97.03,108.2 97.39,108.2 98.71,106.88 102.85,106.88 103.83,105.9 104.61,105.9 105.08,106.37 v2(106.61,106.37) 107.41,107.17 v1(107.41,107.77)
  IN2 w0.122: v1(88.64,106.43) 89.82,107.62 92.83,107.62 94.23,109.03 95.85,109.03 96.58,108.3 v1(96.58,107.74)
  BOTTOM w0.102: v1(106.29,95.42) 107.5,96.63 107.5,101.77 106.94,102.33 106.94,103.09 107.8,103.96 107.8,107.37 v1(107.41,107.77) ; v1(88.64,106.43) 89.64,105.43 JXDP1.56
TDO_XDP: length 45.8
  TOP w0.102: v1(106.36,107.78) v2(105.4,108.74) 105.04,109.1 101.6,109.1 v1(100.93,109.76) ; UC8.2 103.15,95.91 RC230.1 103.66,95.88 v1(103.81,96.03)
  IN3 w0.122: v1(90.64,105.25) 90.64,106.38 94.02,109.76 v1(100.93,109.76)
  BOTTOM w0.102: CC306.1 85.84,106.88 89.44,106.88 90.64,105.68 v1(90.64,105.25) JXDP1.52 ; v1(106.36,107.78) 106.36,107.67 104.37,105.69 104.37,103.09 105.06,102.41 105.06,98.52 104.6,98.07 104.6,96.17 104.35,95.92 103.93,95.92 v1(103.81,96.03)
THERMTRIP1#: length 3.8
  TOP w0.076: 271.39,53.79 v2(270.3,53.79) 268.56,53.79 268.1,53.33 UE1.B12
  TOP w0.102: RE301.1 271.39,53.79
THERMTRIP2#: length 220.4
  TOP w0.076: UE1.H3 260.69,48.53 260.38,48.84 259.09,48.84 259.06,48.81 257.78,48.81 257.21,48.24 255.29,48.24 255.22,48.31 254.87,48.31
  TOP w0.102: v1(246.33,48.15) 246.61,47.88 251.21,47.88 v2(251.32,47.99) 252,48.66 254.46,48.66 254.82,48.31 254.87,48.31
  IN2 w0.122: v1(106.35,106.98) 108.87,106.98 109.53,106.32 117.81,106.32 122.07,102.06 122.07,99.78 124.69,97.15 130.43,97.15 130.66,97.38 140.72,97.38 142.63,95.47 152.37,95.47 157.15,90.69 159,90.69 161.92,87.77 161.92,82.58 163.5,81.01 164.09,81.01 166.67,78.43 168.94,78.43 171.1,76.27 171.1,73.36 180.51,63.95 180.51,63.12 182.16,61.47 182.16,60.61 183.04,59.73 183.04,58.06 186.55,54.55 186.55,49.77 190.86,45.46 191.72,45.46 197.37,39.82 199.98,39.82 201.4,38.4 204.27,38.4 205.6,37.07 206.96,37.07 207.4,36.63 211.45,36.63 212.34,35.75 213.19,35.75 214.05,34.89 217.56,34.89 218.42,35.75 226.1,35.75 226.69,36.33 232.43,36.33 232.81,36.71 234.18,36.71 236.24,38.76 236.24,39.23 237.82,40.82 238.5,40.82 241.45,43.76 242.19,43.76 243.81,45.38 244.68,45.38 246.33,47.03 v1(246.33,48.15)
  BOTTOM w0.102: CE36.1 105.77,94.59 105.77,95.5 107.09,96.82 107.09,100.95 104.78,103.26 104.78,105.41 v1(106.35,106.98) ; CE36.1 QE4.1 ; CE36.1 105.95,94.03 RE69.2
TOUCH_SCREEN_DET#: length 175.2
  TOP w0.102: v1(64.32,93.77) 64.06,94.03 62.46,94.03 RV8.1
  IN2 w0.122: v1(64.32,93.77) 64.44,93.9 67.4,93.9 68.75,95.25 68.75,103.29 69.94,104.48 71.09,104.48 71.38,104.19 72.32,104.19 73.64,105.51 78.39,105.51 81.12,102.79 83.76,102.79 85.06,101.48 92.44,101.48 92.93,100.99 101.88,100.99 102.81,100.06 107.66,100.06 107.85,99.87 111.69,99.87 114.23,97.33 114.23,95.68 118.11,91.79 123.45,91.79 123.83,91.41 126.82,91.41 127.65,90.59 131.72,90.59 133.27,92.13 137.32,92.13 139.31,90.15 144.7,90.15 146.11,88.74 148.66,88.74 149.77,87.64 150.79,87.64 151.38,87.04 151.38,82.19 155.46,78.11 155.46,75.85 155.81,75.5 155.81,68.92 153.39,66.5 153.39,65.33 152.32,64.26 152.32,63.82 154.87,61.27 154.87,60.14 155.32,59.69 155.32,55.99 152.62,53.28 147.5,53.28 145.61,51.39 143.8,51.39 143.06,50.65 v1(137.54,50.65)
  BOTTOM w0.076: UC1.AY5 137.95,52.07 137.71,51.83 137.71,51.59 137.8,51.5 137.8,50.91 v1(137.54,50.65)
  BOTTOM w0.102: JEDP1.32 67.76,89.85 67.62,89.71 65.59,89.71 64.32,90.98 v1(64.32,93.77)
TOUCH_SCREEN_PD#: length 117.9
  TOP w0.102: v2(144.72,83.08) RC272.1 144.72,84.34 v1(144.45,84.6)
  IN3 w0.122: v1(144.45,84.6) 144.25,84.81 135.33,84.81 134.39,85.75 134.39,87.56 132.44,89.5 132.44,93.03 131.88,93.59 123.72,93.59 121.37,91.23 109.05,91.23 107.81,90 107.55,90 105.48,87.93 104.42,87.93 102.37,89.98 100.88,89.98 100.72,90.14 92.93,90.14 92.77,89.98 87.14,89.98 83.65,86.48 81.28,86.48 80.22,87.55 77.04,87.55 76.15,88.44 76.15,92.25 73.33,95.07 v1(73.33,96.08)
  IN4 w0.089: v1(73.33,96.08) 72.78,96.08 71.49,97.37 71.49,97.65 70.54,98.6 v1(70.54,103.35)
  BOTTOM w0.102: UC1.A7 137.08,73.82 138.25,74.99 140.53,74.99 141.74,76.2 141.74,77.34 142.15,77.75 142.75,77.75 143.39,78.38 143.39,78.41 143.57,78.59 143.57,79.78 144.59,80.81 144.59,81.76 144.38,81.97 144.38,84.53 v1(144.45,84.6) ; v1(70.54,103.35) JEDP1.5
TOUCHPAD_INTR#: length 184.8
  TOP w0.102: v1(254.89,48.94) 255.16,48.68 RE318.2 ; JKBTP1.16 206.65,16.72 207.52,15.85 207.52,15.11 207.27,14.86 206.23,14.86 205.92,15.16 203.26,15.16 202.87,14.78 199.32,14.78 197.95,16.15 194.39,16.15 194.24,16.3 194.24,17.57 194.11,17.7 194.11,19.99 194.52,20.39 195.47,20.39 197.11,22.03 197.11,25.12 196.13,26.09 196.13,27.69 195.38,28.44 191.72,28.44 v3(191.31,28.86) v1(190.86,29.31) ; RC414.1 146.13,43.87 146.13,44.98 144.01,47.1 v1(143.53,47.1)
  IN1 w0.089: v1(190.86,29.31) 190.02,28.47 188.23,28.47 183,33.7 160.9,33.7 152.39,42.21 146.22,42.21 143.7,44.74 143.7,46.94 v1(143.53,47.1)
  IN3 w0.122: v1(254.89,48.94) 253.43,47.48 253.43,47.48 253.37,47.42 251.94,47.42 247.63,43.11 246.6,43.11 245.39,41.9 244.73,41.9 244.23,41.4 244.23,40.94 241.36,38.07 241.36,37.53 239.92,36.1 239.92,35.46 236.98,32.52 233.37,32.52 232.52,31.68 229.3,31.68 227.72,30.1 225.28,30.1 224.98,30.39 221.51,30.39 219.74,28.62 217.7,28.62 217.12,28.04 215.29,28.04 214.71,28.62 211.25,28.62 210.28,29.59 204.13,29.59 202.64,28.11 199.31,28.11 198.49,28.93 197.11,28.93 195.88,30.16 191.71,30.16 v1(190.86,29.31)
  BOTTOM w0.076: 141.58,49.92 140.96,50.54 138.91,50.54 138.4,51.04 138.4,51.31 UC1.BA5
  BOTTOM w0.102: v1(143.53,47.1) 143.53,47.96 141.58,49.92
TP_LAN_JTAG_TCK: length 4.1
  TOP w0.102: UL1.35 253.12,71.52 252.81,71.21 v2(252.81,69.22) 252.81,69.17 252.33,68.69 RL2.1
TP_LAN_JTAG_TDI: length 3.1
  TOP w0.102: T88.1 251.35,71.66 251.95,71.66 253,72.72 UL1.32
TP_LAN_JTAG_TDO: length 2.2
  TOP w0.102: T89.1 252.44,71.24 253.12,71.92 UL1.34
TP_LAN_JTAG_TMS: length 4.6
  TOP w0.102: RL1.1 251.15,70.33 v2(251.15,70.61) 251.15,70.72 251.57,71.14 251.77,71.14 252.95,72.32 UL1.33
TPM_GPIO0: length 9.6
  TOP w0.102: UZ12.29 154.49,59.58 v1(154.23,59.32)
  BOTTOM w0.102: v1(154.23,59.32) 154.8,59.89 154.8,61.44 v2(155.14,61.78) 155.64,62.27 156.16,62.27 157,63.12 157,63.57 156.29,64.28 156.29,65.87 RZ112.2
TPM_GPIO4: length 1.1
  TOP w0.102: UZ12.13 161.25,60.08 T283.1
TPM_LPM#: length 13.3
  TOP w0.102: v1(157.54,55.47) 157.59,55.52 157.59,55.72 156.85,56.46 UZ12.3
  IN2 w0.122: v1(157.54,55.47) 158.03,55.96 158.03,62.12 158.31,62.4 v1(158.31,63.92)
  BOTTOM w0.102: v1(158.31,63.92) 158.31,64.13 158.74,64.56 v2(158.74,65.07) 158.7,65.11 RZ363.2
TPM_PIRQ#: length 47.3
  TOP w0.102: v1(161.4,62.95) 161.5,63.04 RZ69.2 160.66,62.78 159.74,62.78 159.53,63 159.11,63 158.85,62.74 UZ12.18 ; v1(144.85,50.95) 144.7,50.8 v2(144.7,49.25) 144.7,47.79 147.57,44.93 147.57,44.84 RC561.2 RC560.2
  IN1 w0.089: v1(157.4,65.41) 157.8,65.81 158.24,65.81 161.1,62.95 v1(161.4,62.95)
  IN2 w0.122: v1(157.4,65.41) 157.4,65.06 158.07,64.38 158.54,64.38 158.73,64.19 158.73,62.47 158.28,62.01 158.28,54.58 158.63,54.23 158.63,53.19 157.54,52.1 154.85,52.1 154.78,52.03 152.84,52.03 151.83,53.04 147.61,53.04 145.52,50.95 v1(144.85,50.95)
TPM_PIRQ#_R: length 25.3
  TOP w0.102: v1(143.75,50.73) 143.75,48.09 146.36,45.48 146.36,44.22 146.59,43.99 149.19,43.99 RC560.1
  IN2 w0.122: v1(136.58,56.37) 137.02,55.93 137.02,54.09 136.64,53.7 136.64,50.78 137.22,50.21 137.91,50.21 138.1,50.4 143.42,50.4 v1(143.75,50.73)
  BOTTOM w0.076: UC1.AP8 136.3,56.09 v1(136.58,56.37)
TPM_TYPE: length 32
  TOP w0.102: v2(154.83,40.18) 155.29,40.64 RC349.1 157.7,42.41 v1(157.7,43.59)
  BOTTOM w0.076: UC1.AY7 136.84,52.2 137.16,51.88 137.16,50.47 137.43,50.2 138.64,50.2 138.66,50.18 140.67,50.18 141.25,49.59
  BOTTOM w0.102: 141.25,49.59 142.54,48.31 142.54,47.34 142.68,47.21 142.88,47.21 143.16,46.92 143.16,46.68 143.93,45.91 145.45,45.91 148.58,42.78 157.29,42.78 157.7,43.19 v1(157.7,43.59)
TRST#_XDP: length 28.1
  TOP w0.102: v1(104.5,106.4) 104.61,106.51 v2(104.61,107.13) 104.61,108.42 104.16,108.87 101.5,108.87 101.08,109.29 100.77,109.29 100.41,109.65 v1(100.41,110.26) ; UC8.12 103.65,102.19 v1(104.14,102.69)
  IN3 w0.122: v1(100.41,110.26) 100.26,110.41 94.31,110.41 90.14,106.23 v1(90.14,105.56)
  BOTTOM w0.102: v1(104.5,106.4) 104.14,106.04 v1(104.14,102.69) ; JXDP1.54 v1(90.14,105.56)
TUSB546A_SBU1_R: length 5.3
  TOP w0.102: UT9.27 26.8,78.99 v1(26,79.79) 26.15,79.94 26.15,80.17 RT132.1
  BOTTOM w0.102: RT414.1 24.51,78.81 25.18,78.81 25.52,79.14 25.95,79.14 26.19,79.38 26.19,79.6 v1(26,79.79)
TUSB546A_SBU2_R: length 5.7
  TOP w0.102: RT133.1 26.4,80.16 26.4,79.98 v1(26.59,79.79) 26.59,79.55 27.2,78.94 UT9.26
  BOTTOM w0.102: v1(26.59,79.79) 26.43,79.64 26.43,79.28 26.05,78.9 25.62,78.9 25.29,78.56 24.51,78.56 RT415.1
TYPEC_CON_SEL1: length 29.6
  IN3 w0.122: v1(156.98,71.21) 156.98,71.21 156.35,70.58 148.12,70.58 147.26,69.72 145.07,69.72 143.87,68.53 143.68,68.53 142.08,66.92 140.21,66.92 138.96,65.67 137.98,65.67 137.35,65.05 v1(136.92,65.05)
  BOTTOM w0.076: v1(136.92,65.05) 136.9,65.02 136.9,64.37 137.02,64.25 137.58,64.25 137.98,63.84 138.32,63.84 UC1.W4
  BOTTOM w0.102: v1(156.98,71.21) v2(158.17,70.03) 158.67,69.53 RC556.1 RC555.1
TYPEC_CON_SEL2: length 28.5
  IN3 w0.122: v1(156.48,67.84) 155.81,67.17 155.81,66.69 154.81,65.69 154.81,64.11 154.4,63.7 154.4,61.67 153.99,61.26 151.2,61.26 150.77,60.83 150.77,60.35 150.55,60.13 149.77,60.13 149.35,59.7 147.31,59.7 146.79,60.22 144.12,60.22 143.88,60.47 142.88,60.47 142.64,60.22 v1(142.64,59.95)
  BOTTOM w0.076: v1(142.64,59.95) 142.05,59.95 141.85,60.16 141.14,60.16 140.87,60.43 140.47,60.43 140.34,60.48 140.19,60.51 139.78,60.51 139.61,60.68 139.61,61.06 139.3,61.37 UC1.AB3
  BOTTOM w0.102: v2(155.92,67.56) 156.2,67.84 v1(156.48,67.84) 156.48,68.09 RC554.1 155.31,68.02 RC553.1
TYPEC_ID: length 6.6
  TOP w0.076: 256.8,50.42 256.96,50.42 257.01,50.36 257.59,50.36 257.66,50.29 258.94,50.29 259.09,50.45 259.71,50.45 UE1.F2
  TOP w0.102: RE343.2 254.47,49.54 v2(255.03,49.54) 255.08,49.54 255.5,49.96 256.05,49.96 CE62.1 256.8,50.42
UART_MISO: length 9.9
  TOP w0.076: 26.88,65.3 26.95,65.22 26.95,64.56 26.94,64.55 26.94,64.09 27.19,63.84 UT5.F2
  TOP w0.102: 26.88,65.3 v1(26.73,65.45) ; v1(31.12,68.6) 31.5,68.6 RT82.1 RT83.2
  IN4 w0.089: v1(31.12,68.6) 31.12,67.94 30.73,67.55 29.07,67.55 27.93,66.4 27.17,66.4 26.73,65.96 v1(26.73,65.45)
UART_MOSI: length 9.5
  TOP w0.076: v1(27.52,65.02) 27.44,64.94 27.44,64.16 27.69,63.91 UT5.E2
  TOP w0.102: RT83.1 32.8,67.33 v1(33.33,67.33) RT81.1
  IN4 w0.099: v1(33.33,67.33) 32.35,67.33 31.85,66.83 29.33,66.83 v1(27.52,65.02)
UG1_ISL9538: length 10.3
  TOP w0.102: v1(27.17,31.84) 27.17,32.09 v2(27.46,32.38)
  IN1 w0.762: 27.89,32.61 27.89,38.3 29.27,39.67 30.61,39.67 31.07,40.13
  vias: v1(27.76,31.84) v1(31.6,41.02)
UG2_ISL9538: length 26.2
  TOP w0.102: v1(34.37,43.74) 34.61,43.49 v2(35.5,43.49)
  IN1 w0.762: 37.05,42.99 37.86,42.17 38.08,42.17 38.82,41.44 38.82,31.67 35.53,28.38 34.65,28.38 33.37,27.09 33.37,26.04 32.61,25.28 31.41,25.28 30.5,26.2 29.66,26.2
  vias: v1(28.29,26.18) v1(28.87,26.18)
UIM_CLK: length 206.4
  TOP w0.102: CZ38.1 v1(117.18,96.16)
  IN2 w0.122: v1(241.48,48.56) 240.89,47.97 240.74,47.97 239.45,46.68 237.68,46.68 236.2,45.2 236.2,44.65 235.14,43.59 234.4,43.59 232.77,41.97 230.57,41.97 230.23,41.62 227.6,41.62 227.16,41.18 225.82,41.18 225.07,40.43 222.05,40.43 221.48,39.86 216.89,39.86 216.14,40.61 212.18,40.61 211.55,41.25 207.73,41.25 206.3,42.67 204.32,42.67 202.99,44 200.45,44 197.18,47.27 196.11,47.27 189.91,53.47 189.91,56.18 186.34,59.75 186.34,62.05 184.33,64.06 184.33,66.14 178.25,72.22 178.25,74.99 177.01,76.23 176.14,76.23 168.1,84.27 168.1,90.8 166.79,92.12 165.05,92.12 163.27,93.9 158.48,93.9 153.28,99.11 144.23,99.11 142.03,101.31 135.84,101.31 135.13,100.6 132.23,100.6 131.69,101.13 130.02,101.13 129.59,101.57 127.82,101.57 125.4,103.98 v1(125.4,105.96)
  BOTTOM w0.102: v1(241.48,48.56) 241.84,48.21 245.19,48.21 245.55,48.56 246.82,48.56 247,48.74 247.78,48.74 248.14,48.38 v2(249.62,48.38) 251.87,48.38 252.29,48.38 256.33,44.34 258.73,44.34 260.79,42.29 261.08,42.29 261.49,41.87 261.49,41.52 263.58,39.43 263.58,38.97 264.36,38.19 264.62,38.19 264.62,38.18 264.81,38.18 264.82,38.17 264.89,38.17 265.13,37.93 265.13,37.86 265.33,37.67 265.57,37.43 266.24,37.43 266.5,37.17 JNGFF2.32 ; v1(125.4,105.96) 123.63,105.96 119.05,101.39 119.05,97.86 117.35,96.16 v1(117.18,96.16) JSIM1.3
UIM_DATA: length 206.3
  TOP w0.102: v1(116.77,109.65) 116.95,109.47 CZ39.1 RZ335.2
  IN2 w0.122: v1(242.37,49.59) 242.37,48.56 241.28,47.47 240.95,47.47 239.66,46.18 237.89,46.18 236.7,44.99 236.7,44.44 235.35,43.09 234.61,43.09 232.98,41.46 230.78,41.46 230.38,41.07 229.21,41.07 227.81,39.66 226.08,39.66 225.46,39.04 221.34,39.04 221.04,39.34 216.67,39.34 215.9,40.11 210.51,40.11 209.99,40.64 207.37,40.64 206.35,41.65 204.63,41.65 202.78,43.5 200.19,43.5 196.93,46.76 195.86,46.76 189.41,53.22 189.41,55.81 185.84,59.38 185.84,61.84 183.82,63.85 183.82,65.93 177.75,72.01 177.75,74.78 176.8,75.73 175.75,75.73 170.47,81.01 170.14,81.01 168.32,82.83 168.32,83.15 166.86,84.62 166.86,91.33 166.58,91.61 164.84,91.61 163.06,93.4 158.28,93.4 153.07,98.6 144,98.6 141.79,100.8 136.05,100.8 135.34,100.09 132.02,100.09 131.49,100.63 129.8,100.63 129.37,101.06 127.61,101.06 119.03,109.65 v1(116.77,109.65)
  BOTTOM w0.102: v1(116.77,109.65) 117.18,110.06 JSIM1.7 ; JNGFF2.34 267,37.25 266.41,37.83 265.73,37.83 265.54,38.03 265.54,38.1 265.06,38.58 264.99,38.58 264.98,38.59 264.53,38.59 263.99,39.14 263.99,39.6 261.9,41.69 261.9,42.04 261.25,42.69 261.1,42.69 260.86,42.93 260.86,43.66 260.6,43.93 259.72,43.93 258.9,44.75 256.49,44.75 252.46,48.79 251.7,48.79 251.64,48.79 251.21,49.22 250.14,49.22 249.53,49.83 247.98,49.83 247.78,49.63 247.28,49.63 247.08,49.42 245.83,49.42 245.02,48.61 v2(244.43,48.61) 244.07,48.61 243.09,49.59 v1(242.37,49.59)
UIM_RESET: length 215.3
  TOP w0.102: CZ40.1 v1(114.64,96.16)
  IN2 w0.122: v1(240.49,48.56) 239.11,47.18 237.47,47.18 235.7,45.41 235.7,44.86 234.93,44.1 234.19,44.1 232.56,42.47 230.31,42.47 229.97,42.13 227.39,42.13 226.95,41.69 225.61,41.69 225.04,41.12 221.89,41.12 221.15,40.38 217.15,40.38 216.41,41.12 212.48,41.12 211.81,41.78 208.08,41.78 206.68,43.17 204.63,43.17 203.29,44.51 200.7,44.51 197.39,47.82 196.45,47.82 190.41,53.86 190.41,56.38 186.84,59.95 186.84,62.26 184.83,64.27 184.83,66.35 178.75,72.43 178.75,75.19 175.95,78 175.09,78 170.94,82.15 170.94,82.73 169.4,84.27 169.4,90.22 166.99,92.62 165.26,92.62 163.48,94.4 158.69,94.4 153.48,99.61 144.45,99.61 142.26,101.81 135.63,101.81 134.96,101.14 133.52,101.14 133.02,101.63 130.33,101.63 129.81,102.15 127.94,102.15 126.04,104.06 v1(126.04,105.96)
  BOTTOM w0.102: v1(126.04,105.96) 125.63,106.37 123.4,106.37 115.63,98.6 115.63,96.57 115.22,96.16 v1(114.64,96.16) JSIM1.2 ; JNGFF2.30 266,34.58 266.31,34.27 266.31,33.57 265.93,33.19 263.64,33.19 263.26,33.57 263.26,33.96 262.63,34.59 262.63,36.69 263.5,37.57 263.5,37.58 263.61,37.68 263.61,38.36 263.17,38.8 263.17,39.26 261.04,41.4 260.62,41.4 260.06,41.96 259.01,41.96 257.03,43.94 256.16,43.94 252.12,47.98 247.98,47.98 247.76,47.75 245.88,47.75 245.52,47.39 244.81,47.39 244.5,47.7 242.51,47.7 v2(242.41,47.8) 241.25,47.8 v1(240.49,48.56)
UPD1_SMBCLK: length 304.3
  TOP w0.076: UE1.C3 260.7,52.53 260.38,52.22 258.58,52.22 v1(258.4,52.4)
  TOP w0.102: RE303.1 v1(251.46,52.24) ; QT1.1 36.5,65.39 36.75,65.64 RT58.1 36.75,67.01 v1(36.52,67.23)
  IN2 w0.122: v1(258.4,52.4) 258.4,53.36 257.74,54.02 256.98,54.02 255.58,52.62 254.56,52.62 254.18,52.24 253.42,52.24 253.29,52.12 251.77,52.12 251.64,52.24 v1(251.46,52.24) 251.46,51.79 251.73,51.52 251.73,46.57 250.54,45.38 250.54,43.9 248.08,41.43 247.61,41.43 246.57,40.39 246.57,38.3 246.29,38.02 246.29,36.86 245.76,36.33 244.6,36.33 243.96,35.69 242.37,35.69 236.35,29.67 233.28,29.67 232.74,29.13 232.34,29.13 231.77,28.56 227.37,28.56 226.64,27.83 223.67,27.83 223.31,27.47 221.9,27.47 221.61,27.76 220.4,27.76 220.31,27.67 215.1,27.67 214.28,28.49 210.18,28.49 209.31,29.36 205.87,29.36 205.78,29.27 199.22,29.27 198.91,29.57 197.45,29.57 196.49,30.54 186.41,30.54 182.89,27.01 155.78,27.01 154.18,25.42 142.68,25.42 136.03,32.06 99.16,32.06 97.09,29.99 72.52,29.99 69.91,32.61 64.81,32.61 52.9,44.52 52,44.52 51.78,44.74 47.5,44.74 46.84,45.4 44.9,45.4 44.43,44.93 42.42,44.93 42.09,45.26 40.34,45.26 40.01,45.59 38.96,45.59 38.68,45.87 38.68,47.32 37.56,48.43 36.98,48.43 35.1,46.55 32.66,46.55 31.77,45.67 28.93,45.67 27.61,46.99 27.61,47.34 25.43,49.53 25.43,50.95 26.73,52.24 31.47,52.24 34.08,54.85 36.35,54.85 36.89,55.38 36.89,60.85 37.41,61.38 37.41,62.62 37.9,63.12 37.9,65.66 36.52,67.03 v1(36.52,67.23)
