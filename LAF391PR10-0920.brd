# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 70.2
  TOP w0.203: v1(266.48,16.2) 266.38,16.3 UA1.22 ; v1(268.15,23.2) 268.05,23.1 267.18,23.1 UA1.37
  TOP w0.254: CA41.2 260.74,22.42 v1(261.14,22.83)
  TOP w0.356: v1(267.59,15.72) 267.59,15.33 CA57.2
  TOP w0.381: CA8.2 267.97,25.4 v1(268.41,25.83)
  TOP w0.457: CA2.2 279.68,6.07 v1(279.25,6.5)
  TOP w0.508: v1(271.78,23.54) 272.17,23.92 CA51.1 ; v1(280.22,7.16) 279.68,7.69 CA3.2 ; v1(271.89,19.02) 272.24,19.38 CA25.1 ; v1(274.38,26.08) 274.22,26.23 RA35.1 ; CA4.2 275.95,17.24 v1(276.28,17.57) 276.28,17.65 275.67,18.26 CA1.1 ; CA35.1 270.01,22.48 269.93,22.55 269.88,22.55 269.49,22.95 v1(269.18,22.95) ; v1(277.59,11.55) 277.16,11.98 RA36.1 ; v1(272.72,16.05) 272.72,15.78 273.21,15.3 CA74.2 ; RA44.1 v1(272.79,22.84) ; CA73.2 275.47,15.41 v1(275.14,15.74) ; CA58.2 v1(267.14,14.08) ; CA9.2 v1(272.79,25.64)
  GND1 w0.203: JHP1.7 290.75,12.67 ; JHP1.7 289.67,12.67 ; JHP1.7 291.83,12 ; JHP1.7 289.67,12 ; JHP1.7 291.83,12.67 ; JHP1.5 289.18,1.83 ; JHP1.5 288.1,1.83 ; JHP1.5 287.02,2.5 ; JHP1.5 289.18,2.5 ; JHP1.5 287.02,1.83
  GND2 w0.203: 287.02,1.83 JHP1.5 ; JHP1.5 287.02,2.5 ; JHP1.5 288.1,1.83 ; JHP1.5 289.18,1.83 ; JHP1.5 289.18,2.5 ; JHP1.7 290.75,12.67 ; JHP1.7 289.67,12 ; JHP1.7 289.67,12.67 ; JHP1.7 291.83,12.67 ; JHP1.7 291.83,12
  IN3 w0.203: v1(261.14,22.83) 261.5,22.48 263.66,22.48 264.38,23.2 v1(268.15,23.2)
  VCC w0.203: 289.67,12 JHP1.7 ; JHP1.7 291.83,12 ; JHP1.7 289.67,12.67 ; JHP1.7 291.83,12.67 ; JHP1.7 290.75,12.67 ; JHP1.5 289.18,1.83 ; JHP1.5 288.1,1.83 ; JHP1.5 287.02,1.83 ; JHP1.5 289.18,2.5 ; JHP1.5 287.02,2.5
  GND3 w0.203: JHP1.7 291.83,12.67 ; JHP1.7 291.83,12 ; JHP1.7 289.67,12.67 ; JHP1.7 290.75,12.67 ; JHP1.7 289.67,12 ; 287.02,2.5 JHP1.5 ; JHP1.5 289.18,1.83 ; JHP1.5 289.18,2.5 ; JHP1.5 288.1,1.83 ; JHP1.5 287.02,1.83
  BOTTOM w0.508: v1(273.35,19.8) 272.72,19.17 CA49.1 ; RA37.1 276.85,18.14 v1(276.28,17.57) ; CA52.1 275.07,15.81 v1(275.14,15.74)
  vias: v1(282.76,0.43) v1(284.59,2) v1(286.57,0.43) v1(290.38,0.43) v1(294.19,0.43) v1(297.97,13.08) v1(298,2.92) v1(298,0.43) v1(299.06,13.1) v1(300.67,1.59) v3(278.48,1.67) v3(280.37,1.43) v3(285.51,1.24)
VBAT1_ISL9538: length 4.5
  TOP w0.102: PC950.2 34.98,47.3 v2(35.07,47.39)
  TOP w0.203: PR940.2 PC950.2 34.8,46.61 34.31,46.61 34.21,46.71 33.37,46.71 33.33,46.74 33.06,46.74 v1(32.62,47.19)
VBUS1_ECOK: length 290.2
  TOP w0.076: 263.38,43.29 263.38,43.68 262.91,44.15 262.91,45.02 UE1.M6
  TOP w0.102: v1(45.62,55.65) 45.42,55.44 45.42,54.9 45.6,54.72 46.36,54.72 46.81,55.16 47.72,55.16 48.07,55.52 PR1257.1 ; PR1220.1 37.71,67.32 PR1222.1 37.71,67.17 38.28,66.59 v1(38.28,66.11) ; 263.38,43.29 263.13,43.04 v2(262.56,43.04) 262.41,42.88 262.41,42.64 v1(262.81,42.25)
  IN1 w0.089: v1(53.65,29.38) 53.65,30.27 60.63,37.26 60.63,44.39 59.25,45.77 52.86,45.77 51.95,46.68 48.14,46.68 46.59,48.23 46.59,55.32 46.41,55.5 45.78,55.5 v1(45.62,55.65)
  IN2 w0.122: v1(38.28,66.11) 38.41,65.99 38.41,61.11 41.43,58.09 44.56,58.09 45.52,57.12 45.52,55.75 v1(45.62,55.65)
  IN3 w0.122: v1(242.24,40.84) 241.99,40.84 241.74,40.59 241.74,39.56 240.59,38.41 240.59,38.07 239.17,36.65 239.17,35.85 238.67,35.35 237.04,35.35 236.68,34.98 235.92,34.98 235.26,34.33 234,34.33 232.87,33.19 229.67,33.19 227.36,30.88 225.76,30.88 225.5,31.14 220.99,31.14 220.31,30.46 218.21,30.46 217.24,29.49 211.44,29.49 210.59,30.34 203.49,30.34 203.09,29.94 197.36,29.94 196.39,30.92 180.47,30.92 179.32,29.76 153.97,29.76 153.38,29.18 144.63,29.18 144.02,29.79 101.4,29.79 99.46,27.85 69.38,27.85 66.77,25.23 57.29,25.23 53.65,28.88 v1(53.65,29.38)
  IN4 w0.089: v1(262.81,42.25) 261.97,41.41 257.47,41.41 256.81,40.75 253.57,40.75 252.96,41.36 246.02,41.36 245.66,41.72 243.88,41.72 243.01,40.84 v1(242.24,40.84)
VBUS2_ECOK: length 320.8
  TOP w0.076: UE1.N3 260.66,44.37 260.66,43.63 v1(260.44,43.42)
  TOP w0.102: PR1242.1 48.44,58.59 49.25,58.59 ; 49.25,58.59 50.86,58.59 52.38,60.12 52.38,63.67 53.76,65.06 v2(53.76,65.07) 56.32,65.07 59.36,68.12 59.36,69.97 59.77,70.38 60.51,70.38 60.79,70.66 61.27,70.66 61.4,70.53 62.54,70.53 62.84,70.84 62.84,71.54 62.29,72.09 62.29,79.97 61,81.25 PR24.1 61,81.78 PR20.2 ; 49.25,58.59 49.25,59.13 48.95,59.43 48.95,59.8 48.72,60.03 47.87,60.03 47.79,60.11 47.39,60.11 46.87,59.58 v1(46.56,59.58)
  IN1 w0.089: v1(46.56,59.58) 45.76,59.58 43.02,56.84 40.92,56.84 39.04,54.96 39.04,48.43 39.72,47.76 39.77,47.76 40.91,46.62 42.13,46.62 42.61,47.1 45.51,47.1 46.21,46.4 51.87,46.4 52.89,45.39 59.13,45.39 60.23,44.29 60.23,37.23 53.14,30.15 53.14,29.51 v1(53.01,29.38)
  IN3 w0.122: v1(243.41,42.19) 243.67,41.93 243.67,41.09 240.85,38.27 240.85,37.97 239.42,36.54 239.42,35.74 238.76,35.08 237.14,35.08 236.44,34.39 235.68,34.39 235.37,34.08 234.16,34.08 233.02,32.94 229.8,32.94 227.49,30.63 225.63,30.63 225.37,30.89 221.12,30.89 220.37,30.15 218.37,30.15 217.4,29.18 211.4,29.18 210.48,30.09 203.61,30.09 202.98,29.46 197.31,29.46 196.1,30.67 180.57,30.67 178.9,28.99 154.39,28.99 154.2,28.8 143.9,28.8 143.43,29.27 101.51,29.27 99.75,27.5 69.42,27.5 66.88,24.96 56.93,24.96 53.01,28.88 v1(53.01,29.38)
  IN4 w0.089: v1(243.41,42.19) 245.5,42.19 246.1,41.58 253.05,41.58 253.66,40.97 256.72,40.97 257.38,41.63 259.11,41.63 260.44,42.96 v1(260.44,43.42)
VBUS3_ECOK: length 2.5
  TOP w0.076: T264.1 270.59,50.21 270.15,49.77 269.19,49.77 UE1.F13
VCC_GT: length 5
  TOP w0.254: v1(63.57,50.2) 63.68,50.08 64.32,50.08 64.69,50.45 PR680.2
  BOTTOM w0.102: v2(61.78,50.22) 62.37,49.63 62.78,49.63 PC669.1
  BOTTOM w0.203: PU612.3 63.95,50.41 63.73,50.2 v1(63.57,50.2)
  BOTTOM w0.254: PC669.1 63.45,50.2 v1(63.57,50.2)
VCC_GT_SENSE: length 40.4
  TOP w0.152: v1(93.47,67.42) 92.63,67.42 RC161.1
  IN4 w0.152: v1(93.47,67.42) 93.29,67.59 88.67,67.59 86.24,70.02 86.24,71.84 85.19,72.89 79.02,72.89 77.7,71.57 77.7,70.74 76.64,69.67 73.16,69.67 73,69.52 73,68.73 73.21,68.53 v1(73.61,68.53)
  BOTTOM w0.152: UC1.J70 100.62,68.67 100.07,68.39 99.45,68.39 99.34,68.29 95.9,68.29 95.17,67.56 93.6,67.56 v1(93.47,67.42) ; v1(73.61,68.53) 74.17,68.53 74.85,67.84 PC651.2 74.88,67.69 PC639.1 74.86,66.82 PR648.1 74.03,66.82 PC653.1
VCC_IA1: length 8.7
  IN4 w0.254: v1(86.92,62.53) 86.92,61.88 83.02,57.98 83.02,57.87 v1(82.99,57.83)
  BOTTOM w0.203: PU610.3 82.71,58.11 v1(82.99,57.83)
  BOTTOM w0.254: v1(86.92,62.53) 86.68,62.29 PR688.2 ; v1(82.99,57.83) 82.99,57.21 PC676.1
VCC_IA2: length 4.6
  TOP w0.254: v1(70.79,77.19) 71.02,77.43 PR691.2
  BOTTOM w0.102: v1(70.79,77.19) v2(70.22,77.76)
  BOTTOM w0.254: PU613.3 73.01,77.23 72.78,77 PC677.1 70.98,77 v1(70.79,77.19)
VCCDSW_EN: length 24.6
  TOP w0.076: 265.02,42.85 v1(265.48,43.3) 265.03,43.3 264.47,43.86 264.47,44.12 264.34,44.24 264.34,45.01 UE1.M7
  TOP w0.102: RC445.1 249.72,39.11 249.1,39.73 v1(249.1,40.12) ; 265.02,42.85 265,42.83 v2(265,42.08) 265,42.01 264.67,41.68 CE66.1
  IN4 w0.089: v1(249.1,40.12) 249.55,40.56 250.78,40.56 250.8,40.53 256.9,40.53 257.56,41.19 262.94,41.19 263.96,42.21 264.39,42.21 v1(265.48,43.3)
VCCDSW_EN_GPIO: length 5.5
  TOP w0.102: v2(246.92,39.92) 248.05,41.05 QC6.2 249.5,41.05 RC431.1 249.61,40.23 RC445.2 250.06,40.03 DC1.2
VCCDSW_EN_Q: length 74.8
  TOP w0.102: v1(251.62,39.26) 251.64,39.29 DC1.1 ; RC442.1 258.07,37.26 258.07,37.87 257.89,38.05 257.03,38.05 256.75,38.32 256.75,38.78 256.61,38.92 v1(256.61,39.35) ; DC2.2 202.2,34.12 v1(202.44,33.88)
  IN1 w0.089: v1(202.44,33.88) 202.87,34.31 205.63,34.31 208.13,31.81 209.94,31.81 212.55,29.21 217.17,29.21 218.15,30.18 221.72,30.18 222.18,30.64 227.94,30.64 228.14,30.84 230.73,30.84 231.6,29.97 233.47,29.97 233.87,30.36 238.25,30.36 241.01,33.12 247.71,33.12 247.88,33.3 249.75,33.3 v1(250.24,32.81)
  IN3 w0.122: v1(256.61,39.35) 256.51,39.44 254.51,39.44 250.24,35.17 v1(250.24,32.81)
  IN4 w0.089: v1(256.61,39.35) 256.51,39.44 251.79,39.44 v1(251.62,39.26)
  BOTTOM w0.102: v1(251.62,39.26) v2(251.06,39.26)
VCCIO_SENSE: length 71.2
  TOP w0.152: RC165.1 125.19,58.06 125.19,57.03 125.44,56.78 v2(125.98,56.78) 126.3,56.78 v1(126.51,57)
  IN3 w0.152: v1(126.51,57) 126.96,56.55 126.96,53.8 126.85,53.69 126.85,52.14 134.12,44.88 144.78,44.88 146.38,43.29 153.15,43.29 154.36,44.5 156.65,44.5 158.75,46.61 158.75,48.22 163.91,53.37 166.29,53.37 171.3,58.39 171.3,58.99 v1(171.43,59.11)
  BOTTOM w0.152: UC1.AM23 126.9,57.39 v1(126.51,57) ; v1(171.43,59.11) 171.61,59.29 171.82,59.29 172.37,58.75 173.44,58.75 174.17,58.01 174.17,56.51 174.55,56.13 174.55,55.7 PR422.2
VCCSA_B+: length 0.7
  TOP w0.102: v1(89.96,87.41) v2(89.96,86.69)
  vias: v1(89.11,87.58)
VCCSENSE: length 75.3
  TOP w0.152: PC620.1 68.97,61.39 69.16,61.58 69.16,62.59 v1(68.86,62.89) ; PC620.1 69.13,60.76 PC617.1 PC618.2 ; PC620.1 68.48,61.39 PR622.1 ; RC140.1 90.99,65.02 v1(90.83,65.17)
  IN1 w0.152: v1(90.83,65.17) 90.76,65.17 90.58,65.35 82.85,65.35 81.78,66.42 78.78,66.42 77.68,67.52 77.68,68.94 76.94,69.68 75.4,69.68 75.07,69.35 75.07,65.08 73.41,63.42 71.86,63.42 70.77,62.33 69.42,62.33 v1(68.86,62.89)
  IN4 w0.076: v1(121.99,70.59) 121.79,70.79 121.66,70.79 121.59,70.72 121.59,69.63 122.03,69.18 122.03,68.46 122.1,68.39 122.1,68.37
  IN4 w0.152: 122.1,68.37 122.1,67.31 121.52,66.72 117.76,66.72 116.54,65.5 113.77,65.5 113.02,64.75 113.02,64.14 111.99,63.12 93.61,63.12 91.43,65.3 90.96,65.3 v1(90.83,65.17)
  BOTTOM w0.076: UC1.E32 122.33,70.93 v1(121.99,70.59)
VCCST_PWRGD: length 267
  TOP w0.102: RE308.1 272.99,45.12 v1(273.25,45.39) ; v1(103.86,90.75) 103.86,90.95 v2(103.61,91.21) ; v1(275.71,44.99) 275.26,44.54 275.26,44.01 275.75,43.53 276.78,43.53 276.92,43.39 276.92,42.93 276.81,42.83 UE4.4
  IN1 w0.089: v1(245.04,47.8) 245.11,47.72 246.49,47.72 246.68,47.91 247.69,47.91 248.31,48.54 248.31,49.22 248.86,49.77 252.09,49.77 252.59,50.28 255.38,50.28 257.14,48.51 261.82,48.51 261.85,48.54 263.11,48.54 263.94,47.72 267.09,47.72 267.63,47.18 267.9,47.18 269.8,49.07 271.07,49.07 272.27,47.88 272.27,46.29 273.17,45.39 v1(273.25,45.39) 273.49,45.62 274.51,45.62 275.15,44.98 275.71,44.98 v1(275.71,44.99)
  IN2 w0.122: v1(103.86,90.75) 103.76,90.65 102.39,90.65 100.66,92.38 99.44,92.38 v1(98.99,92.82) ; v1(107.49,109.09) 108.33,109.94 111.12,109.94 113.06,108 118.04,108 126.42,99.61 128.78,99.61 129.27,99.13 130.96,99.13 131.43,98.67 136.04,98.67 136.5,99.13 137.81,99.13 138.28,98.67 141.31,98.67 143.14,96.84 152.81,96.84 157.68,91.97 159.38,91.97 164.46,86.89 164.46,82.3 165.68,81.09 166.93,81.09 168.91,79.1 169.22,79.1 169.95,78.38 170.59,78.38 171.94,77.03 171.94,73.48 181.9,63.52 181.9,63.05 183.9,61.06 183.9,58.42 187.44,54.87 187.44,51.12 190.9,47.66 190.9,46.87 191.22,46.55 192,46.55 197.89,40.67 202.02,40.67 203.42,39.27 204.61,39.27 205.83,38.05 211.34,38.05 212.79,36.6 225.75,36.6 226.83,37.68 232.87,37.68 233.3,38.12 233.49,38.12 234.32,38.96 234.64,38.96 237.91,42.23 238.71,42.23 241.15,44.67 241.71,44.67 243.27,46.23 244.33,46.23 245.04,46.94 v1(245.04,47.8)
  IN3 w0.122: v1(108.77,92.5) 108.55,92.5 105.05,89 104.86,89 103.88,89.98 103.88,90.69 103.86,90.7 v1(103.86,90.75)
  IN4 w0.089: v1(108.77,92.5) 109.78,93.52 109.78,94.74 109.29,95.23 108.17,95.23 107.6,95.8 107.6,96.31 107.99,96.7 107.99,103.25 106.64,104.6 106.64,105.98 107.01,106.34 107.01,108.61 v1(107.49,109.09)
  BOTTOM w0.102: v1(98.99,92.82) 98.99,92.89 RC123.1 ; v1(103.86,90.75) 104.22,90.39 105.8,90.39 106.1,90.09 106.1,88.44 106.53,88.01 CC301.1 107.47,87.09 RC71.1 107.5,86.71 107.7,86.51 RC78.1
VCCST_PWRGD_CPU: length 16.5
  BOTTOM w0.076: 101.81,77.89 101.81,77.36 102.72,76.45 102.72,75.7 103.78,74.64 103.78,74.04 104.01,73.81 104.01,73.28 UC1.B65
  BOTTOM w0.102: 101.81,77.89 101.81,78.83 102.19,79.21 102.19,80.78 103.28,81.88 103.28,83.17 v2(104.94,84.83) 106.13,86.03 106.66,86.03 RC78.2
VCCST_PWRGD_EC: length 62.5
  TOP w0.076: 270.69,45.67 v1(270.46,45.67) 270.35,45.67 269.92,46.1 269.6,46.1 269.07,46.62 266.66,46.62 266.42,46.86 UE1.K10
  TOP w0.102: RE552.2 225.14,34.84 225.81,34.84 226.25,35.29 v2(226.89,35.29) 227.4,35.29 227.72,34.97 v1(230.09,34.97) ; 270.69,45.67 271.05,45.67 271.59,45.12 RE308.2
  IN1 w0.089: v1(269.26,38.15) 267.47,38.15 266.45,37.13 260.42,37.13 260.39,37.17 257.52,37.17 257.15,37.54 252.21,37.54 251.73,37.05 247.3,37.05 246.41,37.94 244.2,37.94 243.84,38.3 241.94,38.3 241.37,37.73 236.48,37.73 235.02,36.26 233.57,36.26 232.68,35.38 230.5,35.38 v1(230.09,34.97)
  IN2 w0.122: v1(269.26,38.15) 269.48,38.37 269.48,41.1 269.51,41.13 269.51,43.15 269.39,43.27 269.39,45.26 269.8,45.67 v1(270.46,45.67)
VCCSTG_EN: length 151.3
  TOP w0.102: RZ120.1 130.52,33.3 132.8,33.3 135.13,30.96 v2(136.95,30.96) 146.33,30.96 v1(147.06,30.23)
  IN2 w0.122: v1(147.06,30.23) 147.93,29.36 152.36,29.36 154.25,31.25 173.79,31.25 174.39,30.66 179.18,30.66 182.94,34.41 182.94,35.86 181.28,37.51 181.28,42.26 183.6,44.58 183.6,54.69 179.34,58.96 179.34,60.31 178.03,61.62 177.43,61.62 165.19,73.86 162.11,73.86 161.03,74.94 161.03,78.71 159.51,80.24 159.51,80.73 158.86,81.37 158.37,81.37 155.25,84.49 155.25,88.85 153.08,91.02 152.87,91.02 152.03,91.87 151.77,91.87 v1(151.34,92.3)
  IN3 w0.122: v1(151.34,92.3) 151.13,92.1 142.13,92.1 v1(137.94,87.91)
  BOTTOM w0.102: v1(137.94,87.91) 137.94,87.68 137.71,87.45 UZ35.4 137.04,87.45 136.78,87.71 RZ320.2 135.77,87.71 135.61,87.54 UZ19.4
VDD_ISL9538: length 22
  TOP w0.203: PR918.2 26.99,44.47 26.08,44.47 25.56,43.95 v1(25.29,43.95)
  IN2 w0.203: v1(36.14,39.34) 34.84,39.34 34.35,39.84 32.44,39.84 32.1,40.18 28.58,40.18 27.21,41.55 v1(27.21,42.75) 26.79,43.16 26.08,43.16 v1(25.29,43.95)
  BOTTOM w0.203: PU901.18 28.57,43.04 28.46,42.93 v2(27.87,42.93) 27.39,42.93 v1(27.21,42.75) 26.98,42.52 PC933.1
  BOTTOM w0.254: v1(36.14,39.34) 35.81,39.01 PR915.2 ; PR919.1 25.53,43.71 v1(25.29,43.95)
VDDP_ISL9538: length 1.9
  TOP w0.254: v1(33.82,41.87) 33.58,42.11 33.58,43.42 PC932.2
  vias: v2(34.23,41.5)
VIN_1.8VALW: length 1.6
  TOP w0.457: PC530.2 177.19,109.6 v1(177.27,109.52)
  TOP w0.508: v1(177.35,108.59) PL502.2
  vias: v2(177.86,109.69)
VIN_1V_PRIM:
  vias: v1(175.96,99.92) v1(176.79,99.92) v1(177.11,99.35) v2(177.3,100.12)
VIN_1VS_VCCIO:
  vias: v1(180.14,50.44) v1(180.14,49.86) v2(180.94,50.63)
VSS_GT_SENSE: length 40.5
  TOP w0.152: PU602.18 72.07,68.01 v1(72.1,68.04) ; v1(93.45,68.03) 93.44,68.04 RC163.1
  IN4 w0.152: v1(93.45,68.03) 93.32,67.9 88.79,67.9 86.54,70.15 86.54,71.97 85.31,73.2 78.89,73.2 77.4,71.7 77.4,70.86 76.51,69.97 73.03,69.97 72.7,69.64 72.7,68.64 v1(72.1,68.04)
  BOTTOM w0.076: 99.55,68.92 99.71,69.08 99.89,69.08 100.09,69.03 100.23,68.99 100.28,68.99 100.29,68.99 100.41,68.99 100.51,69.03 100.53,69.04 101.01,69.04 UC1.J69
  BOTTOM w0.152: PC654.2 72.02,68.13 v1(72.1,68.04) 72.79,68.04 PC653.2 ; v1(93.45,68.03) 93.62,67.86 94.97,67.86 v2(95.36,68.25) 95.7,68.59 99,68.59 99.55,68.92
VSSIO_SENSE: length 69.3
  TOP w0.152: v1(127.51,57.06) 127.66,57.21 RC167.1
  IN3 w0.152: v1(127.51,57.06) 127.92,56.66 127.92,53.62 127.16,52.85 127.16,52.27 134.24,45.18 144.91,45.18 146.5,43.59 153.02,43.59 154.23,44.8 156.52,44.8 158.45,46.73 158.45,48.34 163.78,53.68 166.16,53.68 171,58.52 171,59.32 v1(171.43,59.75)
  BOTTOM w0.152: v1(171.43,59.75) 171.58,59.6 171.95,59.6 172.5,59.05 173.56,59.05 174.48,58.14 v4(174.48,57.59) 174.48,56.64 174.86,56.26 174.86,55.72 PR412.2 ; UC1.AM22 127.84,57.39 v1(127.51,57.06)
VSSSENSE: length 73.5
  TOP w0.152: PC620.2 68.46,62.34 68.46,63.12 68.7,63.36 v1(68.7,63.5) 68.7,63.59 68.57,63.71 PU602.6 ; v1(90.81,65.77) 90.95,65.91 RC141.1
  IN1 w0.152: v1(90.81,65.77) 90.69,65.66 82.97,65.66 81.91,66.72 78.91,66.72 77.98,67.65 77.98,69.07 77.07,69.99 75.28,69.99 74.77,69.48 74.77,65.21 73.28,63.72 71.71,63.72 71.42,63.43 70.6,63.43 70.13,63.9 69.47,63.9 69.14,63.57 68.77,63.57 v1(68.7,63.5)
  IN4 w0.076: 121.8,68.37 121.8,68.39 121.87,68.46 121.87,69.12 121.42,69.56 121.42,70.79 121.59,70.95 121.76,70.95 121.92,71.12 v1(121.92,71.28)
  IN4 w0.152: 121.8,68.37 121.8,67.43 121.39,67.03 117.63,67.03 116.41,65.81 113.64,65.81 112.72,64.88 112.72,64.27 111.87,63.42 93.74,63.42 91.56,65.6 90.98,65.6 v1(90.81,65.77)
  BOTTOM w0.076: UC1.E33 121.84,71.28 v1(121.92,71.28)
  BOTTOM w0.152: v1(68.7,63.5) 68.7,64.15 PC619.2
32KHZ_OUT: length 4.9
  TOP w0.076: UE1.F3 260.35,50.61 258.53,50.61 258.53,50.61 258.22,50.61 258.22,50.61 v2(257.81,50.61) 257.07,50.61 256.8,50.88
  TOP w0.102: 256.8,50.88 256.73,50.95 256.73,51.02 256.51,51.24 CE54.1
+AC_IN: length 33.2
  TOP w0.508: v1(51.62,77.9) 51.24,77.52 51.24,77.09 50.87,76.71 PR1255.1
  IN2 w0.508: v1(47.43,62.28) 48.44,62.28 52.18,66.01 52.18,71.64 52.89,72.35 52.89,77.26 52.25,77.9 v1(51.62,77.9)
  BOTTOM w0.254: v1(47.43,62.28) 47.43,62.7 41.91,68.21 41.91,70.66 v1(40.92,71.65)
  vias: v2(43.04,64.04)
+BL_PWR_SRC:
  vias: v1(69.78,98.09) v1(69.77,97.46) v1(70.29,97.02) v1(70.68,97.53) v3(74.59,96.66) v3(76.42,96.98) v3(76.42,94.63)
+BL_PWR_SRC_P: length 1.6
  TOP w0.102: CV15.1 75.62,103.97 v3(75.23,104.36)
+CHARGER_SRC:
  vias: v1(21.9,35.1) v1(21.9,34.46) v1(21.9,33.83) v1(21.9,33.19) v1(22.53,35.1) v1(22.53,34.41) v1(22.53,33.8) v1(22.53,33.19) v1(23.68,33.07) v1(24.57,33.07) v1(25.46,33.07) v1(26.34,33.07) v1(28.66,36.31) v1(28.66,35.06) v1(28.66,33.82) v1(28.66,32.57) v2(21.37,36.37)
+COINCELL: length 8.2
  TOP w0.102: v2(44.4,79.84) PC2.2
  TOP w0.508: v1(47.17,79.05) PR2.1 45.52,79.83 PC2.2
  BOTTOM w0.508: v1(47.17,79.05) 47.17,77.9 46.54,77.26 46.54,75.99 47.04,75.49 JRTC1.1
+CRT_VCC: length 6.8
  TOP w0.102: v1(289.62,42.46) v2(289.62,43.66)
  TOP w0.406: RV122.2 287.05,53.44 287.51,52.98 v1(287.51,52.96) 287.05,52.5 RV121.2
  BOTTOM w0.406: v1(287.33,46.91) 288.07,47.65 RV120.2
  BOTTOM w0.508: v1(287.51,52.96) 288.09,52.37 CV101.1
  vias: v1(286.82,51.1) v1(287.46,51.1) v1(289.62,41.7) v1(289.92,50.08)
+DC_IN: length 16.6
  TOP w0.508: 54.54,79.17 54.54,79.09 54.87,78.76 PR1201.1
  IN3 w0.762: 54.54,80.69 54.54,82.98 55.96,84.4 55.96,89.18 54.54,90.6 52.25,90.6 51.52,91.33 51.52,92.53
  vias: v1(51.52,93.85) v1(51.52,93.26) v1(54.59,80.46) v1(54.54,79.88) v1(57.59,96.44) v1(58.33,96.44) v2(54.96,79.28)
+DC_IN_SS: length 85.4
  TOP w0.127: v1(20.45,40.94) v3(19.73,40.22)
  TOP w0.508: v1(20.45,40.94) PD904.2
  IN1 w0.762: v1(53.52,89.66) 53.52,89.2 48.98,84.65 46.4,84.65 45.36,83.61 41.46,83.61 39.04,81.2 33.84,81.2 30.66,78.02 26.69,78.02 25.91,77.25 25.91,74.55 24.57,73.2 22.79,73.2 22.27,72.68 22.27,71.41 20.5,69.64 20.5,67.99 22.69,65.81 22.69,64.36 22.1,63.78 22.1,60.45 21.85,60.19 21.85,58.04 21.34,57.53 20.2,57.53 18.98,56.31 17.96,56.31 15.8,54.15 15.8,51.1 v1(14.41,49.7)
  IN2 w0.508: v1(14.41,49.7) 14.41,44.88 18.34,40.94 v1(20.45,40.94)
+DCIN_JACK:
  vias: v1(39.04,94.03) v1(39.04,93.39) v1(39.04,92.76) v1(39.04,92.12) v1(39.04,91.49) v1(39.04,90.85) v1(48.44,92.88) v1(48.44,92.25) v1(48.44,91.61) v1(48.44,90.98) v3(40.44,94.59) v3(44.45,95.46) v3(48.04,95.02)
+DCPRTC: length 11.8
  TOP w0.381: CC214.1 142.07,43.3 139.91,45.46 139.91,46 140.26,46.34 v1(140.26,47.25)
  BOTTOM w0.381: v1(140.26,47.25) 140.26,47.55 138.89,48.92 138.57,48.92 138.29,49.2 136.83,49.2 v2(136.45,49.58) 135.18,50.85
+DDR_VREF_A_CA: length 7.7
  TOP w0.127: v2(92.28,10.28) 92.91,10.28 v1(92.98,10.36)
  TOP w0.508: v1(92.98,10.36) 93.33,10.71 RD17.1 91.89,11.36 CD25.1 CD26.1 91.87,13.35 91.88,13.36 RD16.1 RD15.2
  BOTTOM w0.305: JDIMM1.164 92.93,10.42 v1(92.98,10.36)
+DDR_VREF_A_DQ: length 8.8
  TOP w0.508: v1(101.78,51.55) 101.62,51.39 100.16,49.93 99.15,48.92 99.15,48.15 98.83,47.82 98.83,44.8 T132.1
  BOTTOM w0.254: v1(101.78,51.55) 101.75,51.58 UC1.AY68
+DDR_VREF_B_CA: length 147.8
  TOP w0.102: v1(46.95,10.9) v2(47.71,10.9)
  TOP w0.508: RD28.2 46.38,13.05 46.37,13.06 45.53,13.06 RD30.1 45.51,13.06 44.64,13.06 RD29.1 44.64,13.04 44.64,12.17 CD57.1 CD58.1 46.51,11.66 46.95,11.23 v1(46.95,10.9)
  IN3 w0.508: v1(46.95,10.9) 47.17,11.13 47.17,13.03 47.71,13.57 50.29,13.57 51.52,12.34 89.69,12.34 92,14.65 92,18.46 93.53,19.99 118.93,19.99 122.38,16.53 126.49,16.53 130.78,12.24 160.08,12.24 161.06,11.25 174.13,11.25 v1(174.92,10.46)
  BOTTOM w0.305: JDIMM2.164 174.92,11.8 v1(174.92,10.46)
+DDR_VREF_B_DQ: length 75.2
  TOP w0.508: v1(46.54,15.03) 46.33,14.83 CD62.1 RD30.2
  IN4 w0.508: v1(46.54,15.03) 46.54,16.94 51.3,21.7 54.28,21.7 75.68,43.1 v1(79.49,43.1)
  BOTTOM w0.152: 102.04,50.81 102.07,50.83 102.07,51.24 102.39,51.56 UC1.BA67
  BOTTOM w0.203: 102.04,50.81 101.93,50.7 101.88,50.7 101.33,50.15 98.91,50.15 97.77,49.01 96.31,49.01 v2(95.75,48.44)
  BOTTOM w0.508: v1(79.49,43.1) 91.69,43.1 95.42,46.83 95.42,48.11 v2(95.75,48.44)
+DDR_VREF_CA: length 70.1
  TOP w0.127: v2(92.77,13.62) 92.77,13.55 v1(93.13,13.19)
  TOP w0.508: v1(93.13,13.19) 93.33,12.98 RD17.2 CD31.1
  IN4 w0.508: v1(93.13,13.19) 91.68,13.19 90.16,14.71 90.16,18.72 88.78,20.09 86.04,20.09 84.7,21.44 84.7,24.37 78.29,30.78 v1(78.29,41.39)
  BOTTOM w0.203: 99.09,49.73 99.19,49.83 102.24,49.83 102.72,50.31 102.72,52.11 102.5,52.32 UC1.AY67
  BOTTOM w0.381: 99.09,49.73 97.25,47.89
  BOTTOM w0.508: 97.25,47.89 96.59,47.23 96.59,46.33 91.64,41.39 v1(78.29,41.39)
+EC_DEBUG_VCC: length 6.2
  TOP w0.102: v3(236.03,10.17) 236.25,10.38 RE71.2 238.15,10.38 238.79,11.02 v1(238.79,11.96)
  BOTTOM w0.102: JDEG1.1 238.34,12.97 238.79,12.52 v1(238.79,11.96)
+EDP_VDD:
  vias: v2(72.25,84.84)
+LCDVDD:
  vias: v1(66.6,90.85) v1(66.6,90.22) v1(67.24,90.85) v1(67.24,90.22) v3(66.98,89.71) v3(68.51,88.18) v3(69.52,84.37)
+MIC2-VREFO-L: length 3.8
  TOP w0.203: RA5.1 269.79,17.48 v1(269.46,17.48) 269.32,17.62 269.32,18.21 268.48,19.05 UA1.28
+MIC2-VREFO-R: length 3.3
  TOP w0.203: UA1.29 268.51,19.45 269.32,18.64 269.43,18.64 v2(269.66,18.41) 270.47,17.6 RA6.1
+PBATT: length 29.4
  TOP w0.508: PR940.1 35.69,45.36 35.69,44.09 36.09,43.69 36.09,42.97 35.49,42.37 35.49,40.88 36.12,40.24 v1(36.12,40.06)
  IN2 w0.508: v1(40.7,19.22) 39.43,20.49 39.43,32.43 38.27,33.59 38.27,38.64 36.85,40.06 v1(36.12,40.06)
  vias: v2(40.09,16.58)
+PECI_VREF: length 14.7
  TOP w0.254: UE1.J11 v1(267.65,48.16)
  TOP w0.381: RE59.2 276.71,49.74 CE25.1
  TOP w0.508: v1(276.71,50.91) RE59.2
  IN1 w0.508: v1(276.71,50.91) 276.71,49.37 276.34,49.01 274.53,49.01 273.74,48.22 273.09,48.22 271.41,49.89 269.46,49.89 267.73,48.16 v1(267.65,48.16)
+PWR_SRC: length 141
  TOP w0.508: v1(34.9,37.77) 32.99,37.77 32.65,38.11 31.97,38.11 31.31,37.45 PD901.2 ; CZ3.1 51.36,97.13 v1(51.87,97.13) ; v1(263.97,8.37) 264.51,8.91 264.51,11.5 264.29,11.72 RZ85.1
  IN1 w0.508: v1(229.28,13.3) 231.95,10.64 241.7,10.64 243.2,9.13 243.2,8.82 245.1,6.92 245.41,6.92 246.05,6.28 246.05,3.73 246.56,3.22 257.87,3.22 259.03,2.05 263.17,2.05 263.71,2.59 263.71,5.29 264.53,6.12 264.53,7.81 v1(263.97,8.37) ; 149.28,109.65 146.61,106.98 146.61,103.81 v1(144.07,101.27)
  IN3 w0.508: v1(34.9,37.77) 36.03,37.77 38.64,40.37 38.64,41.76 36.92,43.47 v1(36.92,44.27) ; v1(229.28,13.3) 229.28,14.67 228.44,15.51 221.46,15.51 220.53,14.58 220.53,11.91 220.02,11.4 213.24,11.4 213.06,11.58 204.63,11.58 203.76,10.71 198.81,10.71 196.65,12.87 196.65,17.32 196.19,17.78 196.19,19.12 195.6,19.72 193.65,19.72 189.54,23.83 v1(189.54,26.56)
  IN4 w0.508: v1(36.92,44.27) 36.5,44.27 35.92,43.68 35.92,42.08
  BOTTOM w0.508: v1(189.54,26.56) 188.83,27.28 186.82,27.28 ; PR102.2 v1(144.07,101.27) ; PR929.2 36.61,44.27 v1(36.92,44.27)
  vias: v1(21.07,29.08) v1(21.07,28.49) v1(21.07,27.91) v1(21.07,27.33) v1(22.68,26.49) v1(23.13,28.92) v1(23.13,28.33) v1(23.13,27.73) v1(23.19,27.12) v1(23.27,26.49) v1(23.72,29.69) v1(24.03,27.72) v1(24.35,29.69) v1(24.62,27.72) v1(24.99,29.69) v1(25.21,27.73) v1(25.62,29.69) v1(25.81,27.74) v1(26.26,29.69) v1(26.84,29.69) v1(28.64,30.79) v1(28.64,29.55) v1(28.64,28.3) v1(28.64,27.06) v1(34.71,26.83) v1(35.05,26.26) v1(35.05,25.68) v1(35.3,26.83) v1(35.88,26.83) v1(36.48,26.82) v1(47.76,42.8) v1(47.76,42.13) v1(47.76,41.5) v1(48.34,42.78) v1(48.34,42.15) v1(48.34,41.51) v1(48.34,40.9) v1(48.95,42.78) v1(48.95,42.15) v1(48.95,41.55) v1(48.95,40.95) v1(49.59,42.72) v1(49.59,42.13) v1(49.59,41.55) v1(49.59,40.97) v1(57.66,101.29) v1(58.68,101.29) v1(59.43,49.96) v1(59.43,49.32) v1(59.43,48.69) v1(59.43,48.05) v1(60.06,48.05) v1(60.06,47.42) v1(60.7,48.05) v1(60.7,47.42) v1(60.7,46.83) v1(60.7,46.25) v1(61.33,48.05) v1(61.33,47.42) v1(61.33,46.83) v1(61.33,46.25) v1(62.68,58.8) v1(62.67,58.21) v1(63.29,58.8) v1(63.25,58.21) v1(76.82,102.31) v1(77.12,102.84) v1(77.41,102.31) v1(78.01,102.33) v1(157.64,110.84) v1(158.13,111.18) v1(158.16,110.58) v1(158.72,111.18) v1(158.74,110.58) v1(159.3,111.18) v1(159.33,110.58) v1(159.95,111.18) v1(159.92,110.58) v1(160.53,111.17) v1(161.12,111.17) v1(179.25,95.42) v1(179.25,94.2) v1(179.53,95.96) v1(179.63,94.81) v1(179.86,95.42) v1(179.86,94.15) v1(180.22,95.96) v1(180.28,94.78) v1(180.59,95.41) v1(180.57,94.17) v1(180.93,95.93) v1(180.92,94.78) v1(181.22,95.41) v1(181.21,94.17) v3(179.76,103.82)
+PWR_SRC_AC: length 0.9
  TOP w0.102: v3(21.54,40.12) 21.84,40.12 v1(22.24,39.71)
  vias: v1(23.64,40.04) v1(24.22,40.04)
+PWR_SRC_R: length 2.3
  TOP w0.305: RZ85.2 263.38,11.62 263.6,11.39 v3(263.6,11.15) JUSH1.26
+REGCTL_PNP10: length 8.8
  TOP w0.127: v3(263.69,70.17) 263.45,70.17 263.18,69.9 v1(263.07,69.9)
  TOP w0.203: UL1.7 v1(258.71,73.52)
  TOP w0.508: v1(263.07,69.9) 263.1,69.87 LL1.1
  IN2 w0.508: v1(258.71,73.52) 259.2,73.52 261.42,71.29 261.68,71.29 v1(263.07,69.9)
+RREF: length 3.8
  BOTTOM w0.102: v2(75.82,90.05) 76.09,89.79 RR4.1
  BOTTOM w0.203: UR1.9 77.32,92.08
  BOTTOM w0.305: 77.32,92.08 77.32,90.75 76.75,90.17 RR4.1
+RSVD_VCC3P3_1:
  vias: v2(261.36,68.94)
+RTC_CELL: length 411.4
  TOP w0.508: v1(255.2,54.76) 255.6,54.36 RE324.2 ; QE15.3 v1(279.18,64.39) ; v1(248.87,54.02) 248.9,54 RE32.1 ; RE31.1 278.38,55.74 v1(278.44,55.67) ; v1(275.26,57.96) RE551.2 ; v1(47.96,83.9) PC3.1 47.96,82.07 PD3.1
  IN1 w0.508: v1(278.44,55.67) 278.44,58.95 279.18,59.69 v1(279.18,64.39)
  IN2 w0.508: v1(278.44,55.67) 278.57,55.55 278.57,54.28 279.28,53.56 279.28,49.12 280.73,47.67 280.73,45 279.39,43.67 279.39,42.95 282.14,40.2 282.14,36.64 281.39,35.89 281.39,32.09 280.71,31.41 280.71,31.15 280.29,30.73 v1(280.29,30.15) ; v1(83.21,87.58) 81.32,85.68 73.33,85.68 72.63,84.98 72.63,83.25 71.37,81.99 70.01,81.99 68.51,83.49 62.29,83.49 61.4,82.6 56.85,82.6 55.55,83.9 52.66,83.9 51.24,82.47 48.57,82.47 47.96,83.07 v1(47.96,83.9)
  IN3 w0.508: v1(280.29,30.15) 278.13,30.15 277.28,31 275.86,31 275.77,30.91 273.49,30.91 273.36,30.78 271.83,30.78 271.05,30 266.65,30 266.08,29.43 263.46,29.43 v1(263.21,29.19) ; v1(244.99,49.45) 244.99,48.85 242.59,46.45 241.14,46.45 240.37,45.69 240.37,44.61 236.78,41.02 235.84,41.02 235.13,40.31 234.12,40.31 233.63,39.82 232.12,39.82 231.63,40.31 229.41,40.31 228.59,39.49 227.66,39.49 226.57,38.4 220.76,38.4 220.27,37.92 217.5,37.92 217.01,37.42 210.48,37.42 209.12,38.78 204.55,38.78 202.16,41.17 183.55,41.17 182.81,40.43 176.55,40.43 172.2,36.09 169.98,36.09 169.98,38.78 172.39,41.19 172.39,49.39 173.79,50.78 173.79,52.12 173.43,52.48 173.43,53.98 174.43,54.97 174.43,57.5 176.48,59.56 176.59,59.56 176.59,62.59 175.63,63.55 175.63,67.48 175.06,68.06 175.06,76.25 173.97,77.34 173.97,78.41 173.56,78.81 173.56,86.51 171.63,88.44 171.63,91.99 169.35,94.28 169.35,96.25 168.14,97.46 165.41,97.46 163.69,95.74 154.23,95.74 153.83,96.14 125.45,96.14 122.86,98.73 119.31,98.73 118.83,98.25 116.8,98.25 115.82,97.27 114.55,97.27 112.7,95.42 109.33,95.42 109.01,95.11 107.2,95.11 105.82,93.73 105.82,91.81 105.1,91.1 104.38,91.1 104.12,91.36 103.61,91.36 103.31,91.06 101.68,91.06 101.38,91.36 98.96,91.36 98.86,91.26 92.7,91.26 91.89,92.07 87.71,92.07 v1(83.21,87.58)
  IN4 w0.508: v1(244.99,49.45) 244.39,50.05 244.39,50.7 244.8,51.11 245.76,51.11 246.89,52.24 247.45,52.24 248.09,52.88 248.09,53.23 v1(248.87,54.02) 249,54.15 250.37,54.15 251.64,55.42 253.17,55.42 253.83,54.76 v1(255.2,54.76) 255.2,56.56 255.71,57.07 255.71,63.45 256.21,63.95 259.97,63.95 260.51,63.42 263.2,63.42 264.6,62.02 264.6,57.96 265.1,57.45 269.98,57.45 270.34,57.09 271.44,57.09 272.31,57.96 v1(275.26,57.96) 276.15,57.96 v1(278.44,55.67)
  BOTTOM w0.254: RA57.2 263.48,26.79 263.48,27.98 263.21,28.25 v1(263.21,29.19)
  BOTTOM w0.508: RE508.2 RE507.2 245.39,51.84 v2(245.01,51.45) 244.5,50.95 244.5,49.93 v1(244.99,49.45)
+RTC_CELL_PCH: length 193.9
  TOP w0.254: CC213.1 133.33,44.55 RC69.2
  TOP w0.508: RE551.1 276.79,57.96 276.66,58.09 CE63.1 RE546.1 276.89,59.99 277.8,60.91 v1(278.19,60.91) ; RC57.2 153.8,41.44 154.09,41.15 155.13,41.15 RC56.2 156.14,41.82 157,42.68 v1(157,43.59) 157,43.89 157.41,44.29 158.83,44.29 166.88,36.24 182.14,36.24 184.28,38.38 190.02,38.38 190.91,37.49 193.58,37.49 194.57,38.48 v2(197.17,38.48) v1(199.09,38.48) ; QE15.1 v1(279.07,65.35) ; CC213.1 133.33,47.08 132.64,47.76 132.64,49.32
  IN2 w0.508: v1(157,43.59) 154.25,40.84 150.15,40.84 146.5,44.5 137.52,44.5 132.6,49.41 v1(132.6,50.47) ; v1(278.19,60.91) 274.78,60.91 272.17,63.52 269.32,63.52 268.15,64.69 266.45,64.69 265.71,63.95 263.04,63.95 262.01,64.98 260.68,64.98 260.2,64.5 254.5,64.5 v1(254.21,64.79)
  IN4 w0.508: v1(254.21,64.79) 252.47,63.05 252.47,59.72 248.99,56.24 247.7,56.24 244.47,53.02 243.53,53.02 243.2,52.69 241.05,52.69 238.09,49.73 237.04,49.73 232.82,45.51 228.71,45.51 227.2,44.01 219.89,44.01 218.55,42.67 v1(218.55,42.46)
  BOTTOM w0.508: v1(199.09,38.48) 203.08,42.46 v1(218.55,42.46) ; v1(279.07,65.35) 278.19,64.46 v1(278.19,60.91)
  vias: v1(130.14,57.65)
+RTC_CELL_VBAT: length 13.9
  TOP w0.254: UE1.A2 259.96,54.13 259.55,54.55 v1(259.55,54.56) 258.61,55.49 258.61,56.37 CE11.1
  TOP w0.508: RE32.2 250.5,54.47 v2(251.55,55.51) 252.21,56.18 v1(254.44,56.18)
  BOTTOM w0.508: v1(259.55,54.56) 258.35,54.56 257.75,55.15 255.97,55.15 254.94,56.18 v1(254.44,56.18)
+SDC_IN: length 17.1
  TOP w0.381: v1(37.49,73.96) 37.32,74.14 PC1203.1 36.84,74.14 PR1207.1
  TOP w0.508: v1(22.41,43.2) 22.81,42.8 22.81,42.46 23.32,41.96 24.52,41.96 PR943.1 25.14,43.07 25.4,43.34 25.86,43.34 PR944.1
  IN4 w0.508: v1(37.49,73.96) 37.9,73.96 39.81,75.87 v1(45.9,75.87)
  BOTTOM w0.508: PC4.1 v1(53.8,84.78)
  vias: v1(22.46,46.25) v1(22.41,44.98) v1(22.41,44.4) v1(22.41,43.81) v1(23.04,46.25) v1(23.63,46.25) v1(24.21,46.25) v1(24.9,46.24) v1(24.91,45.61) v1(48.61,70.27) v1(48.61,69.68) v1(48.61,69.1) v1(49.22,70.27) v1(49.22,69.68) v1(49.22,69.1) v1(49.83,70.27) v1(49.83,69.68) v1(49.83,69.1) v1(50.41,69.58) v1(52.73,82.98) v1(52.73,82.34) v1(52.73,81.71) v1(52.73,81.07) v3(54.14,82.53)
+SDREG2: length 3.3
  BOTTOM w0.203: 81.13,96.54 80.77,96.18 UR1.24
  BOTTOM w0.508: CR15.1 81.89,98.3 v2(81.89,97.3) 81.13,96.54
+SIM_PWR: length 227.5
  TOP w0.508: CZ41.1 CZ37.1 v1(112.1,96.14) ; v1(125.23,108.25) 124.93,108.56 v2(121.58,108.56) RZ335.1
  IN1 w0.508: v1(248.85,52.35) 246.49,52.35 246.04,51.9 245.3,51.9 244.53,51.13 242.91,51.13 241.48,49.7 240.72,49.7 239.84,48.83 239.84,48.07 239.32,47.54 238.18,47.54 235.3,44.67 233.94,44.67 233.43,45.18 v1(233.43,45.23)
  IN2 w0.508: v1(144.58,104.19) 145.09,104.19 148.65,100.63 153.8,100.63 159.08,95.35 163.87,95.35 165.19,94.03 169.52,94.03 171.51,92.05 171.51,83.83 179.8,75.54 179.8,75.11 185.77,69.13 185.77,64.8 187.79,62.79 187.79,60.35 191.36,56.78 191.36,56.1 201.26,46.2 203.01,46.2 205.1,44.12 207.19,44.12 208.46,42.85 212.17,42.85 212.26,42.76 217.3,42.76 218.26,41.79 220.21,41.79 220.53,42.11 224.17,42.11 225.5,43.44 229.66,43.44 230.23,44.02 232.22,44.02 v1(233.43,45.23)
  IN3 w0.508: v1(144.58,104.19) 143.83,104.94 140.84,104.94 137.84,101.94 129.43,101.94 126.69,104.68 126.69,106.27 125.23,107.72 v1(125.23,108.25)
  BOTTOM w0.305: JNGFF2.36 267.5,37.46 265.32,39.65 264.85,39.65
  BOTTOM w0.508: v1(248.85,52.35) 249.09,52.1 249.09,51.16 250.42,49.83 252.43,49.83 253.61,48.65 253.61,48.5 254.94,47.16 256.29,47.16 257.69,45.77 259.47,45.77 260.48,44.75 262.64,44.75 263.49,43.9 263.49,42.48 263.5,42.46 263.5,40.99 264.85,39.65 ; JSIM1.1 v1(112.1,96.14) 112.91,96.14 113.47,96.69 113.47,99.61 120.83,106.98 124.77,106.98 125.28,107.49 125.28,108.21 v1(125.23,108.25)
+TBTA_LDO_BMC: length 2.5
  TOP w0.203: CT71.1 27.8,65.83 27.8,65.35 28,65.15 28,64.8 27.69,64.5 UT5.E1
+TBTA_VBUS: length 5.1
  TOP w0.102: v1(13.09,80.31) v3(13.76,80.31)
  IN2 w0.457: v1(8.85,72.53) 8.51,72.87 v1(6.77,72.87)
  IN3 w0.457: 7.88,72.87 v1(6.77,72.87) ; v1(6.79,69.9) 7.93,69.9
  vias: v1(8.5,70.51) v1(9.08,70.51) v1(9.4,73.15) v1(9.45,72.53) v1(9.67,70.51) v1(9.99,73.12) v1(9.91,69.97) v1(11.04,80.27) v1(11.03,79.68) v1(11.03,79.09) v1(11.03,78.51) v1(11.03,77.92) v1(13.11,79.7) v1(13.14,79.09) v1(13.14,78.51) v1(13.14,77.92)
+TBTA_VBUS_1: length 31.2
  TOP w0.254: v1(30.32,59.66) 30.17,59.81 UT5.A10 UT5.B10
  TOP w0.508: v1(51.95,77.26) 52.29,77.26 52.64,76.92 PR1239.1
  IN3 w0.508: v1(36,60.93) 38.21,60.93 43.49,66.21 50.09,66.21 51.35,67.47 51.35,72.42 52.38,73.45 52.38,76.83 v1(51.95,77.26)
  vias: v1(10.34,59.99) v1(10.34,59.23) v1(10.34,58.59) v1(10.34,57.96) v1(15.22,81.83) v1(15.83,81.83) v1(16.44,81.83) v1(16.45,79.94) v1(17.04,81.81) v1(17.09,79.94) v1(17.67,81.81) v1(17.72,79.94) v1(18.31,81.81) v1(18.36,79.94) v1(25.1,58.85) v1(25.1,58.27) v1(25.1,57.68) v1(25.76,58.86) v1(25.76,58.28) v1(25.76,57.69) v1(30.81,59.34) v1(34.78,60.24) v1(34.78,59.61) v1(34.78,58.97) v1(35.41,60.24) v1(35.41,59.61) v1(35.41,58.97) v1(36.05,60.24) v1(36.05,59.61) v1(36.05,58.97) v3(37.7,60.23)
+USB_EX2_PWR:
  vias: v1(17.07,27.38) v1(17.07,26.79) v1(17.07,26.21) v1(17.58,25.83) v1(26.47,20.11) v1(26.47,19.53) v1(27.11,20.11) v1(27.11,19.53) v3(19.96,25.66)
+UZ12_TPM: length 1.8
  TOP w0.127: v2(161.19,56.8) 160.79,56.4 159.53,56.4
+UZ12_VHIO: length 19.8
  TOP w0.203: UZ12.22 156.85,62.93 156.53,63.24 v1(156.51,63.24) 156.05,63.7 CZ53.1
  TOP w0.254: RZ365.1 RZ366.1 156.1,63.85 CZ53.1 ; 160.96,60.78 160.76,60.58 UZ12.14
  TOP w0.356: 160.96,60.78 161.35,61.16 CZ54.1
  TOP w0.381: CZ54.1 163.28,61.22 CZ55.1 164.19,61.91 164.19,61.06 163.89,60.75 163.89,60.55 v1(162.64,59.31)
  IN1 w0.508: v1(156.51,63.24) 157.22,63.24 157.79,62.67 159.49,62.67 162.64,59.52 v1(162.64,59.31)
  BOTTOM w0.102: v2(156.19,63.67) 156.51,63.36 v1(156.51,63.24)
+VCHGR:
  vias: v1(41.58,27.48) v1(41.58,26.84) v2(40.43,27.64)
+VHDMI_VCC: length 8.6
  BOTTOM w0.254: v1(22.81,49.25) 22.9,49.34 23.39,49.34 RV22.2
  BOTTOM w0.508: CV40.1 15.83,54.99 16.59,55.75 18.57,55.75 19.74,54.58 RV23.2
  vias: v1(14.43,53.74) v1(14.43,53.16) v1(14.43,52.47) v2(14.95,52.45)
+VR_CAP: length 23.2
  TOP w0.254: UE1.J1 258.18,47.73 v1(258.12,47.67) ; UE1.C10 v1(266.82,52.93)
  TOP w0.406: v1(268.79,58.09) 269.04,57.83 CE31.1
  BOTTOM w0.406: v1(268.79,58.09) 268.41,57.7 268.41,57.2 267.77,56.56 267.77,53.64 267.06,52.93 v1(266.82,52.93) 266.63,53.13 266.63,53.89 266.12,54.4 262.16,54.4 259.88,52.13 259.88,48.78 v3(259.22,48.12) 258.77,47.67 v1(258.12,47.67)
+Z4012: length 5
  TOP w0.102: PD3.2 48.01,79.98 48.21,80.19 48.21,81.02 48.72,81.53 49.48,81.53 v2(49.81,81.86)
  TOP w0.508: PR2.2 46.74,80.74 PD3.2
AC1_DISC#: length 102.3
  TOP w0.102: PR939.1 21.26,50.56 21.26,52.07 v1(21.44,52.24) 21.76,52.56 22.47,52.56 22.91,52.12 23.45,52.12 24.39,53.06 24.39,53.67 24.36,53.69 24.36,54.48 RT72.2 ; PR1244.1 51.63,52.99 52.38,52.24 52.38,46.53 53.27,45.64 53.27,35.99 52,34.72 v2(52,28.44) v1(52,27.48)
  IN3 w0.122: v1(21.44,52.24) 21.31,52.24 20.63,51.56 20.63,43.07 21.11,42.59 21.2,42.59 21.77,42.02 21.77,40.94 20.27,39.44 20.27,34.36 18.95,33.04 18.95,26.94 22.23,23.67 33.2,23.67 34.6,22.27 36,22.27 39.43,25.7 41.89,25.7 45.83,29.64 48.57,29.64 50.73,27.48 v1(52,27.48)
AC1_DISC#_R: length 4.9
  TOP w0.102: UT5.G11 26.76,59.24 26.76,58.06 v2(26.76,58.05) 26.42,57.71 26.42,55.62 RT72.1
AC_DIS: length 309
  TOP w0.076: 269.68,48 269.3,48 269.07,48.22 268.33,48.22 UE1.H12
  TOP w0.102: RE83.1 273.88,47.34 v1(273.61,47.61) 273.55,47.61 273.41,47.75 270.62,47.75 270.36,48 269.68,48 ; PR927.1 22.77,48.09 22.94,48.27 PQ909.2 23.73,48.27 24.82,49.37 24.82,51.79 25.07,52.04 27.21,52.04 27.44,51.81 27.44,50.97 v1(27.11,50.64)
  IN2 w0.122: v1(273.61,47.61) 273.87,47.86 273.87,51.55 272.79,52.62 272.03,52.62 270.41,54.24 270.41,55.06 269.04,56.43 266.37,56.43 265.76,57.04 262.73,57.04 262.45,57.32 260.72,57.32 260.21,57.83 257.61,57.83 257.23,58.21 256.32,58.21 255.72,57.62 253.57,57.62 249.36,53.4 249.36,51.74 248.54,50.92 248.54,48.74 249.08,48.2 249.08,46.85 248.52,46.3 248.52,45.15 247.48,44.11 246.38,44.11 244.52,42.25 244.52,41.97 244.2,41.65 244.2,40.51 238.32,34.63 237.23,34.63 236.59,33.99 235.8,33.99 235.76,33.95 233.84,33.95 232.18,32.29 228.06,32.29 226.27,30.5 225.47,30.5 225.16,30.81 222.7,30.81 221.94,30.04 217.39,30.04 217.1,30.33 215.08,30.33 214.86,30.55 211.35,30.55 210.08,31.82 204.96,31.82 204.5,32.28 184.53,32.28 181.1,28.85 173.7,28.85 173.35,29.21 155.36,29.21 153.47,27.32 143.3,27.32 136.74,33.88 98.43,33.88 96.28,31.73 73.3,31.73 70.67,34.36 65.71,34.36 53.67,46.4 52.55,46.4 51.83,47.13 47.84,47.13 47.05,47.93 46.69,47.93 45.85,47.09 43.06,47.09 42.75,46.78 41.01,46.78 39.04,48.74 39.04,51.33 37.82,52.55 36.73,52.55 36.53,52.35 34.97,52.35 33.91,51.29 33.91,49.84 33.6,49.53 28.22,49.53 v1(27.11,50.64)
  BOTTOM w0.102: v1(273.61,47.61) v2(273.04,47.61)
AC_DISC#: length 334.4
  TOP w0.127: v2(47.52,47.42) v1(46.79,47.42)
  TOP w0.254: PR1231.1 41.74,56.36 41.74,57.3 PQ1210.6 ; PQ1210.6 42.04,57.31 42.94,58.21 v1(42.94,58.91) 43.16,59.13 44.4,59.13 44.78,58.75 PQ1211.6 44.78,57.99 46.08,56.69 PQ1211.3 ; PQ1210.6 41.27,57.31 PR1245.1 ; v1(270.18,51.16) 269.79,50.77 268.99,50.77 UE1.E13 ; v1(58.09,83.49) 58.64,84.03 PR25.2 61.95,83.97 PC1217.1 ; PR1223.2 36.89,67.68 v1(37.04,67.53)
  IN2 w0.254: v1(46.79,47.42) 47.41,46.8 51.66,46.8 52.43,46.02 53.52,46.02 65.55,33.99 70.56,33.99 73.17,31.38 96.38,31.38 98.44,33.44 136.72,33.44 143.26,26.89 153.59,26.89 155.15,28.46 181.78,28.46 185.22,31.9 204.44,31.9 205.66,30.68 210.41,30.68 211.07,30.02 216.97,30.02 217.91,29.07 221.41,29.07 222.79,30.45 225.06,30.45 225.34,30.17 226.45,30.17 228.25,31.98 236.44,31.98 241.72,37.26 242.9,37.26 243.43,37.78 243.43,39.06 244.52,40.15 244.52,41.46 245.08,42.02 245.08,42.35 246.52,43.8 247.62,43.8 248.87,45.06 248.87,46.19 250.14,47.46 250.14,50.03 249.8,50.38 249.8,53.26 251.17,54.63 251.34,54.63 253.89,57.18 255.55,57.18 255.83,56.9 257.94,56.9 258.04,57.01 262.3,57.01 262.81,56.5 265.8,56.5 266.18,56.12 268.86,56.12 270.06,54.92 270.06,53.64 270.18,53.51 v1(270.18,51.16) ; v1(37.04,67.53) 37.22,67.36 37.72,67.36 39.01,66.07 39.01,61.3 40.95,59.36 42.52,59.36 42.94,58.94 v1(42.94,58.91)
  IN3 w0.254: v1(46.79,47.42) 46.79,47.91 46.54,48.17 46.54,48.18 46.51,48.21 46.51,48.61 46.54,48.63 46.54,55.55 45.65,56.43 42.73,56.43 42.28,56.88 42.28,57.77 42.94,58.43 v1(42.94,58.91)
  IN4 w0.254: v1(37.04,67.53) 36.57,68 36.57,69.44 37.41,70.28 37.41,70.8 39.04,72.44 41.15,72.44 43.71,74.99 45.93,74.99 50.41,79.47 52.56,79.47 55.3,82.22 56.82,82.22 v1(58.09,83.49)
AC_PRESENT: length 174
  TOP w0.102: v2(168.06,45.21) 167.72,45.55 v1(167.72,45.64) 167.8,45.72 RC243.1 ; UE1.K8 264.85,46.93 v1(265.23,47.31)
  IN1 w0.089: v1(263.81,33.6) 263.1,32.89 261.35,32.89 260.23,31.77 259.8,31.77 259.44,31.42 256.72,31.42 256.39,31.75 249.69,31.75 248.82,30.88 246.31,30.88 245.01,32.18 241.46,32.18 238.21,28.93 235.84,28.93 235.36,29.41 234.24,29.41 233.86,29.03 230.66,29.03 230.28,29.41 225.02,29.41 224.74,29.69 222.56,29.69 221.61,28.74 218.03,28.74 217.03,27.73 215.22,27.73 214.71,28.24 211.84,28.24 209.55,30.53 207.85,30.53 205.41,32.97 202.01,32.97 201.05,33.93 199.65,33.93 197.39,36.19 194.92,36.19 194.52,36.6 190.58,36.6 184.22,42.95 180.56,42.95 180.01,43.5 180.01,44.42 178.39,46.05 168.13,46.05 v1(167.72,45.64)
  IN3 w0.122: v1(263.81,33.6) 263.81,34.35 266.5,37.04 266.5,45.13 266.4,45.23 266.4,46.14 v1(265.23,47.31)
  BOTTOM w0.076: UC1.AY15 131.9,52.15 131.73,51.87 131.62,51.76 131.62,49.98 133.93,47.67 134.43,47.67 134.56,47.55
  BOTTOM w0.102: 134.56,47.55 135.46,46.65 135.46,45.51 136.33,44.63 138.22,42.75 144.19,42.75 148.14,38.8 162.63,38.8 166.04,42.21 166.04,43.35 167.72,45.03 v1(167.72,45.64)
ACAV_IN: length 289.6
  TOP w0.076: 263.99,52.53 264.43,52.98 v1(264.43,53.67)
  TOP w0.102: v1(52.62,40.71) 52.62,40.17 51.49,39.04 v2(51.49,38.77) 51.49,37.11 50.47,36.09 47.43,36.09 46.16,37.36 44.47,37.36 43.97,37.86 37.81,37.86 37.42,38.25 37.42,40.04 36.15,41.3 36.15,42.09 36.89,42.83 36.89,43.11 38.27,44.49 38.27,46.59 38.13,46.72 37.48,47.37 37.11,47.37 36.75,47.74 35.68,47.74 34.68,48.73 34.35,48.73 34.08,48.46 33.87,48.46 33.63,48.7 33.63,48.7 33.52,48.82 33.52,49.41 33.81,49.7 33.81,50.72 32.26,52.27 29.8,52.27 29.49,51.96 29.49,49.86 29.05,49.41 28.45,49.41 28.29,49.25 28.29,47.88 PR946.2 27.36,47.79 PR953.1 ; UE1.C7 263.99,52.53
  IN2 w0.122: v1(264.43,53.67) 264.2,53.89 260.91,53.89 258.63,51.61 256.91,51.61 254.15,48.85 254.15,48.01 253.04,46.9 253.04,45.89 252.43,45.27 252.43,44.52 251.77,43.87 251.77,42.18 249.99,40.4 249.99,39.7 249.08,38.78 248.11,38.78 247.04,37.71 247.04,36.44 246.18,35.58 244.91,35.58 244.27,34.94 242.68,34.94 238.29,30.55 238.29,29.04 237.88,28.62 234.88,28.62 234.05,27.8 230.42,27.8 229.04,26.41 223.56,26.41 223.26,26.72 217.38,26.72 217.07,26.41 209.53,26.41 209.14,26.8 208.43,26.8 206.82,28.41 204.55,28.41 204.38,28.24 199.38,28.24 198.57,29.05 197.18,29.05 196.31,29.92 186.55,29.92 183.14,26.51 155.99,26.51 154.22,24.74 142.59,24.74 135.79,31.54 99.35,31.54 97.29,29.49 72.31,29.49 69.78,32.03 64.32,32.03 55.84,40.5 52.83,40.5 v1(52.62,40.71)
ACAV_IN1: length 8.6
  TOP w0.102: v1(24.85,46.91) 24.85,46.94 25.37,47.46 PQ909.1 ; PQ909.1 25.94,47.05 25.94,46.21 25.76,46.03 v2(25.76,45.81) PR918.1 ; PQ909.1 25.63,47.62 25.96,47.95 PR942.1
  BOTTOM w0.102: PR928.1 25.62,46.91 v1(24.85,46.91) 24.06,46.91 PR925.1
ACIN_ISL9538: length 3.8
  TOP w0.381: PR945.1 28.33,43.5 PC955.1 28.29,43.42 v1(27.71,43.42) 27.52,43.61 PR944.2
  BOTTOM w0.203: v1(27.71,43.42) 28.19,43.42 28.21,43.44 PU901.19
ACOK_ISL9538: length 3.8
  BOTTOM w0.102: v2(27.03,48.31) PR928.2
  BOTTOM w0.203: PU901.24 28.68,45.76 28.68,45.97 27.8,46.85 27.59,46.85 PR928.2
ADP_ISL9538: length 5
  TOP w0.203: v1(28.82,42) 28.99,42.16 28.99,42.48 v2(28.95,42.52) 28.88,42.58 28.09,42.58 27.8,42.29 26.83,42.29 PR943.2
  BOTTOM w0.203: v1(28.82,42) 28.82,41.66 29.02,41.46 29.5,41.46 29.65,41.61 PU901.16
ALW_PWRGD_3V_5V: length 99
  TOP w0.102: UZ6.2 201.45,35.59 DC2.1 201.22,38.13 199.86,39.49 193.65,39.49 193.6,39.54 191.79,39.54 191.36,39.11 v1(190.73,39.11) ; v1(145.85,100.88) 147.5,99.23 147.5,98.04 v2(151.08,94.47) 152.84,92.71 v1(153.57,92.71)
  IN2 w0.122: v1(153.57,92.71) 156.75,89.53 156.75,86.53 157.65,85.63 157.65,84.22 158.22,83.65 159.45,83.65 161.01,82.09 161.01,81.61 163.25,79.37 164.31,79.37 165.66,78.03 165.66,77 179.33,63.32 179.33,62.58 180.18,61.73 180.18,58.91 184.97,54.12 184.97,46.38 189.92,41.42 189.92,39.92 v1(190.73,39.11)
  BOTTOM w0.102: v1(145.85,100.88) 145.65,101.09 PR120.2 PR119.2
ALWON: length 273.5
  TOP w0.076: 261.8,55.93 261.8,55.04 262.42,54.42 UE1.A5
  TOP w0.102: v1(46.99,48.41) 46.99,48.87 45.7,50.16 45.7,50.59 45.52,50.77 42.28,50.77 42.04,50.53 42.04,49.16 41.75,48.87 40.68,48.87 v2(40.2,48.38) 38.74,46.92 38.74,44.31 37.51,43.08 37.51,40.95 37.81,40.65 PR114.1 ; v1(261.77,59.46) 261.77,58.55 262.03,58.29 262.03,57.32 261.55,56.84 261.55,56.28 261.8,56.03 261.8,55.93
  IN2 w0.122: v1(261.77,59.46) 261.77,60.05 261.6,60.22 257.38,60.22 255.22,58.06 253.57,58.06 249.09,53.58 248.73,53.58 248.21,53.06 248.21,48.56 248.8,47.98 248.8,46.98 248.28,46.46 248.28,45.55 247.27,44.55 246.45,44.55 244.25,42.35 244.25,42.08 243.95,41.78 243.95,40.61 238.22,34.88 237.12,34.88 236.49,34.24 235.7,34.24 235.65,34.19 233.73,34.19 232.08,32.54 227.95,32.54 226.17,30.76 225.7,30.76 225.34,31.11 222.65,31.11 221.83,30.29 217.49,30.29 217.2,30.58 215.18,30.58 214.78,30.99 211.58,30.99 210.5,32.06 205.07,32.06 204.61,32.53 184.43,32.53 181.02,29.12 173.79,29.12 173.3,29.61 155.36,29.61 153.32,27.57 143.52,27.57 136.88,34.21 98.2,34.21 95.98,31.99 73.42,31.99 70.79,34.61 65.81,34.61 53.92,46.51 53.74,46.68 52.63,46.68 51.93,47.38 48.08,47.38 47.05,48.41 v1(46.99,48.41)
AR_DET#: length 16.9
  BOTTOM w0.076: UC1.P4 138.76,66.16 139.16,66.56 140.38,66.56 140.58,66.64 140.78,66.84 142.44,66.84 142.44,66.84
  BOTTOM w0.102: RC400.1 RC401.1 152.61,67.85 151.16,67.85 150.37,68.64 148.41,68.64 147.78,68.02 v2(146.77,68.02) 145.77,68.02 145.54,67.79 143.58,67.79 142.63,66.84 142.44,66.84
AUD_HP_NB_SENSE: length 55.6
  TOP w0.102: v1(284.66,3.7) 284.66,4.76 v3(285.25,5.34)
  TOP w0.254: v1(284.66,3.7) 283.67,3.7 DA2.3 283.44,4.67 v1(283.8,5.03) ; v1(258.5,23.14) 258.22,23.41 RA60.2
  IN1 w0.254: v1(258.5,23.14) 259.8,23.14 261.4,21.54 267.95,21.54 268.43,22.02 269.55,22.02 271.96,24.43 274.62,24.43 275.01,24.04 275.01,17.83 276.66,16.18 276.66,15.01 277.04,14.63 277.04,13.89 278.95,11.98 278.95,11.3 280.42,9.83 282.12,9.83 282.48,9.47 282.48,8.07 283.8,6.75 v1(283.8,5.03)
  IN4 w0.254: JHP1.6 290.16,2.5 289.36,1.7 285.81,1.7 284.66,2.84 v1(284.66,3.7)
AUD_HP_OUT_L: length 18.4
  TOP w0.381: LA15.1 278.72,7.49 v1(279.1,7.11) ; v1(272.09,16.1) 271.86,15.87 RA7.1
  IN1 w0.381: v1(279.1,7.11) 279.1,10.05 278.19,10.97 278.19,11.86 276.41,13.64 276.41,14.17 275.99,14.59 275.99,15.76 274.93,16.81 273.87,16.81 272.85,17.83 272.14,17.83 271.71,17.4 271.71,16.48 v1(272.09,16.1)
AUD_HP_OUT_L1: length 14.6
  TOP w0.102: v3(278.4,9.89) 278.72,9.57 LA15.2
  TOP w0.381: v1(282.25,7.16) 282.25,7.41 281.69,7.97 DA1.2 280.52,7.97 280.21,8.28 280.19,8.28 279.84,8.63 CA3.1 279.58,8.73 LA15.2
  IN2 w0.381: JHP1.1 287.84,12.26 286.08,12.26 284.28,10.46 284.28,9.57 283.65,8.94 283.39,8.94 282.25,7.79 v1(282.25,7.16)
AUD_HP_OUT_R: length 15
  TOP w0.381: LA16.1 278.44,6.14 v1(278.44,6.52) ; RA8.1 v1(271.66,14.65)
  IN3 w0.381: v1(278.44,6.52) 278.44,10.71 278.19,10.97 278.19,12.37 275.65,14.91 271.91,14.91 v1(271.66,14.65)
AUD_HP_OUT_R1: length 21.8
  TOP w0.127: v3(285.27,7.12) 284.19,6.04 v1(282.86,6.04)
  TOP w0.381: v1(282.86,6.04) DA1.3 280.88,6.04 279.79,4.95 CA2.1 278.78,4.95 LA16.2
  IN2 w0.381: JHP1.2 293.6,2.38 292.82,1.6 285.91,1.6 284.79,2.71 283.9,2.71 282.86,3.76 v1(282.86,6.04)
AUD_PC_BEEP: length 10.1
  TOP w0.203: v1(269.9,21.15) 269.78,21.28 269.5,21.28 269.2,21.58 268.58,21.58 268.45,21.45 UA1.34
  TOP w0.254: CA28.2 v1(274.46,23.87) CA27.2
  IN1 w0.254: v1(274.46,23.87) 274.46,23 273.61,22.14 270.9,22.14 v1(269.9,21.15)
  BOTTOM w0.102: v1(274.46,23.87) v2(275.01,23.87)
AUD_PWR_EN: length 155.2
  TOP w0.102: UZ5.5 245.15,39.04 v1(245.19,39.09) ; v1(245.19,39.09) 245.39,39.29 245.8,39.29 246.13,38.96 246.13,38.33 245.95,38.15 UZ5.3 ; v1(245.19,39.09) 245.03,39.25 244.66,39.25 v2(244.59,39.19) ; v1(151.96,60.83) 152.77,60.02 RC279.1
  IN3 w0.122: v1(211.76,22.02) 212.65,22.91 212.65,27.73 213.03,28.11 214.48,28.11 215.07,27.53 217.32,27.53 217.91,28.12 221.17,28.12 222.93,29.88 224.73,29.88 225.02,29.59 228.1,29.59 228.31,29.8 235.35,29.8 236.48,28.67 237.72,28.67 238.13,29.09 238.13,30.58 244.91,37.36 244.91,38.51 245.19,38.79 v1(245.19,39.09)
  IN4 w0.089: v1(211.76,22.02) 208.66,22.02 207.9,21.26 202.49,21.26 199.95,23.8 199.95,25.4 198.77,26.58 198.77,28.13 195.02,31.87 193.63,31.87 186.95,38.55 186.95,39.04 180.8,45.18 180.8,48.21 179.3,49.7 179.3,51.81 177.4,53.72 174.15,53.72 173.58,53.14 173.58,52.66 172.99,52.08 172.09,52.08 170.68,53.49 166.9,53.49 165.57,54.82 163.9,54.82 162.98,55.74 162.98,56.19 162.89,56.28 162.24,56.94 160.29,56.94 159.77,57.45 155.73,57.45 155.1,58.08 155.1,59.13 154.24,59.99 153.39,59.99 152.94,60.44 152.94,61 152.65,61.3 152.43,61.3 v1(151.96,60.83) 151.65,60.83 151.4,61.08 150.93,61.08 150.64,61.38 145.73,61.38 144.81,60.45 142.73,60.45 142.17,61.01 141.03,61.01 138.44,63.59 137.39,63.59 v1(136.87,63.08)
  BOTTOM w0.076: UC1.W8 v1(136.87,63.08)
AUD_SENSE_A: length 9
  TOP w0.203: 262.44,23.06 262.48,23.1 UA1.48
  TOP w0.254: RA59.2 256.18,26.86 v2(256.18,26.03) 256.18,25.71 256.75,25.14 257.76,25.14 258.25,24.66 258.58,24.66 259.11,24.13 RA60.1 259.47,23.8 259.87,23.8 CA41.1 260.38,23.29 261.4,23.29 261.62,23.06 262.44,23.06
AUD_SENSE_B: length 8.2
  TOP w0.102: v1(262.12,23.53) 262.5,23.53 262.72,23.75 263,23.75 263.18,23.56 UA1.47
  BOTTOM w0.102: v2(266.67,26.78) 266.61,26.72 RA61.2 265.13,26.72 264.93,26.51 264.93,25.5 262.96,23.53 v1(262.12,23.53)
AUX1_SNOOP_EN#: length 5.3
  TOP w0.102: UT9.29 25.33,77.68 24.86,78.15 24.32,78.15 RT308.1 23.74,77.87 22.58,79.03 v2(22.39,79.03) 21.44,79.03 RT416.1
AUX_EN_WOWL: length 57.7
  TOP w0.076: v1(257.13,51.07) 257.67,51.61 258.75,51.61 258.94,51.42 260.51,51.42 UE1.D3
  TOP w0.102: RZ70.1 218.19,34.82 DZ9.2 220.3,35.54 220.3,36.75 v2(219.2,37.84) 219.13,37.91 v1(219.13,38.91)
  IN1 w0.089: v1(219.17,42.4) 219.18,42.4 230.87,42.4 231.83,43.35 235.89,43.35 238.82,46.27 240.78,46.27 241.42,46.91 242.63,46.91 244.15,48.43 244.9,48.43 245.92,49.45 246.61,49.45 246.84,49.68 247.63,49.68 248.54,50.59 251.11,50.59 252.51,51.99 253.04,51.99 253.67,52.62 255.58,52.62 257.13,51.07 v1(257.13,51.07)
  BOTTOM w0.102: v1(219.13,38.91) 219.17,38.95 v1(219.17,42.4)
BAT1_LED#: length 85.5
  TOP w0.076: UE1.D10 v1(266.81,52.12)
  TOP w0.254: RZ28.1 272.48,13.01 272.03,12.56 v2(272.03,12.49) 272.03,11.67 v1(271.96,11.6)
  IN2 w0.254: v1(282.93,36.08) 283.67,35.34 283.67,31.82 282.88,31.03 282.88,29.27 282.21,28.6 279.82,28.6 279.61,28.81 276.4,28.81 275.83,28.24 274.27,28.24 273.06,27.03 272.48,27.03 271.92,26.48 267.59,26.48 267.15,26.03 266.15,26.03 264.49,24.38 264.49,18.85 264.24,18.6 262.58,18.6 262.23,18.25 262.23,16.85 261.29,15.91 261.29,13.27 262.27,12.29 271.28,12.29 v1(271.96,11.6)
  BOTTOM w0.254: v1(266.81,52.12) 268,52.12 268.4,52.52 274.35,52.52 277.8,49.07 277.8,45.74 279.15,44.4 279.15,41.66 278.25,40.76 278.25,39.19 280.16,37.28 281.73,37.28 v1(282.93,36.08)
BAT2_LED#: length 44
  TOP w0.076: v1(269.55,51.25) 267.71,51.25 UE1.D11
  TOP w0.127: v3(270.78,33.16) 270.62,32.99 v1(270.62,32.43)
  TOP w0.254: RZ361.1 270.36,32.18 v1(270.62,32.43) ; v1(283.11,36.67) 282.88,36.9 QZ2.1
  IN3 w0.254: v1(269.55,51.25) 269.55,49.7 270.39,48.87 270.39,46.81 271.58,45.61 271.58,43.95 271.01,43.38 271.01,42.66 269.55,41.19 269.55,39.04 269.8,38.78 269.8,33.24 v1(270.62,32.43)
  IN4 w0.254: v1(270.62,32.43) 270.62,32.25 271.07,31.8 271.33,31.8 272.34,30.78 275.77,30.78 275.86,30.87 278.48,30.87 278.82,30.53 279.91,30.53 280.83,31.44 280.83,32.12 282.63,33.93 282.65,33.93 283.65,34.92 283.65,36.14 v1(283.11,36.67)
