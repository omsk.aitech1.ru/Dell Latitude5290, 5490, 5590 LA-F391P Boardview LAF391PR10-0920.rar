# Allegro board LAF391PR10-0920.brd (continued)
## Nets (continued)
PCIE_PTX_C_DRX_N11: CN69.1 JNGFF3.35
PCIE_PTX_C_DRX_N12: CN71.1 JNGFF3.47
PCIE_PTX_C_DRX_P1: CR11.2 UR1.3
PCIE_PTX_C_DRX_P3: CZ12.2 JNGFF1.35
PCIE_PTX_C_DRX_P4: CL5.2 UL1.41
PCIE_PTX_C_DRX_P8: CZ11.2 JNGFF2.49
PCIE_PTX_C_DRX_P11: CN70.1 JNGFF3.37
PCIE_PTX_C_DRX_P12: CN72.1 JNGFF3.49
PCIE_PTX_C_RD_DRX_N11: CN23.2 UN4.2
PCIE_PTX_C_RD_DRX_N12: CN33.2 UN5.2
PCIE_PTX_C_RD_DRX_P11: CN22.2 UN4.1
PCIE_PTX_C_RD_DRX_P12: CN32.2 UN5.1
PCIE_PTX_DRX_N1: CR12.1 UC1.B17
PCIE_PTX_DRX_N3: CZ13.1 UC1.D17
PCIE_PTX_DRX_N4: CL6.1 UC1.B19
PCIE_PTX_DRX_N8: CZ10.1 UC1.D21
PCIE_PTX_DRX_N11: CN23.1 UC1.D24
PCIE_PTX_DRX_N12: CN33.1 UC1.A25
PCIE_PTX_DRX_P1: CR11.1 UC1.A17
PCIE_PTX_DRX_P3: CZ12.1 UC1.C17
PCIE_PTX_DRX_P4: CL5.1 UC1.A19
PCIE_PTX_DRX_P8: CZ11.1 UC1.C21
PCIE_PTX_DRX_P11: CN22.1 UC1.C24
PCIE_PTX_DRX_P12: CN32.1 UC1.B25
PCIE_PTX_RD_DRX_N11: CN69.2 UN4.17
PCIE_PTX_RD_DRX_N12: CN71.2 UN5.17
PCIE_PTX_RD_DRX_P11: CN70.2 UN4.18
PCIE_PTX_RD_DRX_P12: CN72.2 UN5.18
PCIE_RCOMPN: RC45.1 UC1.F5
PCIE_RCOMPP: RC45.2 UC1.E5
PCIE_WAKE#: JNGFF1.55 JNGFF1.70 JNGFF2.54 JNGFF3.54 RE274.1 RE275.1
PCIE_WAKE#_R: RE35.1 RE275.2 UE1.N13
PD1_GPIO2: RT71.1 UT5.D10
PD1_GPIO6: RT75.1 UT5.G10
PD1_GPIO7: RT339.1 UT5.D7
PD1_GPIO8: RT76.1 RT377.1 UT5.H6
PD#: CA31.2 DA8.2 RA18.2 RA48.2 RA50.2 UA1.2
PDA_RESET#_R: RT110.2 UT5.F11
PECI_EC: RE60.2 UC1.A54
PECI_EC_R: RE60.1 UE1.K13
PGOOD_3V: PR107.2 PR119.1 PU100.9
PGOOD_5V: PR113.2 PR120.1 PU102.9
PLTRST_LAN#: RC62.2 UL1.36
PLTRST_TPM#: RC60.2 RC325.2 UZ12.17
PM_LANPHY_ENABLE: RL7.1 UC1.AW17
PME#: T115.1(TP-1) UC1.AU11
POA_WAKE#: RE324.1 RZ364.1 UE1.E4
POWER_SW#_MB: CE10.1 JAPS1.11 RE33.2 SW3.2 SW3.4
POWER_SW_IN#: CE12.1 RE31.2 RE33.1 UE1.D5
PROCHOT#: CC310.1 PC605.2 PR678.1 PR926.1 RC83.1 RC84.1 RE288.2
PROCHOT#_ISL9538: PQ1216.1 PR926.2 PU901.23
PROCHOT#_R: RC84.2 UC1.C65
PROCHOT#_R1: RE288.1 UE1.H13
PS_ID: PR4.1 PR5.2 UE1.J8
PWM1_IA: PR687.1 PU602.12
PWM2_IA: PR692.1 PU602.13
PWM_FAN1: JFAN1.2 RE48.2 UE1.L10
PWM_GT: PR664.1 PU602.22
PWM_SA: PR606.1 PU614.3
PWM_VSA: PR606.2 PU602.30
RD1_A_DE0: RN25.2 RN38.1 UN4.6
RD1_A_DE1: RN26.2 RN39.1 UN4.8
RD1_A_EQ0: RN42.2 RN179.1 UN4.23
RD1_A_EQ1: RN43.2 RN176.1 UN4.22
RD1_A_EQ2: RN44.2 RN174.1 UN4.19
RD1_B_DE0: RN27.2 RN40.1 UN4.13
RD1_B_DE1: RN28.2 RN41.1 UN4.9
RD1_B_EQ0: RN49.2 RN52.1 UN4.11
RD1_B_EQ1: RN50.2 RN53.1 UN4.21
RD1_B_EQ2: RN51.2 RN54.1 UN4.16
RD1_REXT: RN30.1 UN4.10
RD2_A_DE0: RN55.2 RN59.1 UN5.6
RD2_A_DE1: RN56.2 RN60.1 UN5.8
RD2_A_EQ0: RN225.2 UN5.23
RD2_A_EQ0_R: QN5.3 RN63.2 RN225.1
RD2_A_EQ1: RN224.2 UN5.22
RD2_A_EQ1_R: QN5.6 RN64.2 RN224.1
RD2_A_EQ2: RN223.2 UN5.19
RD2_A_EQ2_R: QN4.3 RN65.2 RN223.1
RD2_B_DE0: RN57.2 RN61.1 UN5.13
RD2_B_DE1: RN58.2 RN62.1 UN5.9
RD2_B_EQ0: RN69.2 RN72.1 UN5.11
RD2_B_EQ1: RN70.2 RN73.1 UN5.21
RD2_B_EQ2: RN71.2 RN74.1 UN5.16
RD2_REXT: RN31.1 UN5.10
RED: CV129.1 DV5.2 JCRT1.1 LV16.2
RED_CRT: CV126.1 LV16.1 RV116.1 UV6.23
REM_DIODE1_N: CE24.1 CE35.1 QE3.3 UE1.A8
REM_DIODE1_P: CE24.2 CE35.2 QE3.1 QE3.2 UE1.A7
REM_DIODE2_N: CE26.1 CE37.2 CE46.2 QE5.3 QE7.1 QE7.2 UE1.A10
REM_DIODE2_P: CE26.2 CE37.1 CE46.1 QE5.1 QE5.2 QE7.3 UE1.A9
REM_DIODE4_N: CE27.1 CE39.1 QE6.3 UE1.A11
REM_DIODE4_P: CE27.2 CE39.2 QE6.1 QE6.2 UE1.B10
RES_BIAS: RL13.1 UL1.12
RESET_IN#: RE361.1 RE362.1 UE1.C1
RESET_OUT: RE548.2 UE1.G4
RESET_OUT#_R: CC33.1 JXDP1.47 RC128.2 RC129.2
RING2: LA10.1 RA5.2 UA1.30
RING2_R: CA4.1 CA13.2 DA3.3 JHP1.4 LA10.2
RJ45_MDIN0: JLOM1.2 TL1.14
RJ45_MDIN1: JLOM1.6 TL1.20
RJ45_MDIN2: JLOM1.5 TL1.17
RJ45_MDIN3: JLOM1.8 TL1.23
RJ45_MDIP0: JLOM1.1 TL1.13
RJ45_MDIP1: JLOM1.3 TL1.19
RJ45_MDIP2: JLOM1.4 TL1.16
RJ45_MDIP3: JLOM1.7 TL1.22
RTCRST_ON: QE12.2 RE93.1 RE565.2 UE1.F11
RTCRST_ON_R: CE65.1 DE2.2 QE17.2 RE543.1
RTD3_CIO_PWR_EN: T18.1(TP-1) UC1.AC2
RUN_ON: PR402.1 QE2.2 RE280.2 RE292.1 RZ320.1 RZ345.1 UE5.4 UZ3.5 UZ4.3 UZ35.2
RUN_ON#: QE2.5 QE2.6 QZ4.2 RE68.1
RUN_ON_1.8V: CZ197.1 RZ345.2 UZ8.3
RUN_ON_EC: RE292.2 RPE10.4 UE1.E8 UE5.2
RUNPWROK: QE2.3 RE67.1 UC8.1 UC8.4 UC8.10 UC8.13 UE1.G3
SA_LGATE: PQ614.8 PU614.5
SA_SNUB: PC622.1 PR627.2
SA_SW: PL614.4 PQ614.9 PR619.2 PR627.1 PU614.8
SA_UGATE: PQ614.1 PU614.1
SATA_PRX_C_DTX_N0: CN6.1 JSATA1.5
SATA_PRX_C_DTX_P0: CN7.1 JSATA1.6
SATA_PRX_C_RD_DTX_N0: CN14.2 UN7.4
SATA_PRX_C_RD_DTX_P0: CN15.2 UN7.5
SATA_PRX_DTX_N0: CN14.1 UC1.F20
SATA_PRX_DTX_P0: CN15.1 UC1.E20
SATA_PRX_RD_DTX_N0: CN6.2 UN7.12
SATA_PRX_RD_DTX_P0: CN7.2 UN7.11
SATA_PTX_C_DRX_N0: CN5.1 JSATA1.3
SATA_PTX_C_DRX_P0: CN4.1 JSATA1.2
SATA_PTX_C_RD_DRX_N0: CN13.2 UN7.2
SATA_PTX_C_RD_DRX_P0: CN12.2 UN7.1
SATA_PTX_DRX_N0: CN13.1 UC1.B21
SATA_PTX_DRX_P0: CN12.1 UC1.A21
SATA_PTX_RD_DRX_N0: CN5.2 UN7.14
SATA_PTX_RD_DRX_P0: CN4.2 UN7.15
SATALED#: QZ2.4 RN100.2 RN101.2 RPC4.2 UC1.H1
SBIOS_TX: RE306.1 UC1.AB2
SD/MMCCD#: JSD1.9 UR1.30
SD/MMCCLK: RR5.1 UR1.17
SD/MMCCLK_R: CR21.1 JSD1.5 RR5.2
SD/MMCCMD: RR6.1 UR1.19
SD/MMCCMD_R: JSD1.3 RR6.2
SD/MMCDAT0/RCLK+: RR10.1 UR1.16
SD/MMCDAT0/RCLK+_R: JSD1.7 RR10.2
SD/MMCDAT1/RCLK-: RR9.1 UR1.15
SD/MMCDAT1/RCLK-_R: JSD1.8 RR9.2
SD/MMCDAT2: RR8.1 UR1.21
SD/MMCDAT2_R: JSD1.1 RR8.2
SD/MMCDAT3: RR7.1 UR1.20
SD/MMCDAT3_R: JSD1.2 RR7.2
SD_GPIO: RR3.2 UR1.28
SD_RCOMP: RC96.1 UC1.AB7
SD_UHS2_D0N: JSD1.17 UR1.25
SD_UHS2_D0P: JSD1.16 UR1.26
SD_UHS2_D1N: JSD1.19 UR1.23
SD_UHS2_D1P: JSD1.20 UR1.22
SDWP: QR1.1 UR1.29
SIM_DET: JNGFF2.66 JSIM1.9
SIO_EXT_SCI#: RC237.1 RC561.1 UC1.AN7
SIO_EXT_SMI#: RC346.1 UC1.A6
SIO_EXT_WAKE#: RC283.1 UC1.AC1 UE1.M12
SIO_PWRBTN#: CC269.1 JXDP1.41 RC241.1 UC1.BA15 UE1.K11
SIO_SLP_A#: JAPS1.6 UC1.AN16 UE1.M11
SIO_SLP_LAN#: RC68.1 RC344.1 UC1.AW15 UE1.H9 UZ2.5
SIO_SLP_S0#: JAPS1.15 PR425.1 PR426.1 RZ112.1 RZ362.2 RZ363.1 UC1.AT11 UZ35.1
SIO_SLP_S3#: JAPS1.2 QE11.2 RE280.1 UC1.AP15 UE1.K9 UE3.2 UE5.1
SIO_SLP_S4#: JAPS1.5 PR208.1 PR513.1 UC1.BA16 UE1.N12 UZ21.4 UZ34.2
SIO_SLP_S5#: JAPS1.4 UC1.AY16 UE1.N8
SIO_SLP_SUS#: RC441.1 RE349.1 UC1.AN15
SIO_SLP_SUS#_R: RE349.2 RE561.1 UE1.N4
SIO_SLP_WLAN#: QZ15.1 UC1.BB17 UE1.D9
SLEEVE: LA11.1 RA6.2 UA1.31
SLEEVE_R: CA1.2 CA12.1 DA3.2 JHP1.3 LA11.2
SLOT2_SATA_LED#: JNGFF2.10 RN101.1
SLP_WLAN#_GATE: QZ15.2 RE552.1 RZ518.2
SLP_WLAN#_M: DZ9.3 QZ15.3 RZ71.1
SM_RCOMP0: RC5.1 UC1.AR18
SM_RCOMP1: RC6.1 UC1.AT18
SM_RCOMP2: RC7.1 UC1.AU18
SML0_SMBCLK: CC318.1 RC19.1 RC347.1 UC1.R9 UL1.28
SML0_SMBDATA: RC20.1 RC348.1 UC1.W2 UL1.31
SML1_SMBCLK: CC319.1 RC15.1 UC1.W3 UE1.D8
SML1_SMBDATA: RC17.1 UC1.V3 UE1.E11
SNB_+1VALWP: PC302.1 PR303.2
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_1V_PRIM: PC419.1 PR409.2
SNUB_1VS_VCCIO: PC401.1 PR405.2
SNUB_CHG1: PC940.1 PR923.2
SNUB_CHG2: PC941.1 PR924.2
SPK_DET#: JSPK1.5 RA58.2 UC1.W7
SPKR: RA12.2 RC183.1 UC1.AW5
SPKR_R: CA27.1 CA72.1 RA12.1 RA51.1
SRTCRST#: CC24.1 RC56.1 UC1.AN18
SS_1V_PRIM: PC420.1 PR428.1 PU402.7
SS_1VS_VCCIO: PC410.1 PR427.1 PU401.7
SUSACK#: RC443.1 UE1.K12
SUSACK#_R: RC443.2 RC551.1 UC1.AP11
SUSCLK: RC48.1 RN99.2 RZ56.2 UC1.BA17
SUSCLK_R: JNGFF3.68 RN99.1
SW2_DP1_AUXN: CT81.1 CT116.1 RV70.1 UV7.27
SW2_DP1_AUXN_C: CT116.2 RT131.1 UT9.25
SW2_DP1_AUXP: CT80.1 CT115.1 RV76.1 UV7.26
SW2_DP1_AUXP_C: CT115.2 RT130.1 UT9.24
SW2_DP1_CADET: RV73.1 UV7.43
SW2_DP1_HPD: RT73.2 RT380.1 UV7.48
SW2_DP1_HPD_R: RT73.1 UT5.C10
SW2_DP1_N0: CT104.1 UV7.49
SW2_DP1_N0_C: CT104.2 UT9.10
SW2_DP1_N1: CT106.1 UV7.46
SW2_DP1_N1_C: CT106.2 UT9.13
SW2_DP1_N2: CT108.1 UV7.44
SW2_DP1_N2_C: CT108.2 UT9.16
SW2_DP1_N3: CT110.1 UV7.41
SW2_DP1_N3_C: CT110.2 UT9.19
SW2_DP1_P0: CT103.1 UV7.50
SW2_DP1_P0_C: CT103.2 UT9.9
SW2_DP1_P1: CT105.1 UV7.47
SW2_DP1_P1_C: CT105.2 UT9.12
SW2_DP1_P2: CT107.1 UV7.45
SW2_DP1_P2_C: CT107.2 UT9.15
SW2_DP1_P3: CT109.1 UV7.42
SW2_DP1_P3_C: CT109.2 UT9.18
SW2_DP3_AUXN: CV112.1 RV72.1 UV7.29
SW2_DP3_AUXN_C: CV112.2 UV6.3
SW2_DP3_AUXP: CV111.1 RV78.1 UV7.28
SW2_DP3_AUXP_C: CV111.2 UV6.2
SW2_DP3_CADET: RV75.1 UV7.33
SW2_DP3_HPD: RV102.1 UV6.32 UV7.38
SW2_DP3_N0: CV108.1 UV7.39
SW2_DP3_N0_C: CV108.2 UV6.6
SW2_DP3_N1: CV110.1 UV7.36
SW2_DP3_N1_C: CV110.2 UV6.8
SW2_DP3_P0: CV107.1 UV7.40
SW2_DP3_P0_C: CV107.2 UV6.5
SW2_DP3_P1: CV109.1 UV7.37
SW2_DP3_P1_C: CV109.2 UV6.7
SW2_PS8338_CFG0: RV87.1 RV88.1 UV7.59
SW2_PS8338_P0: RV95.1 RV96.1 UV7.60
SW2_PS8338_P1: RV93.1 RV94.1 UV7.1
SW2_PS8338_PC10: RV85.1 RV86.1 UV7.56
SW2_PS8338_PC11: RV83.1 RV84.1 UV7.55
SW2_PS8338_PC20: RV81.1 RV82.1 UV7.54
SW2_PS8338_PC21: RV79.1 RV80.1 UV7.53
SW2_PS8338_PEQ: RV89.1 RV90.1 UV7.8
SW2_PS8338_SW: RV91.1 RV92.1 UV7.18
SW_+1VALWP: PL301.1 PR303.1 PR304.2 PU301.6 PU301.19 PU301.20
SW_USB20_N9: LI7.1 UI3.11
SW_USB20_P9: LI7.4 UI3.10
SYS_PWROK: RC129.1 RE56.1 RE548.1 UC1.B6
SYS_RESET#: CC302.1 JAPS1.13 RC224.2 RC291.1 UC1.B5
SYS_RESET#_R: RC224.1 RC290.2 UC12.4
SYSTEM_ID: CE47.1 RE300.2 UE1.J10
TACH_FAN1: JFAN1.3 RE51.2 UE1.E3
TBT_FORCE_PWR: T19.1(TP-1) UC1.B7
TBT_RESET_N_EC_R: RE95.2 UE1.L8
TBTA_AUXN_C: CT81.2 RT95.1 UT5.J2
TBTA_AUXP_C: CT80.2 RT96.1 UT5.J1
TBTA_BOT_N: RT122.2 UT5.L7
TBTA_BOT_N_R: DT40.4 DT40.7 JUSBC1.B7 RT122.1
TBTA_BOT_P: RT123.2 UT5.K7
TBTA_BOT_P_R: DT40.5 DT40.6 JUSBC1.B6 RT123.1
TBTA_CC1: CT86.1 DT39.2 DT39.8 JUSBC1.A5 RT104.2 UT5.L9
TBTA_CC2: CT85.1 DT39.1 DT39.9 JUSBC1.B5 RT105.2 UT5.L10
TBTA_DBG_CTL1: RT106.1 UT5.E4
TBTA_DBG_CTL2: RT107.1 UT5.D5
TBTA_DEBUG1: RT92.2 UT5.L2
TBTA_DEBUG2: RT93.2 UT5.K2
TBTA_DEBUG3: RT89.2 RT406.2 UT5.L3
TBTA_DEBUG4: RT90.1 RT407.2 RT418.1 UT5.K3
TBTA_LSRX_R: RT88.2 UT5.K4
TBTA_LSTX_R: RT87.2 UT5.L4
TBTA_MRESET: RT86.1 UT5.E11
TBTA_ROM_CLK_PD: RT54.2 UT5.A3
TBTA_ROM_CLK_PD_R: JDB1.2 RT54.1 UT6.6
TBTA_ROM_CS#_PD: RT57.2 UT5.B3
TBTA_ROM_CS#_PD_R: JDB1.5 RT51.2 RT57.1 UT6.1
TBTA_ROM_DI_PD: RT55.2 UT5.B4
TBTA_ROM_DI_PD_R: JDB1.3 RT55.1 UT6.5
TBTA_ROM_DO_PD: RT56.2 UT5.A4
TBTA_ROM_DO_PD_R: JDB1.4 RT52.2 RT56.1 UT6.2
TBTA_ROM_HOLD#_PD: RT50.2 UT6.7
TBTA_ROM_WP#_PD: RT53.2 UT6.3
TBTA_ROSC: RT100.1 UT5.G2
TBTA_RX1N: DT14.1 JUSBC1.B10 UT9.31
TBTA_RX1P: DT13.1 JUSBC1.B11 UT9.30
TBTA_RX2N: DT9.1 JUSBC1.A10 UT9.39
TBTA_RX2P: DT10.1 JUSBC1.A11 UT9.40
TBTA_SBU1: DT40.2 DT40.8 JUSBC1.A8 RT108.1 RT132.2
TBTA_SBU1_R: RT108.2 UT5.K8
TBTA_SBU2: DT40.1 DT40.9 JUSBC1.B8 RT109.1 RT133.2
TBTA_SBU2_R: RT109.2 UT5.L8
TBTA_TOP_N: RT121.1 UT5.L6
TBTA_TOP_N_R: DT39.5 DT39.6 JUSBC1.A7 RT121.2
TBTA_TOP_P: RT120.1 UT5.K6
TBTA_TOP_P_R: DT39.4 DT39.7 JUSBC1.A6 RT120.2
TBTA_TX1N: CT96.1 UT9.34
TBTA_TX1N_C: CT96.2 DT6.1 JUSBC1.A3
TBTA_TX1P: CT95.1 UT9.33
TBTA_TX1P_C: CT95.2 DT5.1 JUSBC1.A2
TBTA_TX2N: CT98.1 UT9.36
TBTA_TX2N_C: CT98.2 DT18.1 JUSBC1.B3
TBTA_TX2P: CT97.1 UT9.37
TBTA_TX2P_C: CT97.2 DT17.1 JUSBC1.B2
TDI_XDP: JXDP1.56 RC229.1 UC8.5
TDO_XDP: CC306.1 JXDP1.52 RC230.1 UC8.2
THERMTRIP1#: RE301.1 UE1.B12
THERMTRIP2#: CE36.1 QE4.1 RE69.2 UE1.H3
TOUCH_SCREEN_DET#: JEDP1.32 RV8.1 UC1.AY5
TOUCH_SCREEN_PD#: JEDP1.5 RC272.1 UC1.A7
TOUCHPAD_INTR#: JKBTP1.16 RC414.1 RE318.2 UC1.BA5
TP_LAN_JTAG_TCK: RL2.1 UL1.35
TP_LAN_JTAG_TDI: T88.1(TP-1) UL1.32
TP_LAN_JTAG_TDO: T89.1(TP-1) UL1.34
TP_LAN_JTAG_TMS: RL1.1 UL1.33
TPM_GPIO0: RZ112.2 UZ12.29
TPM_GPIO4: T283.1(TP-1) UZ12.13
TPM_LPM#: RZ363.2 UZ12.3
TPM_PIRQ#: RC560.2 RC561.2 RZ69.2 UZ12.18
TPM_PIRQ#_R: RC560.1 UC1.AP8
TPM_TYPE: RC349.1 UC1.AY7
TRST#_XDP: JXDP1.54 UC8.12
TUSB546A_SBU1_R: RT132.1 RT414.1 UT9.27
TUSB546A_SBU2_R: RT133.1 RT415.1 UT9.26
TYPEC_CON_SEL1: RC555.1 RC556.1 UC1.W4
TYPEC_CON_SEL2: RC553.1 RC554.1 UC1.AB3
TYPEC_ID: CE62.1 RE343.2 UE1.F2
UART_MISO: RT82.1 RT83.2 UT5.F2
UART_MOSI: RT81.1 RT83.1 UT5.E2
UG1_ISL9538: PQ905.1 PU901.11
UG2_ISL9538: PQ904.1 PU901.5
UIM_CLK: CZ38.1 JNGFF2.32 JSIM1.3
UIM_DATA: CZ39.1 JNGFF2.34 JSIM1.7 RZ335.2
UIM_RESET: CZ40.1 JNGFF2.30 JSIM1.2
UPD1_SMBCLK: QT1.1 RE303.1 RT58.1 UE1.C3
UPD1_SMBCLK_Q: QT1.6 RT58.2 RT67.1 RT92.1 RT375.2 UT5.B5
UPD1_SMBDAT: QT1.4 RE302.1 RT59.1 UE1.B4
UPD1_SMBDAT_Q: QT1.3 RT59.2 RT66.1 RT93.1 RT376.2 UT5.A5
UPD1_SMBINT#: RE91.1 RT60.1 UE1.F10
UPD1_SMBINT#_R: RT60.2 RT68.1 UT5.B6
UPD2_SMBCLK: RPE12.3 UE1.D7
UPD2_SMBDAT: RPE12.4 UE1.E7
UPD2_SMBINT#: RE92.1 UE1.F5
USB2_ID: RC337.1 RT74.2 UC1.AG3
USB2_VBUSSENSE: RC338.1 UC1.AG4
USB3_PRX_C_DTX_N1: CT112.2 UT9.4
USB3_PRX_C_DTX_P1: CT111.2 UT9.5
USB3_PRX_DTX_N1: CT112.1 UC1.H8
USB3_PRX_DTX_N2: LI16.1 RI28.1 UC1.J6
USB3_PRX_DTX_N3: DI1.1 DI1.9 JUSB2.5 UC1.J10
USB3_PRX_DTX_N6: DI4.1 DI4.9 JUSB1.5 UC1.G11
USB3_PRX_DTX_P1: CT111.1 UC1.G8
USB3_PRX_DTX_P2: LI16.4 RI27.1 UC1.H6
USB3_PRX_DTX_P3: DI1.2 DI1.8 JUSB2.6 UC1.H10
USB3_PRX_DTX_P6: DI4.2 DI4.8 JUSB1.6 UC1.F11
USB3_PRX_L_DTX_N2: JNGFF2.29 LI16.2 RI28.2
USB3_PRX_L_DTX_P2: JNGFF2.31 LI16.3 RI27.2
USB3_PTX_C_DRX_N1: CT114.2 UT9.7
USB3_PTX_C_DRX_N2: CI29.1 LI17.1 RI30.1
USB3_PTX_C_DRX_N3: CI5.1 DI1.4 DI1.7 JUSB2.8
USB3_PTX_C_DRX_N6: CI13.1 DI4.4 DI4.7 JUSB1.8
USB3_PTX_C_DRX_P1: CT113.2 UT9.8
USB3_PTX_C_DRX_P2: CI30.1 LI17.4 RI29.1
USB3_PTX_C_DRX_P3: CI4.1 DI1.5 DI1.6 JUSB2.9
USB3_PTX_C_DRX_P6: CI16.1 DI4.5 DI4.6 JUSB1.9
USB3_PTX_DRX_N1: CT114.1 UC1.C13
USB3_PTX_DRX_N2: CI29.2 UC1.B13
USB3_PTX_DRX_N3: CI5.2 UC1.B15
USB3_PTX_DRX_N6: CI13.2 UC1.D16
USB3_PTX_DRX_P1: CT113.1 UC1.D13
USB3_PTX_DRX_P2: CI30.2 UC1.A13
USB3_PTX_DRX_P3: CI4.2 UC1.A15
USB3_PTX_DRX_P6: CI16.2 UC1.C16
USB3_PTX_L_DRX_N2: JNGFF2.35 LI17.2 RI30.2
USB3_PTX_L_DRX_P2: JNGFF2.37 LI17.3 RI29.2
USB20_N1: UC1.AB9 UT5.K5
USB20_N2: LI3.4 UC1.AD6
USB20_N2_R: DI2.3 JUSB2.2 LI3.3
USB20_N4: LI8.1 RI48.1 UC1.AD9
USB20_N4_L: JNGFF2.9 LI8.2 RI48.2
USB20_N5: LZ1.4 UC1.AJ1
USB20_N5_R: JEDP1.12 LZ1.3
USB20_N7: LI9.1 RI50.1 UC1.AH1
USB20_N7_L: JNGFF1.5 LI9.2 RI50.2
USB20_N8: LV27.2 UC1.AF8
USB20_N8_R: DV4.2 JEDP1.2 LV27.1
USB20_N9: UC1.AG1 UI3.2
USB20_N9_R: DI5.2 JUSB1.2 LI7.2
USB20_N10: JUSH1.19 UC1.AH7
USB20_P1: UC1.AB10 UT5.L5
USB20_P2: LI3.1 UC1.AD7
USB20_P2_R: DI2.2 JUSB2.3 LI3.2
USB20_P4: LI8.4 RI47.1 UC1.AD10
USB20_P4_L: JNGFF2.7 LI8.3 RI47.2
USB20_P5: LZ1.1 UC1.AJ2
USB20_P5_R: JEDP1.13 LZ1.2
USB20_P7: LI9.4 RI49.1 UC1.AH2
USB20_P7_L: JNGFF1.3 LI9.3 RI49.2
USB20_P8: LV27.3 UC1.AF9
USB20_P8_R: DV4.3 JEDP1.3 LV27.4
USB20_P9: UC1.AG2 UI3.3
USB20_P9_R: DI5.3 JUSB1.3 LI7.3
USB20_P10: JUSH1.18 UC1.AH8
USB_OC0#: RPC3.2 UC1.A9 UI3.13
USB_OC1#: RPC3.3 UC1.C9 UI1.3
USB_OC2#: RPC3.1 UC1.D9
USB_OC3#: RPC3.4 UC1.B9
USB_POWERSHARE_EN#: RPE11.2 UE1.J3 UI3.6
USB_POWERSHARE_VBUS_EN: RPE11.4 UE1.J2 UI3.5
USB_PWR_EN1#: RPE11.3 UE1.K3 UI1.4
USB_PWR_EN2#: RPE11.1 UE1.G5
USBCOMP: RC44.1 UC1.AB6
USH_DET#: DZ7.2 RE526.1 RZ87.1 UE1.C13
USH_DET#_R: DZ7.1 JUSH1.1 RZ87.2
USH_EXPANDER_SMBCLK: CZ62.1 JUSH1.16 RZ8.2 UE1.B3
USH_EXPANDER_SMBDAT: CZ63.1 JUSH1.15 RZ9.2 UE1.E5
USH_PWR_STATE#: JUSH1.5 RZ10.2 UE1.H2
USH_RST#_R: JUSH1.6 RZ114.2
VCI_IN1#: RE507.1 UE1.B5
VCI_IN2#: RE508.1 UE1.D4
VCT_LAN_R1: RL3.1 UL1.6
VGA_IDENTIFY: RE84.1 RE85.1 UE1.L9
VID0_PRIM_CORE: PR408.2 PR418.2 PR420.1 PU402.9
VID0_VCCIO: PR414.2 PR416.1 PU401.9
VID1_PRIM_CORE: PR411.2 PR417.2 PR419.1 PU402.8
VID1_VCCIO: PR413.2 PR415.1 PU401.8
VIDALERT_N: PR604.2 PR625.1 RC152.1 RC153.2
VIDALERT_N_B: PR625.2 PU602.36
VIDSCLK: CC321.1 PR601.2 PR618.1 UC1.A63
VIDSCLK_B: PR618.2 PU602.37
VIDSOUT: PR605.2 PR626.1 RC157.1 UC1.D64
VIDSOUT_B: PR626.2 PU602.35
VRALERT#: RC73.1 UC1.AM11
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC168.2 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC166.1 UC1.H21
VSET_5105: CE38.1 RE77.1 UE1.C9
VSYNC_CONN: CV132.1 JCRT1.14 RV121.1 RV651.2
VSYNC_CRT: RV651.1 UV6.18
WIGIG_32KHZ: JNGFF1.50 RZ56.1
WLAN_COEX1: JNGFF1.48 RZ130.2
WLAN_COEX2: JNGFF1.46 RZ129.2
WLAN_COEX3: JNGFF1.44 RZ128.2
WLAN_PWR_EN: DZ9.1 RZ38.2 RZ70.2 RZ71.2 UZ4.5
WLAN_WIGIG60GHZ_DIS#: DZ1.1 RE8.1 UE1.L13
WLAN_WIGIG60GHZ_DIS#_R: DZ1.2 JNGFF1.56
WWAN_COEX1: JNGFF2.64 RZ130.1
WWAN_COEX2: JNGFF2.62 RZ129.1
WWAN_COEX3: JNGFF2.60 RZ128.1
WWAN_PWR_EN: CZ198.1 JNGFF2.6 RZ43.1
WWAN_RADIO_DIS#: DZ5.1 RE10.1 UE1.F12
WWAN_RADIO_DIS#_R: DZ5.2 JNGFF2.8
WWAN_WAKE#: JNGFF2.23 RE38.1 UE1.M13
XCLK_BIASREF: RC52.1 RC324.1 UC1.E42
XDP_DBRESET#: CC32.1 JXDP1.48 RC137.1 RC290.1 UC12.1
XDP_JTAGX: CC305.1 RC87.1 RC328.2 UC1.A59
XDP_OBS0: JXDP1.21 RC239.2
XDP_OBS0_R: RC239.1 UC1.C55
XDP_OBS1: JXDP1.23 RC240.2
XDP_OBS1_R: RC240.1 UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRSNT_PIN1: JXDP1.1 RC121.1 RC122.1
XDP_TMS: JXDP1.58 RC228.1 UC8.9
XTAL24_IN_U22: CC21.1 RC46.2 RC419.2 YC1.3
XTAL24_IN_U22_CPU: RC419.1 UC1.E37
XTAL24_IN_U42: CC334.1 RC417.2 RC421.2 YC3.3
XTAL24_IN_U42_CPU: RC417.1 UC1.E3
XTAL24_OUT_U22: RC46.1 RC295.1 RC420.2
XTAL24_OUT_U22_CPU: RC420.1 UC1.E35
XTAL24_OUT_U22_R: CC22.1 RC295.2 YC1.1
XTAL24_OUT_U42: RC418.2 RC421.1 RC422.1
XTAL24_OUT_U42_CPU: RC418.1 UC1.C7
XTAL24_OUT_U42_R: CC335.1 RC422.2 YC3.1
XTALI: CL14.1 RL11.2 UL1.10 YL1.1
XTALO: RL11.1 RL34.2 UL1.9
XTALO_R: CL13.1 RL34.1 YL1.3
Z2805: RL18.1 TL1.24
Z2806: RL16.1 TL1.18
Z2807: RL17.1 TL1.21
Z2808: RL15.1 TL1.15
N04748: PC939.1 PR929.1 PU901.3
N43975: QN1.5 QN1.6 RN2.2
N16399089: PD901.1 PD903.1 PD904.1 PR916.2
N16400770: PR901.3 PR910.1
N16775301: PC208.2 PR204.2 PR206.1 PU200.16
N16775385: PC218.1 PU200.3
N16775433: PC204.1 PR202.2
N16775513: PC205.1 PR203.2
N16775517: PR203.1 PU200.12
N16776853: PC207.1 PU200.14
N16783095: PC113.2 PR108.1
N16783126: PC111.1 PR104.1 PR105.1 PU100.16 PU100.17
N16783134: PC127.2 PR117.1
N16784595: PC102.1 PR100.2
N16784799: PC114.1 PR111.2
N17023599: PD905.3 PR939.2 PR950.1
N17023623: PD905.1 PR961.1 PU903.1
N17023625: PR946.1 PU903.4
N17023649: PR942.2 PU903.2
N17023661: PD905.2 PR941.2
N17185089: PQ1204.5 PR1218.1
N17185092: PQ1204.6 PR1214.2 PR1218.2
N17185371: PQ1204.2 PR1223.1
N17188383: PQ1201.2 PR1216.1 PR1262.1
N17275961: PR612.2 PR614.2 PU602.39
N17275988: PR616.2 PU602.40
N17370862: PC4.2 PQ4.4 PQ5.1 PR11.2 PR16.1
N17370885: PQ5.2 PR10.2 PR15.1
N17370921: PQ1.6 PR15.2
N17370927: PQ7.1 PR16.2
N17370961: PL3.1 PQ2.1 PR3.1 PR6.2
N17370983: PQ2.3 PR3.2 PR5.1
N17370995: PQ3.2 PR6.1 PR8.2
N17370999: PQ2.2 PQ3.1 PR7.2
N17371029: PC6.1 PQ9.4 PR12.2 PR18.1
N17371043: PQ6.1 PR18.2
N17371125: PQ7.2 PR20.1
N17371182: PQ6.2 PR23.2 PR30.1
N17371184: PR23.1 PU1.4
N17371196: PR21.2 PU1.1
N17371202: PR22.2 PU1.2
N17372063: PQ1.3 PR17.2 PR19.2
N17372074: PQ1.5 PR25.1
N17372283: PQ1.2 PR19.1
N17400451: PC515.2 PR515.2 PR516.1 PU503.3
N17494434: PC1211.1 PD1205.1 PQ1212.1 PR1238.1 PR1239.2 PR1246.1 PR1255.2 PU1201.5
N20151644: PR901.2 PR909.1
N27077001: PR917.2 PR937.2
N28424999: T113.1(TP-1) UC1.AW71
N28425002: T114.1(TP-1) UC1.AW70
N28489601: RC222.1 SW1.2
N28769860: PR421.2 PR422.1 PU401.5
N28771761: PR404.2 PR425.2 PU401.14
N28771835: PR410.2 PR426.2 PU402.14
N28810563: CZ110.1 UZ2.10
N28811129: CZ114.1 UZ3.10
N28856399: T16.1(TP-1) UC1.BA70
N28856402: T17.1(TP-1) UC1.BA68
N28857231: T12.1(TP-1) UC1.BB68
N28857234: T13.1(TP-1) UC1.BB69
N28857237: T14.1(TP-1) UC1.AK13
N28857240: T15.1(TP-1) UC1.AK12
N28861827: RC120.1 UC1.C64
N28938912: CC8.1 RC29.2
N28938914: CC7.1 RC28.2
N29708559: T126.1(TP-1) UC1.AY4
N29708561: T127.1(TP-1) UC1.BB3
N29708599: T128.1(TP-1) UC1.AU5
N29708601: T129.1(TP-1) UC1.AT5
N29708639: T130.1(TP-1) UC1.BB5
N30342894: QV4.2 RV18.2
N31877076: JEDP1.21 LV1.1
N32590572: CZ117.1 UZ4.12
N32592963: CZ118.1 UZ4.10
N32594166: CZ109.1 UZ2.12
N32817808: CZ113.1 UZ3.12
N32818355: RZ64.2 RZ65.2 UZ3.3
N32819772: CZ121.1 UZ8.6
N32875032: CZ130.1 UZ23.6
N33199734: JDIMM1.162 T50.1(TP-1)
N33199744: JDIMM1.165 T51.1(TP-1)
N33290988: CD62.2 RD31.1
N33298469: JDIMM2.162 T54.1(TP-1)
N33298471: JDIMM2.165 T55.1(TP-1)
N33612393: CD31.2 RD18.1
N35551558: PC1210.1 PQ1206.4 PR1228.2 PR1229.1
N35551572: PC1214.1 PQ1209.5 PR1243.2
N35551576: PQ1209.2 PQ1209.3 PR1236.1
N35551581: PQ1209.6 PR1229.2
N35551584: PC1213.1 PD1205.2 PR1238.2 PR1240.2 PR1243.1 PU1201.7
N35551592: PC1212.1 PR1237.2 PR1247.1 PU1201.6
N35551616: PQ1212.2 PR1248.1 PR1249.1 PR1250.1
N35551696: PC1202.2 PQ1213.4 PQ1215.1 PR1205.2 PR1212.1
N35551713: PQ1201.6 PR1212.2
N35551783: PC1203.2 PQ1202.4 PQ1203.1 PR1207.2 PR1213.1
N35551785: PQ1203.2 PR1202.2 PR1209.1
N35551806: PQ1204.3 PR1209.2
N35551822: PQ1201.3 PR1213.2
N36255106: PQ1201.5 PR1220.2
N36626863: CT90.1 RT111.2 UT7.3
N36827741: RZ120.2 UZ26.4 UZ34.4
N38749366: QV2.1 RV5.2
N38749387: QV7.1 RV6.1 RV400.1
N38749389: CV635.1 QV8.2 RV400.2
N38798736: RT97.2 RT98.1 RT99.1 UT5.F10
N38798744: RT85.1 UT5.G4
N38798745: RT84.1 UT5.F4
N38798858: RT63.1 UT5.F1
N38798904: RT105.1 UT5.K10
N38798905: RT104.1 UT5.K9
N38798908: RT103.1 UT5.L11
N38798948: RT85.2 T220.1(TP-1)
N38798949: RT84.2 T219.1(TP-1)
N38799002: CT87.1 UT5.H7
N38799008: RT101.1 UT5.D6
N39067212: RE57.1 RE58.1 UE1.B1
N39067288: RE318.1 UE1.G2
N39070459: QE11.3 RE70.1 RE90.2
N39070470: QE4.2 RE70.2
N39154673: RV123.2 UV6.10
N39154676: RV124.2 UV6.9
N39317125: PR423.1 PR424.1 PU402.5
N39469798: PR679.1 PU614.7
N39469818: PC631.1 PR630.2
N39469863: PC632.1 PR636.1 PU602.28
N39469972: PR678.2 PU602.38
N39469996: PC611.2 PU614.2
N39469998: PC611.1 PR619.1
N39470129: PC640.1 PR646.2
N39470145: PC601.1 PR652.2
N39470173: PC632.2 PR641.1
N39470189: PH604.1 PR642.2
N39470446: PC603.1 PR602.1 PU602.34
N39470448: PC604.1 PR603.1 PU602.33
N39470528: PR608.1 PU602.32
N39470532: PR611.1 PU602.31
N40719702: CE57.1 RE350.2
N41288260: JNGFF2.25 RZ326.1
N41303246: CZ38.2 RZ334.1
N41840158: QN4.5 RN182.2 RN183.1 RN192.2
N41840194: QN5.2 RN184.2 RN185.1 RN186.2
N41840238: QN5.5 RN187.2 RN188.1 RN189.2
N44308050: RI14.2 UI3.16
N44315031: PC947.1 PR935.1 PR947.1 PU901.29
N44519703: PR936.1 PR948.1 PU901.30
N44621211: PR933.2 PR951.2 PU901.26
N45247841: JNGFF2.67 T225.1(TP-1)
N45314468: JESPI.8 RE375.1 RE560.1
N45617512: CL17.1 TL1.4
N45617514: CL16.1 TL1.1
N45617540: CL20.1 TL1.7
N45617554: CL21.1 TL1.10
N45925426: RT378.1 UT5.D1
N45925428: RT379.1 UT5.D2
N45988164: PC119.1 PU102.16 PU102.17
N46047516: PQ8.3 PR26.2 PR28.1
N46047518: PQ8.1 PR22.1 PR27.1
N46047526: PQ8.2 PR29.1
N46050852: PQ1208.2 PQ1208.3 PR1259.1
N46050860: PQ1208.5 PR1244.2 PR1260.2 PR1261.1
N46050887: PQ1208.6 PQ1211.1 PR1234.1 PR1261.2
N46050911: PQ1211.5 PR1233.1 PR1242.2
N46050913: PQ1211.2 PR1235.1 PR1257.2
N46050923: PQ1210.5 PR1245.2
N46051012: PQ1207.6 PQ1211.4 PR1230.1 PR1258.2
N46051197: PQ1207.2 PQ1207.3 PR1232.1
N46051213: PQ1207.5 PR1241.2
N46101144: PC1206.1 PR1201.2 PR1203.1 PR1219.1 PU1201.3
N46101200: PC1205.1 PR1208.2 PR1217.1 PU1201.2
N46209617: PQ1205.2 PR1225.1
N46209621: PQ1205.1 PR1215.1 PR1226.2
N46209625: PQ1205.3 PR1221.2 PR1224.1
N46209711: PR1211.2 PU1200.1
N46209717: PR1215.2 PU1200.2
N46210543: PR1216.2 PU1200.4
N46212351: PQ1215.2 PR1251.2 PR1252.1
N46212363: PQ1214.6 PR1252.2
N46455859: QZ3.1 RZ25.1
N46814682: PH601.2 PR610.1 PR631.2
N46814700: PC627.1 PR632.2
N46814728: PH602.1 PR628.2
N46814746: PC627.2 PR638.2 PU602.8
N46814769: PC617.2 PR621.1
N46815156: PR620.2 PU602.1
N46815164: PC621.2 PR623.1
N46815166: PR621.2 PR622.2 PR623.2 PU602.5
N46815186: PC616.2 PR617.2 PU602.4
N46815188: PC614.2 PR617.1
N46815204: PR610.2 PU602.3
N46815214: PC613.2 PR613.2 PU602.2
N46816449: PC647.2 PR650.2
N46816463: PC629.2 PR639.1
N46816511: PH603.2 PR635.1 PR647.2
N46816791: PC630.1 PR640.1 PU602.20
N46816817: PC630.2 PR644.1
N46816821: PH605.1 PR657.2
N46816907: PC639.2 PR645.1
N46907385: RT380.2 UT9.32
N46924944: PR920.2 PU901.21
N46924987: PR922.2 PU901.22
N46998600: CZ56.1 RZ63.1
N46999447: JNGFF2.58 RZ132.2
N47324022: PC313.1 PU301.16 PU301.17
N47329694: QE12.1 RE94.1
N48068474: PC307.2 PR308.1
N48704005: PL614.3 PR624.1
N49117945: PR932.1 PU901.27
N49204882: PL612.3 PR661.1
N49222948: PR687.2 PU610.1
N49223679: PR659.2 PU610.2
N49223737: PC655.2 PU610.7
N49223739: PR660.2 PU610.5
N49223741: PC655.1 PR660.1
N49225697: PR686.2 PU610.17
N49226542: PR692.2 PU613.1
N49226544: PR671.2 PU613.2
N49227484: PC671.2 PU613.7
N49227486: PR672.2 PU613.5
N49227488: PC671.1 PR672.1
N49228457: PR689.2 PU613.17
N49230528: PR681.2 PU612.17
N49231011: PC663.1 PR665.1
N49231017: PR665.2 PU612.5
N49231019: PC663.2 PU612.7
N49231205: PR664.2 PU612.1
N49231242: PR662.2 PU612.2
N49939391: JUSH1.23 RZ364.2
N50084581: QC6.1 RC433.2
N50084583: CC340.1 QC7.2 RC432.2 RC433.1
N50204886: PC930.1 PR914.2
N50205391: PC944.1 PR934.2
N50521287: RV97.1 UV7.20
N50521312: CV96.1 UV7.17
N50577367: RZ62.1 UZ12.27
N50631091: CZ126.1 UZ5.12
N50631103: CZ127.1 UZ5.10
N50631939: CA49.2 UA1.25
N50631945: CA25.2 UA1.32
N50631959: RA53.1 RA57.1 UA1.33
N50631969: CA29.2 UA1.24
N50632394: CA35.2 UA1.38
N50632521: CA51.2 RA44.2 UA1.39
N50632689: CA52.2 UA1.21
N50632795: CA29.1 UA1.23
N50632802: CA53.2 UA1.19
N50670221: CA33.1 RA17.1
N50714989: RV620.2 UV6.11
N50740210: QV7.2 RV323.2 RV324.2 RV326.2
N50865698: RC436.2 UC1.F65 UC1.G65
N50938785: CE64.1 DE2.1 QE15.2 RE541.2 RE543.2 RE565.1
N50938791: QE17.1 RE546.2
N51488834: RV622.2 UV6.12
N51859224: CL11.1 CL12.1 LL2.1 UL1.46 UL1.47
N52552880: CZ200.1 QZ1.2 RZ380.2
N119328643: PC938.1 PR930.1 PR931.2 PU901.25
N132000604: PC934.1 PR921.2
N132005053: PR917.3 PR938.2
N5052105529: T204.1(TP-1) UV7.4
N5052105531: T223.1(TP-1) UV7.2
N5052105558: T224.1(TP-1) UV7.14

Pads without a net: DV6 3; FD1 1; FD2 1; FD3 1; FD4 1; JAPS1 16 17 18; JDIMM1 87 88 91 92 95 97 100 101 104 105; JDIMM2 87 88 91 92 95 97 100 101 104 105; JEDP1 16 20; JHDMI1 14; JIR1 4; JKBTP1 4 11; JNGFF1 6 16 17 19 20 21 22 25 26 27 28 31 32 34 59 61 65 67 68 71 73; JNGFF2 20 22 24 28 44 46 48 56 59 61 63 65 68; JNGFF3 5 6 7 8 11 13 17 19 20 22 23 24 25 26 28 30 32 34 36 40 42 44 46 48 56 58 67; JSATA1 8 20; JSD1 14; JSIM1 4 6 8; JSPI1 17; JUSH1 10 25; PBATT1 11 12; PD2 2; PRP1 4 5; PU100 10 15; PU102 10; PU200 18 19; PU301 9 10 12; PU401 4; PU402 4; PU503 2 6 7; PU610 6 13 16 18; PU612 6 13 16 18; PU613 6 13 16 18; PU901 13; QL2 3 4 5; QZ7 1 2 6; RC22 2; RC27 2; RC405 2; RPE12 1 2 7 8; RT75 2; RT87 1; RT88 1; RT110 1; RT339 2; RZ326 2; UA1 1 6 7 8 9 10 11 12 13; UC1 A3 A4 A11 A23 A26 A27 A29 A31 A33 A36 A38 A45 A47 A52 A65 A69 AB12 AB13 AB62 AC63 AD3 AD4 AE62 AE63 AF6 AF7 AF11 AF12 AF13 AG62 AH3 AH9 AH10 AH11 AH12 AJ3 AJ62 AK6 AK7 AK9 AK10 AK62 AK70 AL25 AL27 AL61 AL63 AM1 AM2 AM3 AM4 AN1 AN2 AN3 AP1 AP2 AP3 AP4 AP13 AP56 AR56 AU56 AU58 AU63 AW1 AW13 AW20 AW48 AW68 AW69 AY1 AY2 AY20 AY21 B2 B3 B11 B23 B26 B27 B29 B31 B33 B36 B38 B45 B47 B52 B69 B70 BA3 BA4 BA7 BA8 BA9 BB2 BB4 BB7 BB9 BB11 BB57 BB66 C2 C4 C8 C11 C12 C15 C19 C20 C23 C27 C28 C29 C31 C32 C33 C36 C37 C38 C41 C54 C70 C71 D1 D3 D4 D5 D7 D12 D15 D19 D20 D23 D27 D28 D29 D31 D32 D33 D36 D37 D38 D41 D54 D71 E1 E2 E10 E16 E22 E23 E25 E61 F6 F10 F16 F18 F25 F52 F60 F61 G18 G61 H11 H63 J4 J68 J71 K45 K46 L6 M1 M2 M3 M4 N1 N2 N3 N9 N11 P1 P3 P62 U6 U7 V1 V2 V62 W12; UD1 1; UE1 B8 B9; UE4 1; UE6 1; UI3 9 15; UR1 31; UT5 C1; UT7 4; UV6 13 27 28 31; UV7 31 32 34 35 58; UV24 3; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; YC1 2 4; YC3 2 4

## Via types
v1: diameter 0.457, hole 0.203, TOP to BOTTOM, 6085 vias
v2: diameter 0.305, hole 0.152, TOP to BOTTOM, 874 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 206 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 99 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 78.2
  TOP w0.102: v1(72.79,45.92) 70.76,45.92 70.12,45.28 64.61,45.28 v2(64.25,45.64) 62.24,45.64 62.04,45.44 60.35,45.44 58.54,47.26 PR210.1 ; UD1.4 48.19,17.96 47.93,17.7 47.93,14.4 48.68,13.65 48.72,13.65 49.41,12.96 v1(49.62,12.96) 49.62,13.36 50,13.74 RD19.1
  IN1 w0.089: v1(49.62,12.96) 47.96,14.62 47.96,18.61 50.86,21.51 51.87,21.51 72.42,42.06 72.42,45.55 v1(72.79,45.92)
1.8V_PRIM_PWRGD: length 165
  TOP w0.076: UE1.L7 263.71,45.82 263.71,44.26 264.02,43.95 264.02,43.07 v1(264.13,42.95)
  TOP w0.102: v2(174.4,107.23) v1(174.91,107.23) 174.91,107.35 PR517.1 ; RE361.2 252.83,53.16 v1(252.75,53.23)
  IN3 w0.122: v1(252.75,53.23) 252.47,53.51 251.13,53.51 249.2,51.58 247.98,51.58 247.32,50.92 244.91,50.92 243.87,49.89 243.87,49.26 242.21,47.59 240.39,47.59 239.09,46.3 237.77,46.3 235.23,43.75 230.13,43.75 229.54,43.16 227.45,43.16 226.66,42.38 221.01,42.38 219.9,41.27 217.87,41.27 216.75,42.39 207.42,42.39 203.04,46.78 198.95,46.78 185.86,59.87 185.86,62.9 185.08,63.67 185.08,70.35 177.89,77.54 177.89,87.77 176.39,89.26 175.68,89.26 175.19,89.76 175.19,91.57 176.37,92.76 176.37,95.72 178.24,97.58 178.24,106.47 177.47,107.23 v1(174.91,107.23)
  BOTTOM w0.102: v1(264.13,42.95) 264.13,43.9 262.77,45.26 261.78,45.26 260.2,46.83 258.09,46.83 257.69,47.24 257.69,47.93 258.94,49.18 258.94,52.49 258.58,52.85 255.93,52.85 255.2,53.59 253.11,53.59 v1(252.75,53.23) ; PU501.5 175.05,107.1 v1(174.91,107.23)
2.5VSP: length 3.3
  TOP w0.102: PC516.1 216.34,17.04 v2(216.7,17.41)
  TOP w0.254: 214.3,15.41 214.36,15.36 PR515.1 214.37,14.57 PC515.1
3.3V_CAM_EN#: length 194.9
  TOP w0.102: v1(62.79,94.53) 62.18,95.14 62.18,96.66 61.17,97.67 61.17,99.21 RZ380.1 ; RC311.1 132.82,55.19 v1(132.92,55.09) 132.92,54.97 132.54,54.59 v2(132.4,54.59)
  IN2 w0.122: v1(62.79,94.53) 62.92,94.66 64.06,94.66 64.19,94.79 67.87,94.79 68.5,95.42 68.5,103.42 69.88,104.8 71.13,104.8 71.49,104.44 72.2,104.44 73.53,105.76 78.5,105.76 81.22,103.04 83.86,103.04 85.16,101.73 92.54,101.73 93.04,101.24 101.98,101.24 102.92,100.31 107.76,100.31 107.95,100.12 111.82,100.12 115.12,96.82 115.12,95.17 118.24,92.05 123.6,92.05 123.98,91.66 127.87,91.66 128.27,92.07 130.15,92.07 130.56,91.66 132.29,91.66 133.01,92.38 137.42,92.38 139.41,90.39 147.71,90.39 149.97,88.14 150.99,88.14 151.88,87.25 151.88,82.39 155.96,78.31 155.96,76.05 156.31,75.71 156.31,68.72 156.04,68.45 156.04,66.8 156.55,66.3 158.25,66.3 159.23,65.31 159.23,61.84 159.54,61.53 159.54,54.81 160.05,54.3 160.05,51.46 159.56,50.97 155.47,50.97 154.97,50.47 154.11,50.47 153.47,49.83 153.47,48.05 152.7,47.29 152.7,47.22 151.36,45.88 147.16,45.88 143.98,49.07 138.93,49.07 138.36,48.5 136.77,48.5 135.31,49.96 135.31,50.72 132.52,53.51 132.52,54.57 132.92,54.97 v1(132.92,55.09)
  BOTTOM w0.076: UC1.AT15 132.61,54.79 v1(132.92,55.09)
3.3V_TS_EN: length 250.4
  TOP w0.076: UE1.J7 264.02,47.73 263.61,47.32 v1(262.89,47.32)
  TOP w0.102: RV323.1 v1(75.72,109.47) ; RE547.1 261.42,39.62 v1(261.32,39.52) 261.17,39.37 v2(261.17,38.95)
  IN3 w0.122: v1(262.89,47.32) 262.41,46.83 262.41,45.39 261.6,44.57 261.6,43.68 261.85,43.43 261.85,40.03 261.34,39.52 v1(261.32,39.52)
  IN4 w0.089: v1(261.32,39.52) 261.07,39.77 250.78,39.77 249.17,38.16 244.75,38.16 243.93,37.35 240.4,37.35 239.42,38.33 237.58,38.33 236.16,39.75 236.16,41.99 234.78,43.38 227.69,43.38 227.56,43.25 220.98,43.25 219.7,41.97 218.2,41.97 216.37,43.8 212.59,43.8 211.24,45.14 209.79,45.14 208.85,46.09 206.51,46.09 205.22,47.38 203.59,47.38 201.01,49.97 200.02,49.97 189.48,60.51 189.48,64.17 183.49,70.15 181.59,70.15 178.5,73.24 176.33,73.24 175.26,74.3 175.26,78.18 172.33,81.11 172.33,81.9 171.51,82.72 171.51,83.49 169.02,85.98 160.33,85.98 157.65,88.65 142.51,88.65 140.36,90.8 135.85,90.8 135.84,90.81 134.96,90.81 134.95,90.8 128.29,90.8 124.67,87.18 111.93,87.18 109.5,89.61 109.5,90.97 108.3,92.18 108.3,92.81 109.39,93.9 109.39,94.57 109.13,94.84 108.01,94.84 107.21,95.64 107.21,96.48 107.59,96.86 107.59,101.35 106.94,102 106.94,103.74 105.99,104.69 105.47,104.69 101.85,108.31 98.8,108.31 95.38,111.74 77.99,111.74 v1(75.72,109.47)
3.3V_WWAN_EN: length 66.7
  TOP w0.076: 262.03,55.93 262.03,55.19 262.73,54.49 262.73,53.47 262.83,53.37 262.83,52.93 UE1.C6
  TOP w0.102: v1(226.47,42.8) 225.78,42.8 225.1,42.11 225.1,40.37 225.73,39.73 v2(225.73,39.06) 225.73,37.27 226.1,36.9 227.27,36.9 228.02,36.15 232.49,36.15 232.74,36.41 232.74,36.98 231.96,37.77 RZ40.2 231.45,38.17 231.45,38.83 231.81,39.19 UZ2.3 ; v1(261.95,56.46) 262.03,56.38 262.03,55.93
  IN1 w0.089: v1(226.47,42.8) 226.47,42.72 226.55,42.64 230.71,42.64 231.7,43.63 235.67,43.63 238.56,46.53 240.59,46.53 241.36,47.29 242.37,47.29 243.97,48.89 245.06,48.89 245.83,49.66 245.83,50.34 246.46,50.97 250.88,50.97 252.15,52.24 252.15,54.53 254.31,56.69 259.9,56.69 260.41,57.2 261.22,57.2 v1(261.95,56.46)
3V5V_EN: length 170.4
  TOP w0.102: v2(40.06,39.29) 39.47,39.88 PR114.2 39.47,41.53 PR116.1 39.41,41.61 PC128.1 39.41,43.94 v1(39.43,43.96)
  IN3 w0.122: v1(39.43,43.96) 39.25,43.96 38.78,44.43 38.78,48.44 38.46,48.76 38.46,57.12 43.54,62.21 44.97,62.21 47.2,64.44 51.87,64.44 54.41,66.98 54.41,77.01 57.62,80.22 57.62,81.09 58.98,82.44 58.98,85.04 60.13,86.18 60.13,95.8 60.61,96.29 61.88,96.29 62.54,96.95 63.73,96.95 65.38,98.6 65.49,98.71 67.79,98.71 68.98,99.9 74.49,99.9 75.7,98.69 91.81,98.69 92.74,99.61 92.74,101.34 92.18,101.9 92.18,104.03 94.19,106.04 95.28,106.04 95.97,106.74 98.77,106.74 100.56,108.53 103.87,108.53 105.61,110.27 110.48,110.27 119.44,101.31 140.82,101.31 v1(143.18,103.68)
  BOTTOM w0.102: PU100.12 143.38,103.88 v1(143.18,103.68) ; PU102.12 39.93,44.19 39.71,43.96 v1(39.43,43.96)
3V_FB: length 2.4
  BOTTOM w0.254: PU100.13 142.93,104.19 v2(142.55,103.81) 142.3,103.55 PC113.1
3V_SN: length 1.4
  TOP w0.102: PR106.2 v2(138.1,104.62)
3V_VIN:
  vias: v1(142.73,111.15) v1(143.31,111.15) v1(143.95,111.15) v1(146.61,111.3) v1(147.25,111.3) v1(154.79,110.51) v1(154.79,109.9) v1(155.38,110.51) v1(155.38,109.9) v1(155.38,109.29) v2(148.86,110.78)
5V_FB: length 1.5
  BOTTOM w0.254: PC127.1 39.78,44.62 39.79,44.64 PU102.13
5V_SN: length 2
  TOP w0.102: v2(46.12,49.25) 45.29,50.08 PR112.2
5V_VIN:
  vias: v1(43.93,43.16) v1(43.93,42.53) v1(44.57,43.19) v1(44.57,42.6) v1(44.89,41.7) v1(45.25,43.29) v1(45.25,42.71) v1(45.32,42.11) v1(45.31,41.27) v1(45.32,40.69) v3(45.06,44.34)
+0.6V_DDR_VTT: length 171.5
  IN1 w1.016: 197.99,12.33 197.06,11.4 177.62,11.4 177.61,11.41 176.92,11.41 176.9,11.43 130.99,11.43 125.94,16.48 122.98,16.48 118.9,12.4 117.03,12.4 ; 74.02,12.59 74.02,12.26 74.86,11.43 115.7,11.43 116.49,12.21
  IN4 w1.016: 116.46,12.48 116.17,12.19 101.68,12.19 101.53,12.04 74.79,12.04 74.05,12.79
  vias: v1(57.03,52.85) v1(57.31,53.41) v1(57.66,52.85) v1(58.3,52.85) v1(64.19,27.76) v1(64.16,27.17) v1(64.8,27.73) v1(73.79,13.89) v1(74.43,13.92) v1(116.45,13.33) v1(117.04,13.32) v1(198.3,13.51) v1(198.89,13.51) v1(199.47,13.51) v3(195.93,11.52)
+0.6VSP:
  vias: v2(56.32,54.63)
+0.9V_LAN: length 31.5
  TOP w0.203: v1(255.45,71.29) 255.64,71.11 UL1.40 ; UL1.8 259.05,73.92 v1(258.75,74.21) ; UL1.37 254.44,69.63 ; UL1.22 v1(255.24,77.26) ; UL1.11 260.14,75.12 260.7,75.68 260.7,77.73 CL9.1 ; UL1.43 v1(256.84,71.25) ; UL1.16 v1(257.64,75.41)
  TOP w0.254: CL10.1 251.49,67.71 251.74,67.46 252.72,67.46 254.44,69.18 254.44,69.63
  TOP w0.381: CL10.1 v1(252.05,67.97) ; v1(260.15,77.14) 260.15,77.51 260.42,77.78 260.42,77.79 CL9.1
  IN2 w0.254: v1(257.64,75.41) 257.09,75.41 v1(255.24,77.26)
  IN2 w0.762: 257.99,66.48 258.68,67.17 261.81,67.17 263.73,69.08 264.58,69.08
  IN4 w0.508: v1(252.05,67.97) 252.05,69.74 253.79,71.48 254.61,71.48 254.63,71.47
  BOTTOM w0.356: CL8.1 255.3,77.32 v1(255.24,77.26)
  vias: v1(257.36,65.67) v1(257.94,65.67) v1(265.18,69.69) v1(265.76,69.69) v2(265.64,70.2)
+1.0V_AMPHYPLL: length 21.8
  TOP w0.102: v1(133.41,78.33) 133.41,78 v2(133.9,77.5)
  TOP w0.381: v1(132.74,67.81) 132.74,67.58 132.11,66.95 CC264.1
  IN3 w0.508: v1(132.74,67.81) 131.92,68.63 130.51,68.63 129.49,69.64 129.49,72.21 130.63,73.34 131.72,73.34 133.86,75.48 133.86,77.87 v1(133.41,78.33)
  BOTTOM w0.254: UC1.L15 132.53,67.37 132.74,67.59 v1(132.74,67.81) 132.74,67.97 132.5,68.21 UC1.K15
  BOTTOM w0.381: RC169.2 134.57,80.52 134.24,80.18 134.07,80.18 133.41,79.52 CC219.1
  BOTTOM w0.508: CC219.1 v1(133.41,78.33)
+1.0V_APLL: length 25.8
  TOP w0.102: v1(152.63,69.03) 152.65,69.05 152.77,69.05 v2(153.19,69.47)
  IN3 w0.356: 135.06,64.63 134.98,64.7 133.42,64.7 133.18,64.46 v1(132.84,64.46)
  IN3 w0.508: v1(152.63,69.03) 152.87,69.27 152.87,69.68 152.41,70.14 148.3,70.14 147.44,69.28 145.25,69.28 144,68.03 143.81,68.03 142.26,66.48 140.39,66.48 138.33,64.41 135.52,64.41 135.31,64.63 135.06,64.63
  BOTTOM w0.254: UC1.V15 132.84,64.39 v1(132.84,64.46)
  BOTTOM w0.508: v1(152.63,69.03) 152.63,68.87 LC2.2
+1.0V_APLLEBB: length 13.7
  TOP w0.127: v2(134.97,81.83) 134.97,81.54 v1(135.31,81.2)
  TOP w0.508: v1(135.31,81.2) 135.31,80.63 RC310.2 134.03,80.18 CC325.1
  IN2 w0.508: v1(135.31,81.2) 135.31,81.07 134.02,79.79 134.02,73.85 134.36,73.52 134.36,71.93
  BOTTOM w0.254: UC1.N18 130.52,66.44 130.23,66.14 v1(130.23,66.13)
+1.0V_CLK1: length 7.6
  TOP w0.406: v1(133.2,75.72) 134.07,75.72 v1(135.41,77.06)
  BOTTOM w0.203: 132.9,74.34 132.8,74.24 UC1.A14
  BOTTOM w0.406: v1(135.41,77.06) 136.01,77.66 RC302.2 ; 132.9,74.34 133.2,74.65 v2(133.2,75.08) 133.2,75.72 v1(133.2,75.72)
+1.0V_CLK2: length 15.4
  TOP w0.508: v1(130.12,78.05) v2(130.12,77.16) 130.12,73.18 129.57,72.62 129.57,69.64 130.2,69.01 v1(130.2,67.79)
  BOTTOM w0.254: v1(130.2,67.79) 130.2,67.89 UC1.K19
  BOTTOM w0.508: RC170.2 128.03,79.94 CC220.1 128.41,79.11 129.47,78.05 v1(130.12,78.05)
+1.0V_CLK3: length 14.6
  TOP w0.102: v2(131.03,83.09) 130.81,82.87 v1(130.81,82.6)
  IN2 w0.508: v1(130.81,82.6) 130.81,82.3 129.42,80.91 129.42,77.77 129.93,77.26 129.93,73.66 131.06,72.52 131.06,72.11
  BOTTOM w0.254: UC1.L21 128.57,67.47 v1(128.82,67.79)
  BOTTOM w0.508: v1(130.81,82.6) 130.81,83.17 130.4,83.58 RC303.2
+1.0V_CLK4: length 21.7
  TOP w0.102: v2(124.26,78.44) 124.64,78.06 v1(124.64,77.77)
  IN2 w0.508: v1(128.9,66.12) 128.9,65.94 128.46,65.51 127.79,65.51 126,67.3 126,68.32 124.46,69.86 124.46,73.25 123.95,73.76 123.95,77.08 v1(124.64,77.77)
  BOTTOM w0.254: UC1.N20 v1(128.9,66.12)
  BOTTOM w0.508: v1(124.64,77.77) 124.64,79.02 CC226.1 124.93,79.21 125.91,80.18 125.91,80.56 126.19,80.85 RC173.2
+1.0V_CLK5: length 24.2
  TOP w0.102: RC52.2 v2(125.23,83.07)
  TOP w0.305: v1(129.54,67.82) 129.06,68.3 128.99,68.3 128.71,68.58 128.71,69.01 128.93,69.24 128.93,69.87
  TOP w0.508: 128.93,69.87 128.93,72.26 127.54,73.66 125.53,73.66 v1(125.25,73.94) ; RC52.2 124.13,81.87 v1(123.88,81.61)
  IN2 w0.508: v1(125.25,73.94) 125.91,74.6 125.91,79.57 v1(123.88,81.61)
  BOTTOM w0.254: UC1.L19 129.87,67.38 129.54,67.72 v1(129.54,67.82)
  BOTTOM w0.508: RC171.2 125.5,82.04 CC221.1 125,82.05 124.31,82.05 v1(123.88,81.61)
+1.0V_CLK6: length 7.4
  TOP w0.508: v1(139.22,79.04) 139.09,79.17 v2(138.61,79.17) 137.19,79.17 136.62,78.6 136.62,75.27 v1(135.82,74.47)
+1.0V_DTS:
  vias: v2(144.81,67.06)
+1.0V_MPHYAON: length 15.9
  TOP w0.508: 133.15,71.17 133.15,71.55 133.63,72.03 134.32,72.03 134.96,71.39 135.65,71.39 136.5,70.53 136.73,70.53 137.41,69.85 138.19,69.85 138.44,70.11 139.34,70.11 140.92,71.7 142.88,71.7 v1(143.39,71.19)
  BOTTOM w0.254: 131.17,68.18 UC1.K17 ; 131.17,68.18 131.23,68.18 131.44,67.97 131.44,67.82 v1(131.47,67.79) ; 131.17,68.18 131.17,68.16 v1(130.83,67.82) ; 142.37,68.2 140.96,68.2 140.96,68.2 140.89,68.13 140.38,68.13 140.36,68.15 UC1.L1
  vias: v2(145.32,69.26)
+1.0V_MPHYGT: length 3.6
  TOP w0.508: v1(135.11,78.1) 134.87,78.34 RC310.1
  BOTTOM w0.102: v2(138.83,83) 139.02,82.81 CC210.1
  BOTTOM w0.508: RC169.1 134.91,78.3 v1(135.11,78.1)
  vias: v1(131.47,66.09) v1(132.1,66.12) v1(132.74,66.12) v1(139.79,81.2) v1(140.37,81.21) v1(140.95,81.33) v1(141.1,80.74) v1(141.13,80.16) v1(141.55,81.32)
+1.0V_PRIM: length 99.9
  TOP w0.457: v1(127.74,64.25) 127.41,63.92 127.41,62.18 127.77,61.82 CC206.1
  TOP w0.508: v1(137.47,98.27) v3(137.47,97.65)
  IN3 w0.508: v1(95.29,93.19) 95.29,93.54 98.1,96.35 98.1,100.64 99.34,101.88 99.34,103.04 101.3,105 101.3,105.71 102.8,107.21 105.11,107.21 106.05,106.27 108.53,106.27 111.99,102.8 111.99,99.64 112.59,99.04 113.36,99.04 115.19,100.87 130.45,100.87 133.05,98.27 v1(137.47,98.27) ; 145.91,67.5 144.73,66.32 142.99,66.32 142.52,65.85 140.66,65.85 138.98,64.16 138.94,64.16 138.58,63.8 135.44,63.8 135.19,63.56 134.56,63.56 134.55,63.55 133.48,63.55 133.35,63.67 131.37,63.67 130.83,63.14 v1(130.83,62.76)
  BOTTOM w0.254: UC1.P18 130.1,65.28 128.15,65.28 127.74,64.86 v1(127.74,64.25) ; v1(127.93,58.87) 128.19,58.61 128.77,58.61 UC1.AK20 ; UC1.AB17 130.83,62.69 v1(130.83,62.76) 130.83,62.86 130.52,63.18 UC1.Y18
  BOTTOM w0.457: v1(148.97,67.97) 149.05,67.97 149.39,67.63 RC301.1
  BOTTOM w0.508: v1(95.29,93.19) 95.29,93 94.76,92.48 94.04,92.48 RC216.1
  BOTTOM w1.524: 132.9,90.6 130.66,90.6 130.56,90.5 128.73,90.5 127.03,88.79 127.03,84.88
  vias: v1(128.9,61.98) v1(129.55,61.98) v1(130.2,61.98) v1(140.26,87.04) v1(140.9,87.04) v1(146.46,68.45) v1(147.04,68.45) v1(147.63,68.45) v1(150.84,68.83) v1(151.43,68.83) v1(152.02,68.84) v1(158.74,97.2) v1(158.74,96.55) v1(159.33,97.2) v1(159.33,96.55) v1(159.91,97.2) v1(159.91,96.55) v1(160.49,97.2) v1(160.49,96.55) v1(161.1,97.2) v1(161.1,96.55) v1(161.69,97.2) v1(161.69,96.55) v1(162.27,97.2) v1(162.27,96.55)
+1.0V_PRIM_CORE: length 2.7
  TOP w0.127: v1(165.54,94.73) v3(164.98,94.73)
  BOTTOM w0.203: 129.44,63.8 UC1.V20 129,63.8 ; UC1.V21 128.57,63.64
  BOTTOM w0.254: UC1.AF19 130.18,60.97 v1(130.18,61.12) ; v1(130.83,61.09) 130.83,60.99 130.52,60.67 UC1.AF18
  vias: v1(128.3,61.08) v1(128.9,61.04) v1(165.56,95.32) v1(165.76,95.93) v1(166.17,95.32) v1(166.17,94.73) v1(166.43,95.93)
+1.0V_PRIM_COREP: length 17.8
  IN1 w0.254: v1(170.31,98.69) 170.31,96.59 170.01,96.29 168.76,96.29 168.56,96.08 v1(168.61,96.08) ; v1(168.27,102.7) 167.45,102.7 166.55,101.8 166.55,97.18 168.25,95.47 v1(168.61,95.47)
  BOTTOM w0.254: v1(170.31,98.69) 170.49,98.87 PU402.1 ; v1(168.27,102.7) v2(168.94,102.03) 170.36,102.03 PR423.2
+1.0V_PRIM_XDP: length 73.4
  TOP w0.356: CC29.1 101.16,108.44 101.58,108.02 v1(101.58,107.87)
  TOP w0.508: v1(112.83,99.87) 112.83,96.57 115.94,93.46 v2(115.94,89.84) RC115.2
  IN2 w0.508: v1(94.59,93.21) 94.59,93.37 95.1,93.87 100.18,93.87 100.41,93.65 v1(101.88,93.65)
  IN3 w0.508: v1(112.83,99.87) 112.83,103.09 108.84,107.08 108.84,108.61 107.62,109.83 105.8,109.83 103.84,107.87 v1(101.58,107.87) 101.58,107.57 100.31,106.3 96.16,106.3 95.2,105.34 95.2,104.82 v1(92.64,102.26) 93.25,101.65 94.7,101.65 95.43,100.91 95.43,98.47 93.98,97.02 93.98,93.82 v1(94.59,93.21)
  BOTTOM w0.279: JXDP1.43 92.64,96.72 ; JXDP1.44 v1(92.64,102.26)
  BOTTOM w0.381: 92.64,96.72 92.64,96.59 92.66,96.57 92.66,96.14 92.64,96.11 92.64,95.98 93.46,95.16 CC28.1 93.46,94.45 RC216.2
  BOTTOM w0.508: RC138.2 102.09,93.44 v1(101.88,93.65) ; v1(94.59,93.21) 94.59,93.79 94.24,94.15 RC216.2
+1.0V_SRAM: length 4
  TOP w0.457: CC217.1 127.45,61.2 127.75,60.89 v1(127.75,60.87)
  BOTTOM w0.254: v1(127.75,60.87) 127.75,60.88 128.06,60.58 128.48,60.58 UC1.AF21 128.69,60.55 129.11,60.55 UC1.AF20 ; UC1.T19 129.82,64.92 129.28,64.92 UC1.T20 129.17,64.86 128.9,64.59 v1(128.9,64.44)
  vias: v1(139.71,76.26) v1(140.19,76.67) v2(139.88,77.94)
+1.0V_VCCST: length 481.1
  TOP w0.508: PR605.1 59.93,67.25 PR604.1 PR601.1 59.91,65.49 PC602.1 v1(58.39,65.49) ; 103.84,81.05 104.22,80.67 RC152.2 ; 103.84,81.05 103.84,83.01 106.71,85.88 106.71,88.26 v3(107.4,88.95) v1(108.23,89.79) ; 103.84,81.05 102.78,81.05 102.42,80.69 RC157.2 ; CC202.1 128.11,66.85 v1(127.99,66.73) ; v1(126.08,81.53) 126.8,81.53 129.62,78.71 v1(130.1,78.71) ; v1(277.42,50.97) 277.63,50.77 RE59.1 ; v1(111.18,89.79) 111.18,92.17 v1(108.94,94.41)
  IN1 w0.508: v1(61.78,93.65) 61.78,94.53 62.54,95.3 64.52,95.3 65.84,96.62 68.13,96.62 68.36,96.39 70.59,96.39 71.48,97.28 v1(72.19,97.28)
  IN2 w0.508: 127.15,71.98 127.15,72.98 127.81,73.63 128.17,73.63 129.06,74.52 129.06,77.23 128.78,77.51 128.78,78.84 v1(126.08,81.53)
  IN3 w0.254: v1(240.83,39.82) 240.83,39.65 240.02,38.84 240.02,38.33 238.45,36.75 237.58,36.75 236.52,35.68 235.81,35.68 235.01,34.89 233.73,34.89 232.74,33.91 229.11,33.91 228.72,33.51 226.13,33.51 225.3,32.69 221.67,32.69 220.81,31.82 218.77,31.82 217.09,30.13 214.95,30.13 214.77,30.31 211.42,30.31 210.82,30.91 205.9,30.91 203.99,32.81 175.57,32.81 173.5,30.74 101.24,30.74 99.25,28.76 68.93,28.76 66.18,26.02 63.14,26.02 60.89,28.27 60.89,41.61 58.35,44.15 58.35,51.89 58.02,52.22 56.57,52.22 56.29,52.5 56.29,53.72 56.44,53.87 56.44,55.29 55.95,55.78 55.95,58.22 56.75,59.03 56.75,60.68 58.83,62.76 58.83,65.05 v1(58.39,65.49)
  IN3 w0.508: v1(108.94,94.41) 109.38,93.98 109.38,92.19 107.63,90.44 107.37,90.44 105.3,88.38 104.6,88.38 102.56,90.42 101.32,90.42 101.12,90.62 92.54,90.62 92.34,90.43 v1(91.86,90.43) 91.86,90.71 91.14,91.44 87.97,91.44 83.46,86.93 82.39,86.93 81.64,87.68 81.64,90.23 74.65,97.21 74.65,97.35 73.82,98.19 73.1,98.19 v1(72.19,97.28) ; v1(109.94,87.25) 108.23,88.95 v1(108.23,89.79) v1(111.18,89.79) 120.73,89.79 126.08,84.43 v1(126.08,81.53)
  IN4 w0.254: v1(277.42,50.97) 277.42,53.64 279.07,55.29 279.07,56.03 275.31,59.79 271.91,59.79 269.68,62.02 265.61,62.02 262.82,64.82 260.79,64.82 260.56,64.59 255.99,64.59 254.18,62.78 254.18,59.61 249.61,55.04 248.11,55.04 244.91,51.84 244.12,51.84 243.83,51.55 243.25,51.55 241.7,50 241.7,49.36 242.12,48.94 242.12,48.31 241.61,47.8 240.34,47.8 239.2,46.66 237.93,46.66 236.91,45.64 236.91,43.71 240.8,39.82 v1(240.83,39.82)
  BOTTOM w0.203: UC1.A18 130.32,73.98 130.71,74.37 130.71,74.93
  BOTTOM w0.254: v1(130.1,78.71) 130.3,78.71 130.61,78.41 130.61,77.49 130.71,77.39 130.71,74.93 ; UC1.K20 129.19,68.25 129.09,68.25 129.09,68.25 128.71,68.25 128.71,68.25 128.61,68.25 UC1.K21 128.57,68.29 128.14,67.86 128.14,66.88 v1(127.99,66.73)
  BOTTOM w0.305: RC120.2 109.35,87.75 108.87,88.24 107.73,88.24 RC71.2
  BOTTOM w0.508: v1(109.94,87.25) 109.5,87.68 RC120.2 ; v1(61.78,93.65) 61.78,82.47 60.38,81.07 60.38,77.39 60.95,76.82 60.95,75.04 59.87,73.96 59.87,70.96 59.21,70.3 59.21,66.32 v1(58.39,65.49) ; v1(91.86,90.43) 91.86,90.68 91.48,91.07 RC218.2 ; v1(111.18,89.79) 112.6,88.36 RC79.2 112.42,87.58 111.51,86.66 RC80.2 ; RE90.1 v1(108.23,89.79)
+1.0V_VCCSTG: length 83.3
  TOP w0.508: RC81.2 108.89,81.71 v1(108.92,81.73) ; RC143.2 132.88,83.62 v1(129.66,83.62) 129.59,83.55 129.59,81.94 CC199.1 128.14,81.89 127.82,82.22 125.87,82.22 125.36,81.71 125.36,80.99 126.64,79.71 v3(127.14,79.71) 129.29,77.57 129.29,74.91 128.78,74.4 128.06,74.4 v1(128.02,74.45) ; RC135.2 104.45,94.66 105.38,93.73 v1(106.86,93.73) ; v1(108.21,96.06) RC134.2 RC131.2 ; v1(111.51,82.17) 111.79,82.44 v1(111.79,87.93)
  IN1 w0.508: v1(129.66,83.62) 129.66,84.31 126.94,87.03 112.69,87.03 v1(111.79,87.93)
  IN2 w0.508: v1(106.86,93.73) 106.86,94.71 v1(108.21,96.06)
  IN3 w0.508: v1(104.96,89.79) 106.86,91.69 v1(106.86,93.73)
  IN4 w0.508: v1(108.92,81.73) 109.61,82.42 111.26,82.42 v1(111.51,82.17) ; v1(111.79,87.93) 115.5,91.64 115.5,93.9 114.23,95.17 111.94,95.17 111.05,96.06 v1(108.21,96.06)
  BOTTOM w0.203: UC1.A22 127.84,74.18 128.02,74.36 v1(128.02,74.45)
  BOTTOM w0.381: v1(104.96,89.79) RC83.2
  BOTTOM w0.508: RC82.2 111.51,81.48 v1(111.51,82.17) ; RC87.2 109.07,80.96 RC130.2 109.08,81.57 v1(108.92,81.73)
+1.0V_VCCSTG_C:
  vias: v2(131.16,89.24)
+1.0V_VCCSTG_R: length 14.3
  TOP w0.254: 131.04,71.29 130.64,70.89 130.64,70.2 130.35,69.91 v1(130.17,69.91)
  TOP w0.508: RC143.1 132.61,82.04 131.12,80.55 v2(131.12,79.09) 131.12,72.56 131.04,72.49 131.04,71.29
  BOTTOM w0.254: UC1.G20 129.89,69.63 v1(130.17,69.91)
+1.0VO_DSW: length 9.1
  BOTTOM w0.076: v2(146.87,57.98) 146.91,58.03
  BOTTOM w0.254: v2(146.87,57.98) 146.03,57.15 142.51,57.15 142.12,57.54 UC1.AL1 ; 146.91,58.03 148.11,59.23 CC204.1
+1.0VS_VCCIO: length 151.2
  TOP w0.508: v1(109.91,91.8) 110.49,91.22 110.49,89.33 111.05,88.77 v3(111.05,87.42) 111.05,83.1 110.09,82.14 RC2.2
  IN2 w0.508: v1(109.91,91.8) 109.47,91.8 108.87,91.21 104.27,91.21 104.12,91.36 103.66,91.36 103.65,91.35 103.58,91.35 103.51,91.28 102.93,91.28 102.62,91.59 102.62,93.85 102.13,94.34 100.61,94.34 99.33,95.63 97.74,95.63 97.31,95.2 95.36,95.2 94.9,95.65 94.04,95.65 92.9,94.52 v1(92.9,93.84)
  IN3 w0.122: 118.77,56.51 118.77,53.59
  IN3 w0.127: 126.04,56.05 126.04,57.58 125.79,57.83
  IN3 w0.508: v1(173.23,57.63) 175.29,59.69 175.29,60.88 174.81,61.36 174.81,66.82 173.28,68.35 173.28,77.61 172.24,78.65 172.24,84.79 170.97,86.06 170.97,91.7 167.89,94.79 167.89,95.8 166.93,96.76 165.73,96.76 163.82,94.85 153.6,94.85 153.15,95.3 125.28,95.3 122.86,97.71 119.69,97.71 119.23,97.25 117.26,97.25 114.74,94.73 112.83,94.73 v1(109.91,91.8)
  BOTTOM w0.203: UC1.AL30 123.77,57.48 ; UC1.AL30 123.77,58.24 ; UC1.AL30 124.15,57.86 ; UC1.AL30 123.39,57.86 ; 124.22,57.95 UC1.AK28 ; UC1.AK28 124.22,58.71 ; UC1.AK28 123.84,58.33 ; UC1.AK28 124.61,58.33 ; 123.31,57.95 UC1.AK30 ; UC1.AK30 123.31,58.71 ; UC1.AK30 123.69,58.33
  BOTTOM w0.254: v1(109.91,91.8) 109.66,91.55 QE11.1 ; UC1.AL42 v1(117.37,57) UC1.AM42 v1(116.45,57)
  BOTTOM w0.508: RC132.2 92.8,93.89 92.86,93.84 v1(92.9,93.84)
  vias: v1(122.85,57) v1(123.29,59.18) v1(123.77,57) v1(123.88,59.19) v1(124.46,59.19) v1(172.29,57.05) v1(172.29,56.47) v1(172.62,57.6) v1(172.88,57.05) v1(172.88,56.47) v1(173.41,56.74)
+1.2V_DDR_B+:
  vias: v1(57.98,60.91) v1(58.61,60.91) v1(60.35,61.62) v1(60.35,61.03) v1(60.35,60.42) v2(59.08,61.53)
+1.2V_DDRP: length 30.5
  IN1 w0.508: v1(54.13,63.57) 54.13,63.52 53.65,63.04 50.63,63.04 48.3,60.71 48.3,58.61 47.12,57.43 47.12,49.17 47.88,48.41 49.17,48.41 50.08,49.32 54.31,49.32 55.15,50.16 v1(55.15,50.87)
  BOTTOM w0.508: v1(54.13,63.57) 54.43,63.87 PR204.1 54.8,63.88 PC208.1
  vias: v1(53.29,50.85) v1(53.93,50.85) v1(54.51,56.64) v1(54.51,50.87) v1(55.1,56.64) v1(55.78,50.87) v1(56.42,50.87) v1(57.05,50.87) v3(55.68,50.11)
+1.2V_LDO: length 16.6
  IN2 w0.508: v1(74.76,96.03) 74.05,95.32 74.05,94.1 74.48,93.67 74.48,92.36 75.81,91.03 v1(76.66,91.03)
  BOTTOM w0.127: v1(74.76,96.03) 74.76,96.48 74.62,96.62 73.65,96.62 73.6,96.57 73.04,96.57 v2(72.81,96.34)
  BOTTOM w0.203: UR1.14 76.82,94.35 76.73,94.44 76.06,94.44 ; UR1.10 76.89,92.75 76.51,92.38 76.51,92.05
  BOTTOM w0.508: 76.06,94.44 CR6.1 75.49,95.94 CR5.1 75.4,96.03 v1(74.76,96.03) ; 76.51,92.05 76.51,91.74 CR7.1 75.95,91.03 v1(76.66,91.03)
+1.2V_MEM: length 138.6
  TOP w0.381: 55.55,24.68 51.53,24.68 49.54,26.67 CD32.1 49.53,27.06 49.49,27.1 UD1.5
  TOP w0.508: CD41.1 189.07,10.57 v1(188.92,10.43) ; RD28.1 47.24,13.97 47.93,13.27 47.93,11.94 49.16,10.71 49.97,10.71 ; v1(106.91,10.53) 107.02,10.64 CD8.1
  IN1 w0.457: v1(122.78,50.46) 123.07,50.75 124.81,50.75 125.93,49.63 127.48,49.63 v1(127.93,50.07)
  IN2 w0.508: v1(188.92,10.43) 188.8,10.43 188.08,11.15 179.11,11.15 v1(178.43,10.47)
  BOTTOM w0.152: UC1.BB41 117.82,50.52
  BOTTOM w0.178: v1(114.2,50.41) 114.16,50.45 UC1.BB47 ; v1(127.93,50.07) 127.77,50.23 127.77,51.41 UC1.BB23 ; UC1.BB32 122.78,51.42 v1(122.78,50.46) ; UC1.BB51 111.7,50.46 v1(111.72,50.44)
  BOTTOM w0.254: v1(116.42,54.46) 116.74,54.14 UC1.AU42 ; v1(123.77,54.44) 124.07,54.14 UC1.AU28 ; v1(120.11,54.44) 120.41,54.14 UC1.AU35 ; v1(117.73,49.58) 117.8,49.65 117.8,50.51 117.82,50.52 ; UC1.AU23 126.81,54.14 v1(126.51,54.44)
  BOTTOM w0.305: v1(101.79,21.79) 101.68,21.68 JDIMM1.199 ; v1(161.42,10.54) JDIMM2.118 ; JDIMM2.153 172.17,20 172.17,22 172.58,22.41 v1(173.04,22.41) ; JDIMM1.136 83.93,10.5 v1(84.06,10.37) ; JDIMM1.118 v1(79.43,10.34) ; JDIMM1.112 v1(77.93,10.34) ; JDIMM1.142 v1(85.43,10.37) ; v1(167.82,10.46) 167.43,10.86 JDIMM2.142 ; v1(159.93,10.5) JDIMM2.112 ; v1(150.39,21.36) 150.68,21.07 JDIMM2.75 ; v1(63.43,10.57) 63.43,10.58 JDIMM1.54 ; JDIMM2.129 164.17,21.52 v1(164.26,21.6) ; v1(91.68,10.32) 91.93,10.56 JDIMM1.160 ; v1(78.43,22.06) 79.18,21.32 JDIMM1.117 ; JDIMM1.241 112.18,20 112.18,21.06 111.85,21.39 v1(111.14,21.39) ; JDIMM2.148 170.92,11.8 v1(170.92,10.52) ; v1(86.48,21.54) 85.63,21.54 85.18,21.08 JDIMM1.141 ; JDIMM2.141 v1(167.17,21.7) ; v1(172.9,10.46) 172.43,10.94 JDIMM2.154 ; v1(77.84,21.47) 77.68,21.3 JDIMM1.111 ; JDIMM1.153 90.18,20 90.18,21.51 v1(90.24,21.57) ; 164.85,22.2 165.68,21.37 JDIMM2.135 ; JDIMM1.124 v1(80.93,10.32) ; JDIMM2.163 174.68,20.97 175.3,21.59 v1(175.24,21.59) ; JDIMM2.111 159.68,21.01 160.19,21.52 ; v1(91.68,22.3) 92.01,22.3 92.68,21.64 JDIMM1.163 ; JDIMM2.147 170.68,21.59 v1(169.46,22.81) ; v1(69.02,21.2) 68.68,20.86 JDIMM1.75 ; v1(96.46,10.32) 96.43,10.35 JDIMM1.178 ; v1(173.92,10.47) 173.92,11.8 JDIMM2.160 ; JDIMM1.12 52.93,10.58 v1(52.94,10.57) ; v1(173.04,21.8) 173.68,21.16 JDIMM2.159 ; JDIMM1.159 91.68,21.18 91.23,21.63 v1(91.23,21.81) ; JDIMM2.199 183.68,20.98 183.99,21.29 v1(184.29,21.29) ; v1(90.26,10.32) 90.26,10.54 90.43,10.71 JDIMM1.154 ; v1(193.92,21.21) 194.17,20.95 194.17,20 JDIMM2.241 ; v1(80.68,21.9) 80.74,21.9 80.74,21.81 80.68,21.75 JDIMM1.123 ; JDIMM1.135 83.68,21.52 v1(82.69,22.51) ; JDIMM1.220 106.93,11.8 106.93,10.54 v1(106.91,10.53) ; JDIMM2.33 140.17,21.32 v1(140.28,21.43) ; JDIMM2.96 155.93,10.88 v1(155.51,10.47) ; JDIMM2.178 v1(178.43,10.47) ; JDIMM2.117 161.17,21.21 v1(161.81,21.85) ; JDIMM1.96 v1(73.93,10.32) ; v1(82.18,22.09) JDIMM1.129 ; v1(134.93,10.48) JDIMM2.12 ; v1(165.92,10.47) JDIMM2.136 ; v1(82.43,10.35) JDIMM1.130 ; v1(188.92,10.43) 188.93,10.43 JDIMM2.220 ; JDIMM1.148 88.93,10.92 89.32,10.53 v1(89.32,10.34) ; v1(164.43,10.47) JDIMM2.130 ; v1(162.92,10.49) JDIMM2.124 ; v1(86.88,22.13) 87.64,22.13 88.63,21.14 88.63,20.04 JDIMM1.147 ; 163.07,22.19 v1(163.07,22.21) ; v1(145.42,10.36) JDIMM2.54 ; JDIMM2.123 162.68,21.8 ; JDIMM1.33 v1(58.18,21.48)
  vias: v1(54.98,48.22) v1(55.24,48.75) v1(55.24,47.61) v1(55.25,46.99) v1(55.62,48.22) v1(55.87,48.75) v1(55.87,47.61) v1(55.87,46.97) v1(56.25,48.22) v1(56.51,48.75) v1(56.51,47.61) v1(56.51,47.02) v1(56.89,48.22) v1(57.14,48.75) v1(57.14,47.61) v1(57.14,47.02) v1(57.52,48.22) v1(57.78,48.75) v1(111.05,26.84) v1(111.37,26.27) v1(111.69,26.86) v1(112.07,26.4) v1(112.07,25.7) v1(112.51,25.19) v1(144.45,10.4) v1(160.85,22.76) v1(161.3,22.33) v1(168.97,23.32) v1(173.04,23.62) v1(173.04,22.99) v1(175.35,22.71) v3(187.34,22.06)
