# Allegro board LAF391PR10-0920.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on IN1 (solid shape): 19.49,17.8 22.74,17.8 28.05,12.49 44.47,12.49 47.6,9.36 221.65,9.36 221.89,9.46 221.99,9.7 221.99,9.8 223.03,12.32 225.55,13.36 226.55,13.36 229.07,12.32 230.11,9.8 230.11,9.7 230.21,9.46 230.45,9.36 240.6,9.36 241.77,8.87 242.26,7.7 242.26,1 242.36,0.76 242.6,0.66 277.68,0.66 277.68,0.2 242.6,0.2 242.04,0.44 241.8,1 241.8,7.7 241.45,8.55 240.6,8.9 230.45,8.9 229.89,9.14 229.65,9.7 229.65,9.8 228.74,11.99 226.55,12.9 225.55,12.9 223.36,11.99 222.45,9.8 222.45,9.7 222.21,9.14 221.65,8.9 1,8.9 0.44,9.14 0.2,9.7 0.2,17.9 0.44,18.46 1,18.7 12.14,18.7 12.15,18.66 12.94,18.21 13.52,18.9 13.52,20.24 17.05,20.24
GND on IN1 (solid shape): outline of 332 points within 0.2,54.33 12.5,68.35
GND on IN1 (solid shape): outline of 2478 points within 0.2,45.14 300.9,112.9
GND on IN1 (solid shape): outline of 2862 points within 157.84,12.75 192.87,19.18
GND on IN1 (solid shape): outline of 2842 points within 51.11,11.22 158.55,25.44
GND on IN2 (solid shape): 154.54,107.44 154.54,104.24 152.63,102.33 149.58,102.33 147.43,104.49 147.43,107.16 148.42,108.15 153.83,108.15
GND on IN2 (solid shape): 287.58,16.65 288.16,15.96 288.95,16.41 288.96,16.45 300.1,16.45 300.66,16.21 300.9,15.65 300.9,14.32 284.59,14.32 283.01,15.9 283.01,18.21 283.44,18.64 287.58,18.64
GND on IN2 (solid shape): 288.75,68.66 289.2,68.11 289.82,68.45 300.1,68.45 300.66,68.22 300.9,67.66 300.9,64.3 300.66,63.74 300.1,63.5 297.2,63.5 297.2,63.2 297.11,62.99 296.9,62.9 296.2,62.9 296.2,61.7 295.96,61.14 295.4,60.9 294.75,60.9 294.21,60.65 294.06,60.07 293.6,60.07 291.49,62.18 287.13,62.18 286.06,63.24 282.05,63.24 281.41,63.88 281.41,67.69 282.63,68.91 288.75,68.91
GND on IN2 (solid shape): 17.89,39.57 17.89,31.8 17.1,31.01 13.52,31.01 13.52,32.5 12.94,33.19 12.15,32.74 12.14,32.7 1,32.7 0.44,32.94 0.2,33.5 0.2,34.6 0.44,35.16 1,35.4 1.5,35.4 2,35.6 2.2,36.1 2.2,37.1 2,37.6 1.5,37.8 1,37.8 0.44,38.04 0.2,38.6 0.2,39.45 0.44,40.01 1,40.25 9.5,40.25 10.19,40.83 9.74,41.61 9.7,41.62 9.7,42.13 15.32,42.13
GND on IN2 (solid shape): outline of 247 points within 283.82,28.62 300.9,46.88
GND on IN2 (solid shape): outline of 337 points within 0.2,54.4 12.53,68.27
GND on IN2 (solid shape): outline of 383 points within 0.2,0.2 277.68,20.09
GND on IN2 (solid shape): outline of 2438 points within 0.2,45.14 300.9,112.9
GND on IN2 (solid shape): outline of 10760 points within 49.95,10.94 196.3,23.14
GND on IN3 (solid shape): 82.7,62.57 82.7,61.06 82.57,60.94 79.92,60.94 79.81,61.05 79.81,62.53 79.99,62.71 82.56,62.71
GND on IN3 (solid shape): 288.75,68.66 289.2,68.11 289.82,68.45 300.1,68.45 300.66,68.22 300.9,67.66 300.9,64.3 300.66,63.74 300.1,63.5 297.2,63.5 297.2,63.2 297.11,62.99 296.9,62.9 296.2,62.9 296.2,61.7 295.96,61.14 295.4,60.9 294.75,60.9 294.4,60.81 294.14,60.55 294.13,60.54 294.07,60.36 294.05,60.18 294.02,60.1 293.95,60.07 293.6,60.07 293.36,59.84 282.96,59.84 281.23,61.57 281.23,62.09 281.41,62.26 281.41,62.9 281.42,62.98 281.41,63.05 281.41,63.57 281.42,63.67 281.41,63.77 281.41,67.69 282.63,68.91 288.75,68.91
GND on IN3 (solid shape): 17.86,39.95 17.86,37.11 17.28,36.52 17.28,31.72 16.51,30.96 13.52,30.96 13.52,32.5 12.94,33.19 12.15,32.74 12.14,32.7 1,32.7 0.44,32.94 0.2,33.5 0.2,34.6 0.44,35.16 1,35.4 1.5,35.4 2,35.6 2.2,36.1 2.2,37.1 2,37.6 1.5,37.8 1,37.8 0.44,38.04 0.2,38.6 0.2,39.45 0.44,40.01 1,40.25 9.5,40.25 10.19,40.83 9.74,41.61 9.7,41.62 9.7,41.98 15.83,41.98
GND on IN3 (solid shape): 294.55,44.87 294.51,44.86 294.06,44.32 294.3,43.66 294.51,43.54 294.75,43.5 295.4,43.5 295.96,43.26 296.2,42.7 296.2,41.5 296.9,41.5 297.11,41.41 297.2,41.2 297.2,40.9 300.1,40.9 300.66,40.66 300.9,40.1 300.9,33.55 300.66,32.99 300.1,32.75 299.8,32.75 299.3,32.55 299.1,32.05 299.1,30.75 299.01,30.54 298.8,30.45 294.3,30.45 288.96,30.45 288.95,30.49 288.16,30.94 287.58,30.25 287.58,28.7 287.51,28.62 284.48,28.62 283.52,29.59 283.52,30.2 284.36,31.03 285.91,31.03 286.9,32.03 290.15,32.03 292.31,34.18 292.31,46.25 292.66,46.6 294.55,46.6
GND on IN3 (solid shape): outline of 190 points within 277.82,13.28 300.9,22.59
GND on IN3 (solid shape): 19.49,17.8 22.74,17.8 28.05,12.49 44.47,12.49 47.6,9.36 221.65,9.36 221.89,9.46 221.99,9.7 221.99,9.8 223.03,12.32 225.55,13.36 226.55,13.36 229.07,12.32 230.11,9.8 230.11,9.7 230.21,9.46 230.45,9.36 240.6,9.36 241.77,8.87 242.26,7.7 242.26,1 242.36,0.76 242.6,0.66 277.68,0.66 277.68,0.2 242.6,0.2 242.04,0.44 241.8,1 241.8,7.7 241.45,8.55 240.6,8.9 230.45,8.9 229.89,9.14 229.65,9.7 229.65,9.8 228.74,11.99 226.55,12.9 225.55,12.9 223.36,11.99 222.45,9.8 222.45,9.7 222.21,9.14 221.65,8.9 1,8.9 0.44,9.14 0.2,9.7 0.2,17.9 0.44,18.46 1,18.7 12.14,18.7 12.15,18.66 12.94,18.21 13.52,18.9 13.52,20.24 17.05,20.24
GND on IN3 (solid shape): outline of 337 points within 0.2,54.4 12.53,68.27
GND on IN3 (solid shape): outline of 2590 points within 0.2,45.14 300.9,112.9
GND on IN4 (solid shape): 66.09,50.96 66.09,49.27 66.01,49.19 65.06,49.19 64.93,49.32 64.93,50.44 64.82,50.56 63.7,50.56 63.57,50.58 63.44,50.56 63.38,50.56 63.29,50.65 63.29,51.05 63.36,51.13 65.93,51.13
GND on IN4 (solid shape): 69.36,56.4 69.36,53.94 68.56,53.14 68.56,49.39 68.48,49.31 67.33,49.31 67.29,49.35 67.29,49.76 67.16,49.89 66.71,49.89 66.64,49.83 66.64,48.34 66.61,48.31 66.33,48.31 66.27,48.38 66.27,51.01 66.66,51.4 66.66,52.87 67.04,53.25 67.04,56.53 67.25,56.74 69.03,56.74
GND on IN4 (solid shape): 288.75,68.66 289.2,68.11 289.82,68.45 300.1,68.45 300.66,68.22 300.9,67.66 300.9,64.3 300.66,63.74 300.1,63.5 297.97,63.5 297.2,63.5 297.2,63.2 297.11,62.99 296.9,62.9 296.2,62.9 296.2,61.7 295.96,61.14 295.4,60.9 294.9,60.9 294.75,60.9 294.21,60.65 294.06,60.07 293.6,60.07 291.49,62.18 287.13,62.18 286.06,63.24 282.05,63.24 281.41,63.88 281.41,67.69 282.63,68.91 288.75,68.91
GND on IN4 (solid shape): 17.86,39.95 17.86,37.11 17.28,36.52 17.28,31.72 16.51,30.96 13.52,30.96 13.52,32.5 12.94,33.19 12.15,32.74 12.14,32.7 1,32.7 0.44,32.94 0.2,33.5 0.2,34.6 0.44,35.16 1,35.4 1.5,35.4 2,35.6 2.2,36.1 2.2,37.1 2,37.6 1.5,37.8 1,37.8 0.44,38.04 0.2,38.6 0.2,39.45 0.44,40.01 1,40.25 9.5,40.25 10.19,40.83 9.74,41.61 9.7,41.62 9.7,41.98 15.83,41.98
GND on IN4 (solid shape): 294.55,44.87 294.51,44.86 294.07,44.39 294.2,43.76 294.44,43.57 294.75,43.5 295.4,43.5 295.96,43.26 296.2,42.7 296.2,41.5 296.9,41.5 297.11,41.41 297.2,41.2 297.2,40.9 300.1,40.9 300.66,40.66 300.9,40.1 300.9,33.55 300.66,32.99 300.1,32.75 299.8,32.75 299.3,32.55 299.1,32.05 299.1,30.75 299.01,30.54 298.8,30.45 293.63,30.45 288.96,30.45 288.95,30.49 288.16,30.94 287.58,30.25 287.58,28.62 284.66,28.62 283.82,29.46 283.82,30.6 285.22,32 285.22,37.23 287.68,39.7 289.44,39.7 292,42.26 292,45.94 292.94,46.88 294.55,46.88
GND on IN4 (solid shape): 8.05,67.86 8.44,67.86 8.44,67.86 8.59,67.86 9.5,66.95 9.5,58.29 9.99,57.8 10.07,57.69 10.18,57.61 10.22,57.58 11.48,57.58 12.5,56.56 12.5,54.83 12.06,54.4 9.7,54.4 9.7,54.68 9.74,54.69 10.19,55.47 9.5,56.05 1,56.05 0.44,56.29 0.2,56.85 0.2,57.81 0.4,58.34 0.89,58.6 1.5,59.24 1,59.97 1,62.93 1.5,63.66 0.89,64.3 0.4,64.56 0.2,65.09 0.2,65.78 0.44,66.34 1,66.58 4.13,66.58 4.23,66.37 4.39,66.21 5.12,66.15 5.5,66.78 5.5,68.27 7.65,68.27
GND on IN4 (solid shape): outline of 190 points within 277.82,13.28 300.9,22.59
GND on IN4 (solid shape): 19.49,17.8 22.74,17.8 28.66,11.88 45.08,11.88 47.6,9.36 221.65,9.36 221.89,9.46 221.99,9.7 221.99,9.8 223.03,12.32 225.55,13.36 226.55,13.36 229.07,12.32 230.11,9.8 230.11,9.7 230.21,9.46 230.45,9.36 240.6,9.36 241.77,8.87 242.26,7.7 242.26,1 242.36,0.76 242.6,0.66 277.68,0.66 277.68,0.2 242.6,0.2 242.04,0.44 241.8,1 241.8,7.7 241.45,8.55 240.6,8.9 230.45,8.9 229.89,9.14 229.65,9.7 229.65,9.8 228.74,11.99 226.55,12.9 225.55,12.9 223.36,11.99 222.45,9.8 222.45,9.7 222.21,9.14 221.65,8.9 1,8.9 0.44,9.14 0.2,9.7 0.2,17.9 0.44,18.46 1,18.7 12.14,18.7 12.15,18.66 12.94,18.21 13.52,18.9 13.52,20.24 17.05,20.24
GND on IN4 (solid shape): outline of 150 points within 121.85,10.21 196.65,15.67
GND on IN4 (solid shape): outline of 2477 points within 0.2,45.14 300.9,112.9
GND on IN4 (solid shape): outline of 4188 points within 46.92,12.65 117.77,42.67
GND on TOP: 73.94,54.61 73.75,54.8 72.53,54.8 71.95,55.38 71.95,57.12 72.09,57.26 74.34,57.26 74.48,57.12 76.78,57.12 77.4,57.74 78.03,57.74 78.7,58.41 78.7,59.13 78.49,59.34 75,59.34 74.9,59.24 74.38,59.24 74.26,59.36 74.26,60.49 74.52,60.74 75.61,60.74 76.13,61.27 78.15,61.27 78.35,61.47 78.35,62.59 78.43,62.68 83.01,62.68 83.02,62.67 83.49,62.67 83.69,62.48 83.69,60.36 83.51,60.18 81.31,60.18 79.87,58.75 79.87,55.55 79.81,55.48 79.02,55.48 78.78,55.72 78.78,56.37 78.4,56.75 77.53,56.75 77.32,56.55 77.32,56.03 75.9,54.61
GND on TOP: 15.42,64.69 15.93,64.69 16.06,64.56 16.06,63.29 16.25,63.1 16.25,62.47 16.18,62.4 15.55,62.4 15.36,62.59 15.36,64.63
GND on TOP: 56.7,63.48 55.3,63.48 55.24,63.55 55.24,64.69 55.36,64.82 56.63,64.82 56.76,64.69 56.76,63.55
GND on TOP: 77.53,75.36 76.51,75.36 76.26,75.1 76.26,74.09 75.62,73.45 75.62,70.57 75.85,70.34 76.1,70.34 76.26,70.19 76.26,66.53 76.45,66.34 76.45,65.77 76.7,65.52 76.95,65.52 77.78,66.34 77.78,75.1
GND on TOP: 64.65,62.4 63.63,62.4 63.45,62.23 63.45,61.26 63.56,61.16 64.14,61.16 64.34,60.96 64.34,60.63 64.47,60.5 64.95,60.5 65.08,60.63 65.08,61.01 65.23,61.16 65.82,61.16 65.89,61.24 65.89,61.67 65.82,61.74 65.31,61.74
GND on TOP: 172.88,63.51 172.88,63.05 172.76,62.93 172.16,62.93 172.01,62.78 172.01,61.64 171.86,61.49 171.56,61.49 171.31,61.73 171.31,63.36 171.91,63.95 172.43,63.95
GND on TOP: 31.69,36.33 32.69,35.33 32.69,31.09 32.69,31.08 32.69,30.94 32.44,30.68 28.79,30.68 28.17,30.06 28.14,30.06 28.13,30.07 23.04,30.07 22.63,29.66 21.01,29.66 20.58,29.23 18.53,29.23 18.43,29.33 18.43,32.18 18.87,32.62 22.02,32.62 22.24,32.4 22.24,31.88 22.53,31.59 25.77,31.59 25.97,31.79 26.75,31.79 27,32.04 27,33.13 26.64,33.49 25.81,33.49 25.71,33.58 25.71,36.22 25.83,36.33
GND on TOP: 81.46,53.32 81.4,53.39 81.4,54.95 80.86,55.48 80.23,55.48 80.06,55.65 80.06,58.59 80.23,58.77 80.76,58.77 82.03,60.04 83.62,60.04 83.69,59.98 83.69,59.73 82.8,58.84 82.8,55.36 83.05,55.1 83.05,53.39 82.99,53.32
GND on TOP: 58.04,92.3 57.35,92.99 56.37,92.99 54.99,94.36 54.99,95.81 54.75,96.06 53.27,96.06 53.14,95.93 51.62,95.93 51.36,95.68 51.36,94.53 51.24,94.41 50.73,94.41 50.6,94.53 50.6,94.92 49.33,96.19 49.33,98.73 49.59,98.98 60,98.98 60.63,98.34 60.63,96.98 60.61,96.85 60.63,96.71 60.63,96.44 61.02,96.06 61.02,93.14 60.18,92.3 ; 1 cut-out
GND on TOP: 102.67,88.82 102.67,89.71 100.26,92.12 98.61,92.12 98.23,92.5 98.23,93.52 96.32,95.42 94.42,95.42 93.78,94.79 93.78,90.85 94.67,89.96 94.67,88.57 96.07,87.17 96.32,87.17 96.45,87.3 96.45,88.69 97.46,89.71 100.26,89.71 100.39,89.58 100.39,88.82 100.51,88.69 102.54,88.69
GND on TOP: 113.9,63.34 113.11,63.34 112.96,63.19 112.96,62.23 113.09,62.1 113.92,62.1 114.02,62.2 114.02,63.22
GND on TOP: 66.58,54.05 66.58,50.53 66.9,50.21 69.26,50.21 69.32,50.28 69.32,56.22 69.05,56.49 69.05,56.49 68.9,56.63 66.46,56.63 66.31,56.49 66.31,54.31
GND on TOP: 21.07,37.4 22.97,37.4 23.05,37.49 23.05,39.11 22.99,39.17 20.97,39.17 20.85,39.05 20.85,37.62
GND on TOP: 77.4,47.29 77.97,47.87 79.19,47.87 79.23,47.82 79.23,46.9 79.17,46.83 77.46,46.83 77.4,46.89
GND on TOP: 74.66,76.15 75.08,76.15 75.24,76.31 75.24,77.96 75.09,78.1 74.05,78.1 73.97,78.03 73.97,76.85
GND on TOP: 75.81,76.75 79.16,76.75 79.29,76.89 79.29,79.9 78.54,80.65 78.54,83.08 78.84,83.38 78.84,84.19 78.69,84.34 75.96,84.34 75.56,83.93 75.56,77.01
GND on TOP: 165.79,61.51 166.17,61.51 166.3,61.64 166.3,62.15 164.77,63.67 164.65,63.67 164.14,63.17 163.5,63.17 163.25,62.91 162.74,62.91 161.98,62.15 161.22,62.15 161.09,62.02 161.09,61.64 161.17,61.57 163.02,61.57 163.12,61.67 163.12,62.18 163.58,62.63 165.13,62.63 165.71,62.05 165.71,61.59
GND on TOP: 68.97,91.36 69.27,91.36 69.78,91.87 71.44,91.87 71.72,91.59 71.72,87.99 71.93,87.78 72.39,87.78 72.47,87.7 72.47,87.35 72.38,87.26 70.93,87.26 70.79,87.39 70.79,88.99 70.63,89.15 68.99,89.15 68.91,89.22 68.91,91.3
GND on BOTTOM: 246.54,38.93 246.1,39.37 245.87,39.37 245.3,39.94 245.3,40.55 244.78,41.07 244.78,41.3 244.91,41.43 245.69,41.43 245.8,41.32 245.8,41.31 246.05,41.06 247.34,41.06 247.58,41.31 250.77,41.31 250.81,41.26 250.81,39.31 250.43,38.93
GND on BOTTOM: 91.5,59.04 92.13,59.04 92.57,58.59 92.57,56.63 92.51,56.56 92.26,56.56 92.13,56.69 92.13,57.32 91.5,57.96
GND on BOTTOM: 82.94,95.14 84.94,95.14 85.65,95.86 85.65,96.03 85.25,96.44 84.71,96.44 84.26,96.9 84.26,98.68 84.15,98.78 83.6,98.78 83.54,98.73 83.54,98.12 82.94,97.51
GND on BOTTOM: 249.79,44.95 248.84,45.9 248.84,47.31 248.88,47.35 251.42,47.35 251.64,47.13 251.64,46.28 252.02,45.89 252.02,45.13 251.85,44.95
GND on BOTTOM: 85.14,60.74 85.14,60.73 84.96,60.54 82.05,60.54 81.88,60.7 81.81,60.7 79.62,60.7 79.61,60.69 79.43,60.69 79.24,60.5 78.97,60.5 78.58,60.11 78.02,60.11 77.81,59.9 77.81,59.39 77.78,59.36 77.4,59.36 77.4,59.35 76.7,59.35 76.7,59.36 75.47,59.36 74.52,58.41 74.52,57.41 75.14,56.79 76.92,56.79 77,56.71 77,55.37 76.21,54.58 73.99,54.58 73.67,54.9 73.67,56.37 73.3,56.74 71.75,56.74 71.26,57.23 71.26,60.17 71.26,60.79 71.68,61.22 72.14,61.22 72.38,61.13 72.62,61.22 73.87,61.22 73.87,61.21 74.02,61.18 74.16,61.21 74.17,61.22 74.41,61.22 74.62,61.16 74.82,61.22 75.07,61.22 75.29,61.15 75.51,61.22 76.08,61.78 78.43,61.78 79.05,62.4 79.05,62.72 79.36,63.03 79.8,63.03 80.05,62.77 83.67,62.77 83.72,62.72 83.72,61.61 83.67,61.55 83.19,61.55 83.13,61.48 83.13,60.94 83.17,60.89 84.6,60.89 85.28,61.57 85.9,61.57 85.96,61.52 85.96,60.92 85.81,60.77 85.19,60.77 85.16,60.74
GND on BOTTOM: 79.24,47.82 79.24,46.9 79.17,46.83 77.39,46.83 77.33,46.88 77.33,47.35 77.46,47.48 77.72,47.48 78.1,47.87 79.19,47.87
GND on BOTTOM: 100.51,88.82 102.67,88.82 102.8,88.95 102.8,89.71 102.54,89.96 102.54,91.87 102.42,91.99 96.07,91.99 94.67,90.6 94.67,88.57 96.07,87.17 96.32,87.17 96.45,87.3 96.45,88.82 97.46,89.84 100.13,89.84 100.39,89.58 100.39,88.95
GND on BOTTOM: 74.16,76.18 74.1,76.25 74.1,77.28 73.83,77.55 72.46,77.55 72.41,77.51 71.12,77.51 71.07,77.56 71.07,78.22 71.11,78.27 72.11,78.27 72.48,77.9 73.73,77.9 73.73,77.9 75.19,77.9 75.35,77.74 75.35,76.22 75.32,76.18
GND on BOTTOM: 65.08,49.2 64.94,49.34 64.94,50.55 64.81,50.67 64.81,50.67 64.76,50.72 63.97,50.72 63.79,50.54 63.42,50.54 63.03,50.15 62.59,50.15 62.52,50.22 62.52,50.87 62.61,50.97 63.44,50.97 63.55,51.09 64.82,51.09 64.93,50.98 66.02,50.98 66.11,50.89 66.11,49.3 66.01,49.2
GND on BOTTOM: 53.29,52.9 52.96,53.23 52.96,55.36 53.13,55.52 53.9,55.52 54.06,55.37 55.35,55.37 55.38,55.33 55.86,54.86 55.86,54.47 56.63,53.7 56.63,53.02 56.52,52.9
GND on BOTTOM: 29.07,48.29 28.06,48.29 27.73,48.62 25.69,48.62 25.05,49.27 24.43,49.27 24.39,49.31 24.39,50.16 24.97,50.75 26.62,50.75 26.69,50.72 26.72,50.64 27.11,50.26 27.49,50.64 27.52,50.72 27.59,50.75 31.73,50.75 31.81,50.7 31.83,50.61 32.19,50.12 32.56,50.61 32.57,50.7 32.65,50.75 34.84,50.75 35.03,50.93 35.03,51.66 35.32,51.95 35.91,51.95 36.05,52.09 36.05,53.84 36.21,54.01 36.63,54.01 36.63,54.02 36.89,54.28 36.89,54.78 37.14,55.04 37.65,55.04 37.9,54.78 37.9,53.97 37.95,53.92 37.95,49.09 37.8,48.94 36.2,48.94 36.14,49.01 36.12,49.04 36.06,49.15 35.96,49.24 35.83,49.31 35.68,49.34 35.5,49.34 35.35,49.31 35.21,49.24 35.12,49.15 35.05,49.04 35.04,49.01 34.58,49.01 34.49,49.12 34.37,49.2 33.98,49.19 33.8,48.86 33.8,48.84 33.66,48.7 33,48.7 33,48.71 32.24,48.71 32.24,48.7 32.09,48.7 32.09,48.71 31.33,48.71 31.33,48.7 30.5,48.7 30.38,48.59 30.38,48.1 30.2,47.93 29.44,47.93
GND on BOTTOM: 58.52,55.14 57.83,55.14 57.52,55.44 56.95,55.44 56.42,55.98 56.42,57.17 55.73,57.86 55.73,58.72 55.78,58.77 55.96,58.77 56.01,58.72 56.01,57.93 57.14,56.81 57.14,56.43 57.21,56.36 57.56,56.36 57.61,56.31 57.61,56.1 58.06,55.65 58.53,55.65 58.55,55.63 58.55,55.18
GND on BOTTOM: 91.75,84.37 90.16,84.37 90.03,84.25 90.03,83.93 89.65,83.55 89.15,83.55 88.7,83.99 88.19,83.99 88.13,83.93 88.13,83.42 88.19,83.36 88.8,83.36 88.93,83.23 88.93,82.39 89.08,82.24 90.1,82.24 90.3,82.04 90.3,81.78 90.43,81.66 91.19,81.66 91.32,81.78 92.05,81.78 92.18,81.91 92.18,82.77 91.88,83.08 91.88,84.25
GND on BOTTOM: 81.46,53.32 81.4,53.39 81.4,54.53 81.4,54.53 81.4,54.91 81.4,54.91 81.4,55.23 81.77,55.6 81.77,57.6 82.05,57.88 82.05,58.27 82.05,58.27 82.05,58.82 82.03,58.85 82.03,59.19 82.03,59.19 82.03,60.29 82.12,60.38 83.71,60.38 83.75,60.35 83.75,59.23 82.61,59.23 82.41,59.04 82.41,58.31 82.41,58.31 82.41,56.75 82.67,56.49 82.67,56.16 83.05,55.77 83.05,55.06 83.05,55.06 83.05,54.54 83.05,54.54 83.05,53.39 82.99,53.32
GND on BOTTOM: 92.43,87.68 90.73,87.68 90.54,87.87 90.54,89.2 90.67,89.33 92.51,89.33 92.64,89.2 92.64,87.88
GND on BOTTOM: 66.37,48.32 66.32,48.37 66.32,49.03 66.27,49.08 66.27,51.01 66.42,51.16 66.42,54.21 66.22,54.4 66.22,56.43 66.48,56.69 68.82,56.69 69.29,56.21 69.29,53.92 68.52,53.15 68.52,52.68 68.53,52.67 68.53,49.36 68.48,49.31 67.32,49.31 67.28,49.35 67.28,49.91 67.26,49.93 66.66,49.93 66.65,49.92 66.65,48.39 66.58,48.32
GND on BOTTOM: 88.45,87.55 88.32,87.55 88.19,87.42 88.19,86.66 88.07,86.53 86.86,86.53 86.73,86.41 86.73,85.64 86.86,85.52 88.32,85.52 88.57,85.77 88.57,87.42
GND on BOTTOM: 76.84,66.07 76.7,66.21 76.7,66.59 76.26,67.04 76.26,69.29 75.62,69.92 75.62,74.26 75.62,74.26 75.62,74.75 75.54,74.83 75.54,75.92 75.5,75.96 75.5,77.96 75.49,77.96 75.62,78.09 75.62,84.23 75.61,84.24 75.61,86.26 75.81,86.45 78.55,86.45 78.91,86.09 78.91,85.74 78.91,85.74 78.91,84.13 78.92,84.12 78.92,83.63 78.36,83.07 78.36,81.45 77.87,80.95 77.87,80.08 77.72,79.93 77.72,76.23 77.69,76.21 77.38,76.21 77.38,76.21 76.57,76.21 76.54,76.24 76.54,76.71 76.49,76.76 75.89,76.76 75.87,76.73 75.87,75.21 76.37,74.7 77.61,74.7 77.65,74.66 77.65,66.21 77.51,66.07
GND on BOTTOM: 54.67,78.41 53.9,78.41 53.78,78.28 53.78,77.01 53.65,76.88 53.4,76.88 53.14,76.63 53.14,73.71 53.65,73.2 57.33,73.2 57.71,73.58 57.71,77.26 57.59,77.39 56.82,77.39 56.57,77.14 56.57,75.48 56.44,75.36 55.55,75.36 55.3,75.61 55.3,76.75 55.05,77.01 55.05,78.02
GND on GND1, GND2: outline of 342 points within 0.2,0.2 300.9,112.9
GND on GND1, GND2, GND3: 299.6,87.8 299.43,87.78 299.27,87.72 299.27,87.8 278.46,87.8 276.28,89.98 276.28,96.1 300.1,96.1 300.66,95.86 300.9,95.3 300.9,88.6 300.66,88.04 300.1,87.8
GND on IN1: 78.82,71.26 78.82,77.8 79.48,78.46 79.48,83.63 79.07,84.04 76.42,84.04 75.52,83.14 75.52,71.24 75.76,71.01 78.57,71.01
GND on IN1: 83.73,60.94 83.73,62.18 83.14,62.78 79.62,62.78 78.23,61.38 76.06,61.38 75.58,60.89 74.68,60.89 73.83,60.04 73.83,54.92 74.13,54.62 75.96,54.62 76.9,55.56 76.9,56.47 79.75,59.32 79.75,60.13 80.43,60.81 83.6,60.81
GND on IN1: 65.67,46.96 60,46.96 59.21,47.75 59.21,53.83 59.26,53.91 59.35,53.92 59.87,54.28 59.35,54.63 59.26,54.64 59.21,54.73 59.21,58.39 61.19,60.37 66.94,60.37 68.01,59.3 68.01,57.52 69.09,56.44 69.09,47.31 68.24,46.46 66.17,46.46 ; 1 cut-out
GND on IN1: 82.44,59.24 83.59,59.24 83.72,59.37 83.72,60.39 83.64,60.46 82.42,60.46 82.29,60.33 82.29,59.39
GND on IN1: 55.43,62.15 55.43,62.34 55.3,62.47 55.3,64.63 55.43,64.75 57.52,64.75 57.65,64.63 57.65,63.86 55.81,62.02 55.55,62.02
GND on IN1: 64.27,50.57 63.4,50.57 63.33,50.64 63.33,50.94 63.43,51.05 65.97,51.05 66.18,50.84 66.18,49.32 66.12,49.27 64.53,49.27 64.41,49.39 64.41,50.44
GND on IN1, IN2: 74.97,76.39 74.97,77.7 74.6,78.08 72.2,78.08 72.04,77.91 72.04,77.38 73.16,76.26 74.84,76.26
GND on IN2: 63.33,51.08 65.79,51.08 66.18,50.69 66.18,49.73 66.1,49.65 64.26,49.65 64.1,49.8 64.1,50.35 63.89,50.56 63.37,50.56 63.27,50.66 63.27,51.02
GND on IN2: 20.32,35.78 21.65,37.11 30.61,37.11 30.62,37.09 31.04,37.51 34.09,37.51 34.35,37.26 34.35,37.21 34.42,37.13 34.42,29.23 33.71,28.52 33.71,20.98 32.62,19.89 28.6,19.89 27.7,20.79 27.7,23.43 26.35,24.77 22.46,24.77 22.3,24.93 22.3,27.43 21.72,28.01 21.53,28.01 20.32,29.22
GND on IN2: 75.7,77.16 76.58,77.16 79.22,79.8 79.22,83.51 78.72,84 76.05,84 75.61,83.56 75.6,83.56 75.6,77.26
GND on IN2: 60.41,55.14 59.9,55.65 59.9,58.04 60.84,58.97 66.54,58.97 67.11,58.4 67.11,57.83 69.21,55.74 69.21,53.58 68.64,53.01 68.64,50.28 68.13,49.77 66.51,49.77 66.35,49.92 66.35,50.77 65.91,51.21 60.63,51.21 60.41,51.44
GND on IN2: 81.73,60.51 83.35,60.51 83.72,60.15 83.72,59.55 83.51,59.34 81.73,59.34 81.65,59.42 81.65,60.43
GND on IN2: 74.34,60.93 75.54,60.93 77.35,62.74 82.48,62.74 82.68,62.54 82.68,61.12 82.48,60.92 79.89,60.92 78.45,59.48 75.13,59.48 74.81,59.17 74.45,59.17 74.29,59.32 74.29,60.88
GND on IN3: 66.86,60.88 66.86,57.9 68.38,56.37 68.57,56.37 69.24,55.7 69.24,47.64 68.13,46.53 66.51,46.53 66.38,46.66 66.38,53.8 65.75,54.43 60.84,54.43 59.49,55.77 59.49,58.95 60.74,60.19 60.74,61.51 60.05,62.2 60.05,62.84 60.38,63.17 63.17,63.17 63.94,62.4 64.7,62.4 65.46,61.64 66.1,61.64
GND on IN3: 81.73,59.34 83.5,59.34 83.71,59.55 83.71,60.12 83.34,60.49 81.84,60.49 81.69,60.35 81.69,59.39
GND on IN3: 64.84,50.96 66,50.96 66.11,50.85 66.11,49.28 66.04,49.2 65.09,49.2 64.77,49.52 64.77,50.89
GND on IN3: 78.41,83.99 75.87,83.99 75.49,83.61 75.49,77.21 75.94,76.75 78.8,76.75 79.05,77.01 79.05,83.6 78.66,83.99 78.42,83.99
GND on IN3: 20.12,32.18 20.76,32.81 22.79,32.81 22.79,32.82 27.23,32.82 27.74,33.33 27.74,37.1 28.25,37.61 33.1,37.61 33.41,37.31 33.41,25.29 33.15,25.04 27.92,25.04 27.54,24.67 22.34,24.67 20.12,26.89
GND on VCC: 299.41,87.78 299.27,87.72 299.27,87.8 278.46,87.8 276.28,89.98 276.28,95.48 276.29,95.49 276.28,95.97 276.28,95.97 276.28,96.1 300.1,96.1 300.66,95.86 300.9,95.3 300.9,88.6 300.66,88.04 300.1,87.8 299.6,87.8
GND on VCC: 45.52,8.9 45.52,24.58 46.13,25.19 55.66,25.19 77.38,46.91 78.9,46.91 80.7,48.71 80.7,52.9 88.55,60.75 94.78,60.75 94.9,60.88 104.09,60.88 105.21,59.76 105.21,58.49 105.99,57.7 112.3,57.7 112.4,57.7 112.4,57.7 113.61,57.7 114.07,57.25 128.93,57.25 130.41,57.24 130.51,57.24 130.97,56.78 130.97,54.14 132.44,52.67 132.87,52.67 133.42,52.12 133.68,52.12 134.19,51.61 136.43,51.61 136.94,52.12 140.67,52.12 141.05,51.74 141.55,51.74 142.19,51.1 142.7,51.1 143.46,50.34 144.98,50.34 148.29,47.04 151.16,47.04 151.8,47.67 153.24,47.67 153.62,47.29 157.64,47.29 158.02,47.67 168.61,47.67 169.75,46.53 174.7,46.53 186.89,34.34 188.16,34.34 194.75,27.75 194.75,25.09 197.03,22.8 197.03,9.57 197,9.54 197,9.06 197.03,9.02 197.03,8.9
GND on VCC: outline of 88 points within 0.2,8.9 23.68,83.6
GND on IN4: 74.51,77.55 75.13,77.55 75.23,77.46 75.23,76.24 75.14,76.15 74.49,76.15 74.42,76.22 74.42,77.46
GND on IN4: 79.12,62.89 84.07,62.89 84.46,62.5 84.46,60.57 84.38,60.5 82.39,60.5 82.22,60.33 82.22,57.81 80.33,55.93 77.25,55.93 75.92,54.61 74.25,54.61 74.24,54.61 73.97,54.61 73.69,54.9 73.69,57.17 73.76,57.24 79.87,57.24 81.49,58.86 81.49,60.26 81.23,60.52 80.11,60.52 79.94,60.35 78.02,60.35 77.78,60.11 76.37,60.11 76.17,60.31 76.17,61.19 76.31,61.32 77.55,61.32
GND on IN4: 169.73,47.81 168.79,48.75 168.79,51.77 169.11,52.1 173.47,52.1 173.74,52.37 176.1,52.37 177.19,51.28 177.19,49.76 175.84,48.41 174.29,48.41 173.69,47.81
GND on IN4: 75.69,84.17 78.55,84.17 78.8,83.92 78.8,83.43 78.34,82.97 78.34,81.34 77.8,80.79 77.8,76.55 77.77,76.51 75.69,76.51 75.52,76.69 75.52,83.99
GND on IN4: 83.92,60.24 82.55,60.24 82.38,60.08 82.38,59.3 82.53,59.16 83.79,59.16 84.01,59.37 84.01,60.16
GND on GND3: outline of 346 points within 0.2,0.2 300.9,112.9
GNDA on TOP (solid shape): 300.9,12.73 300.9,12.15 300.66,11.59 300.1,11.35 296.93,11.35 296.93,11.81 296.94,11.81 296.94,12.67 298.03,13.76 300.9,13.76
GNDA on TOP (solid shape): 287.07,12.47 287.16,12.42 287.16,12.31 287.07,12.05 287.11,11.78 287.18,11.64 287.28,11.53 287.31,11.42 287.22,11.35 287.2,11.35 286.51,10.77 286.96,9.99 287,9.98 287,4.52 286.96,4.51 286.51,3.73 287.2,3.15 289.97,3.15 290.06,3.08 290.04,2.97 289.86,2.28 290.44,1.88 291.26,1.88 291.48,1.92 291.67,2.03 292.78,2.03 292.97,1.92 293.19,1.88 294.01,1.88 294.23,1.92 294.43,2.04 294.61,2.35 294.59,2.71 294.59,2.72 294.52,2.86 294.42,2.97 294.39,3.08 294.48,3.15 300.1,3.15 300.66,2.91 300.9,2.35 300.9,1 300.66,0.44 300.1,0.2 278.36,0.2 278.21,0.35 278.21,1.83 278.47,2.09 282.49,2.09 282.95,2.54 284.57,2.54 285.27,3.25 285.22,4.27 285.68,5.18 285.68,9.32 285.39,9.75 285.22,10.24 285.38,11.54 286.31,12.47
GNDA on BOTTOM (solid shape): 276.81,21.46 276.81,20.52 273.84,20.52 273.64,20.32 273.64,19.27 273.16,18.79 271.78,18.79 271.66,18.92 271.66,19.6 273.56,21.51 276.76,21.51
GNDA on BOTTOM (solid shape): outline of 467 points within 282.6,0.2 300.9,13.76
GNDA on IN1 (solid shape): 300.9,13.56 300.9,12.15 300.66,11.59 300.1,11.35 296.78,11.35 296.69,11.42 296.72,11.53 296.82,11.65 296.89,11.79 296.9,12.17 296.69,12.49 296.68,12.5 296.5,12.59 296.31,12.62 295.49,12.62 294.91,12.22 295.11,11.42 295.02,11.35 294.18,11.35 294.09,11.42 294.29,12.22 293.71,12.62 292.89,12.62 292.31,12.22 292.51,11.42 292.42,11.35 288.95,11.35 288.88,11.43 288.91,11.53 289.09,12.22 288.51,12.62 287.69,12.62 287.11,12.22 287.31,11.42 287.22,11.35 287.2,11.35 286.51,10.77 286.96,9.99 287,9.98 287,4.52 286.96,4.51 286.51,3.73 287.2,3.15 289.97,3.15 290.06,3.08 289.86,2.28 290.44,1.88 291.26,1.88 291.84,2.28 291.64,3.08 291.73,3.15 292.72,3.15 292.81,3.08 292.61,2.28 293.19,1.88 294.01,1.88 294.59,2.28 294.39,3.08 294.48,3.15 300.1,3.15 300.66,2.91 300.9,2.35 300.9,1 300.66,0.44 300.1,0.2 278.26,0.2 278.19,0.28 278.19,1.32 279.91,3.04 284.84,3.04 285.22,3.43 285.19,4.03 285.33,4.62 285.33,6.47 284.28,7.51 284.28,12.57 285.47,13.76 300.69,13.76
GNDA on IN2 (solid shape): 300.59,12.15 300.45,11.8 300.1,11.66 297.14,11.66 296.96,11.83 296.96,12.51 296.96,12.51 296.96,13.34 297.39,13.76 300.59,13.76
GNDA on IN2 (solid shape): 300.1,3.15 300.66,2.91 300.9,2.35 300.9,1 300.66,0.44 300.1,0.2 278.19,0.2 278.19,1.52 284.76,1.52 285.13,1.15 293,1.15 293.37,1.52 294.39,1.52 294.72,1.85 294.72,3.15
GNDA on IN2 (solid shape): 286.67,11.2 286.67,11.11 286.52,10.47 286.96,9.99 287,9.98 287,4.52 286.96,4.51 286.51,3.73 287.2,3.15 289.72,3.15 289.72,2.14 286.62,2.14 285.61,3.16 285.3,3.16 285.2,3.53 285.18,3.91 285.18,10.6 286.03,11.45 286.41,11.45
GNDA on IN3 (solid shape): outline of 932 points within 278.19,0.2 300.9,13.76
GNDA on GND1, GND2: 278.19,0.2 278.19,10.44 276.92,11.71 276.92,12.73 276.03,13.61 276.03,13.74 275.96,13.8 275.96,14.22 275.47,14.72 272.01,14.72 271.76,14.46 271.62,14.46 271.56,14.52 271.35,14.52 270.97,14.14 269.57,14.14 269.19,13.76 264.96,13.76 264.85,13.87 264.85,14.17 265.08,14.4 265.59,14.4 265.87,14.67 265.87,15.65 265.59,15.92 265.49,15.92 265.49,17.46 265.55,17.53 265.63,17.45 267.11,17.45 267.64,17.98 267.64,22.25 267.24,22.65 266.65,22.65 266.52,22.53 266.05,22.53 265.87,22.71 265.87,23.87 266.81,24.81 266.99,24.81 268.38,26.21 273.08,26.21 273.34,26.46 274.4,26.46 275.26,25.6 275.26,22.55 275.79,22.02 276.68,22.02 277.04,21.66 277.04,15.05 278.71,13.38 284.89,13.38 285.28,13.76 300.9,13.76 300.9,12.15 300.66,11.59 300.1,11.35 287.2,11.35 286.5,10.75 287,9.98 287,4.52 286.5,3.75 287.2,3.15 300.1,3.15 300.66,2.91 300.9,2.35 300.9,1 300.66,0.44 300.1,0.2
GNDA on VCC: 278.23,0.2 278.37,0.34 278.37,0.83 278.19,1.01 278.19,10.44 276.92,11.71 276.92,12.73 276.03,13.61 276.03,13.74 275.96,13.8 275.96,14.22 275.47,14.72 272.01,14.72 271.76,14.46 271.62,14.46 271.56,14.52 271.35,14.52 270.97,14.14 269.57,14.14 269.19,13.76 264.96,13.76 264.85,13.87 264.85,14.17 265.08,14.4 265.59,14.4 265.87,14.67 265.87,15.65 265.59,15.92 265.49,15.92 265.49,17.46 265.55,17.53 265.63,17.45 267.11,17.45 267.64,17.98 267.64,22.25 267.24,22.65 266.65,22.65 266.52,22.53 266.05,22.53 265.87,22.71 265.87,23.87 266.81,24.81 266.99,24.81 268.38,26.21 273.08,26.21 273.34,26.46 274.4,26.46 275.26,25.6 275.26,22.55 275.79,22.02 276.68,22.02 277.04,21.66 277.04,15.05 278.71,13.38 284.89,13.38 285.28,13.76 300.9,13.76 300.9,12.15 300.66,11.59 300.1,11.35 287.2,11.35 287.16,11.35 286.5,10.73 287,9.98 287,4.52 286.5,3.77 287.2,3.15 300.1,3.15 300.66,2.91 300.9,2.35 300.9,1 300.66,0.44 300.1,0.2
GNDA on IN4: outline of 132 points within 279.61,0.2 300.9,13.76
GNDA on GND3: 282.25,0.2 282.25,5.49 281.59,6.14 278.67,6.14 278.19,6.63 278.19,10.44 276.92,11.71 276.92,12.73 276.03,13.61 276.03,13.74 275.96,13.8 275.96,14.22 275.47,14.72 272.01,14.72 271.8,14.51 271.79,14.52 271.35,14.52 270.97,14.14 269.57,14.14 269.19,13.76 264.96,13.76 264.85,13.87 264.85,14.17 265.08,14.4 265.59,14.4 265.87,14.67 265.87,15.65 265.59,15.92 265.49,15.92 265.49,17.46 265.55,17.53 265.63,17.45 267.11,17.45 267.64,17.98 267.64,22.25 267.24,22.65 266.65,22.65 266.52,22.53 266.05,22.53 265.87,22.71 265.87,23.87 266.81,24.81 266.99,24.81 268.38,26.21 273.08,26.21 273.34,26.46 274.4,26.46 275.26,25.6 275.26,22.55 275.79,22.02 276.68,22.02 277.04,21.66 277.04,15.05 278.71,13.38 284.89,13.38 285.28,13.76 300.9,13.76 300.9,12.15 300.66,11.59 300.1,11.35 287.2,11.35 286.5,10.75 287,9.98 287,4.52 286.5,3.75 287.2,3.15 300.1,3.15 300.66,2.91 300.9,2.35 300.9,1 300.66,0.44 300.1,0.2
VBAT1_ISL9538 on BOTTOM (solid shape): 32.87,47.33 32.87,47.08 32.51,46.73 32.46,46.68 32.37,46.68 32.16,46.47 32.16,45.69 32.1,45.63 32.01,45.63 31.95,45.7 31.95,46.7 32.2,46.96 32.31,47.02 32.37,47.13 32.39,47.15 32.39,47.26 32.43,47.33 32.44,47.42 32.44,47.45 32.75,47.45
VCCSA_B+ on TOP: 90.1,89.33 88.19,89.33 87.94,89.07 87.94,88.44 88.45,88.44 88.45,87.93 87.94,87.93 87.94,87.55 88.32,87.17 90.1,87.17 90.35,87.42 90.35,89.07
VCCSA_B+ on BOTTOM: 90.1,89.33 89.08,89.33 88.83,89.07 88.83,87.55 89.08,87.3 89.84,87.3 89.97,87.17 89.97,86.66 89.84,86.53 89.34,86.53 89.21,86.41 89.21,86.03 89.34,85.9 91.88,85.9 92,86.03 92,86.91 91.75,87.17 91.01,87.17 90.35,87.83 90.35,89.07
VDDP_ISL9538 on BOTTOM (solid shape): 33.66,42.58 33.66,42.38 33.78,42.26 33.83,42.2 33.9,42.15 34.55,41.49 34.55,40.09 34.47,40.01 33.53,40.01 33.47,40.08 33.47,41.74 33.16,42.04 33.16,42.39 33.08,42.47 32.75,42.47 32.65,42.57 32.65,42.67 32.73,42.75 33.49,42.75
VIN_1.8VALW on BOTTOM (solid shape): 178.63,109.19 178.63,108.25 178.5,108.12 177.47,108.12 176.99,107.64 175.95,107.64 175.75,107.84 175.75,108.25 175.76,108.26 175.76,108.57 176.08,108.89 176.08,110.03 176.2,110.16 177.67,110.16
VIN_1V_PRIM on TOP (solid shape): 177.48,100.32 177.48,98.59 177.3,98.41 175.67,98.41 175.44,98.64 175.44,100.26 175.69,100.52 177.28,100.52
VIN_1V_PRIM on BOTTOM (solid shape): 176.28,100.63 178.11,100.63 178.39,100.35 178.39,98.95 177.88,98.44 175.58,98.44 175.57,98.45 175.21,98.45 174.93,98.73 173.89,98.73 173.82,98.8 173.82,99.92 173.92,100.02 175.06,100.02 175.7,100.66 176.1,100.66 176.1,101.22 176.28,101.22
VIN_1VS_VCCIO on TOP (solid shape): 181.65,50.66 181.65,48.95 181.59,48.89 179.05,48.89 178.87,49.07 178.87,50.59 179.1,50.82 181.49,50.82
VIN_1VS_VCCIO on BOTTOM (solid shape): 180.09,51.02 181.08,51.02 181.31,50.8 181.31,49.78 180.44,48.91 176.72,48.91 176.31,49.32 176.31,50.75 176.41,50.85 177.93,50.85 178.12,51.04 180.08,51.04
+AC_IN on TOP (solid shape): 41.91,72.59 41.91,69.62 41.73,69.44 40.24,69.44 39.98,69.7 39.98,71.08 40.26,71.37 40.26,71.43 40.3,71.47 40.39,71.47 41,72.08 41,72.59 41.1,72.69 41.81,72.69
+AC_IN on TOP (solid shape): 40.31,65.15 40.31,64.68 40.5,64.49 42.82,64.49 44.4,62.91 48.44,62.91 48.59,62.76 48.59,60.98 48.49,60.88 47.1,60.88 46.68,61.31 46.05,61.31 46.02,61.34 46.02,61.83 45.32,61.83 45.32,61.34 44.82,61.34 44.82,61.83 44.12,61.83 44.12,61.34 43.26,61.34 41.99,62.61 40.08,62.61 39.96,62.73 39.96,63.34 39.63,63.67 39.63,65.15 39.7,65.22 40.24,65.22
+BL_PWR_SRC on TOP: 68.76,98.95 68.97,99.16 69.84,99.16 70.86,100.18 72.1,100.18 72.3,99.98 72.3,99.3 71.78,99.3 71.78,98.8 72.3,98.8 72.3,98.5 71.78,98.5 71.78,98 72.3,98 72.3,97.62 72.59,97.33 76.38,97.33 76.64,97.07 76.64,94.53 76.51,94.41 75.87,94.41 75.75,94.53 75.75,95.42 74.86,96.31 71.94,96.31 71.92,96.33 71.77,96.33 71.55,96.11 69.01,96.11 68.76,96.35
+BL_PWR_SRC on BOTTOM: 69.22,97.71 69.22,98.28 69.46,98.52 71.87,98.52 72.02,98.38 72.02,96.38 71.85,96.21 67.81,96.21 67.73,96.29 67.73,96.75 67.75,96.85 67.73,96.95 67.73,97.4 67.82,97.48 68.99,97.48
+BL_PWR_SRC_P on TOP: 72.49,97.63 72.44,97.67 72.44,99.86 72.75,100.17 73.23,100.17 73.87,100.81 73.87,102.05 73.97,102.15 74.73,102.15 74.99,102.41 74.99,103.22 75.19,103.42 76.13,103.42 76.23,103.33 76.23,101.87 76.25,101.85 76.25,97.85 76.03,97.63
+CHARGER_SRC on TOP (solid shape): 24.44,36.56 24.44,33.57 24.71,33.31 26.46,33.31 26.78,32.99 26.78,32.06 26.71,31.99 25.96,31.99 25.79,31.82 22.64,31.82 22.52,31.94 22.52,32.47 22.15,32.85 19.37,32.85 19.15,33.06 19.15,35.5 20.58,36.93 24.07,36.93
+CHARGER_SRC on BOTTOM (solid shape): 29.55,36.82 29.55,32.26 29.08,31.8 28.43,31.8 28.19,32.04 28.19,34.34 28.09,34.44 27.21,34.44 27.2,34.44 27.06,34.44 26.78,34.16 26.78,33.25 26.76,33.13 26.78,33.01 26.78,32.13 26.66,32.01 26.02,32.01 25.81,31.8 22.53,31.8 22.28,32.05 22.28,32.56 22.03,32.81 19.36,32.81 19.08,33.1 19.08,35.32 20.45,36.7 23.44,36.7 23.44,36.15 25.39,36.15 25.39,36.7 26.07,36.7 26.39,37.02 29.35,37.02
+CHARGER_SRC on IN2 (solid shape): 29.21,36.42 29.21,32.46 29.02,32.27 28.12,32.27 27.79,32.6 21.61,32.6 21.31,32.89 21.31,33.12 26.76,33.12 26.77,33.06 26.78,33.01 26.8,32.96 26.83,32.91 26.87,32.87 26.91,32.83 26.96,32.8 27.01,32.77 27.06,32.76 27.12,32.75 27.17,32.75 27.23,32.76 27.28,32.77 27.33,32.8 27.38,32.83 27.42,32.87 27.46,32.91 27.48,32.96 27.51,33.01 27.52,33.06 27.53,33.12 27.52,33.17 27.51,33.23 27.5,33.28 27.47,33.33 27.44,33.38 27.4,33.42 27.36,33.45 27.31,33.48 27.25,33.5 27.2,33.51 27.14,33.51 27.09,33.51 27.03,33.5 26.98,33.48 26.93,33.45 26.89,33.42 26.85,33.38 26.82,33.33 26.79,33.28 26.77,33.23 26.76,33.17 26.76,33.12 21.31,33.12 21.31,35.95 22.09,36.72 28.91,36.72
+CRT_VCC on TOP (solid shape): 288.34,51.74 288.35,51.74 288.35,50.47 288.22,50.34 287.84,50.34 287.54,50.64 286.85,50.64 286.69,50.67 286.54,50.64 285.85,50.64 285.71,50.5 285.65,50.47 285.38,50.47 285.31,50.4 285.13,50.4 285.07,50.46 285.07,51.27 285.16,51.36 285.3,51.33 285.44,51.36 286.37,51.36 286.4,51.33 287.59,51.33 288.03,51.78 288.3,51.78
+CRT_VCC on BOTTOM (solid shape): 290.15,42.48 290.15,41.5 289.97,41.31 287.82,41.31 287.64,41.49 287.64,42.06 287.69,42.17 287.71,42.3 287.69,42.42 287.64,42.54 287.64,42.59 287.86,42.82 289.82,42.82
+CRT_VCC on BOTTOM (solid shape): 294.24,51.43 294.24,50.63 294.13,50.52 292.04,50.52 290.88,49.36 288.91,49.36 288.65,49.61 288.65,50.41 288.75,50.51 289.68,50.51 289.87,50.47 290.06,50.51 290.52,50.51 291.56,51.55 294.13,51.55
+CRT_VCC on IN4 (solid shape): outline of 499 points within 286.18,41.36 291.21,53.48
+DC_IN on TOP (solid shape): 54.84,80.58 54.84,79.05 54.7,78.91 54.41,78.91 54.28,79.04 54.28,80.53 54.47,80.72 54.7,80.72
+DC_IN on TOP (solid shape): 54.64,95.64 54.64,94.4 55.02,94.02 55.02,92.28 54.7,91.95 53.9,91.95 52.5,90.55 50.62,90.55 50.47,90.71 50.47,91.48 51.21,92.22 51.21,93.39 51.87,93.39 51.87,93.34 51.89,93.28 51.91,93.23 51.93,93.18 51.97,93.14 52.01,93.1 52.05,93.07 52.1,93.04 52.16,93.02 52.21,93.01 52.27,93.01 52.32,93.02 52.38,93.03 52.43,93.05 52.47,93.08 52.52,93.12 52.55,93.16 52.59,93.21 52.61,93.26 52.62,93.31 52.63,93.36 52.63,93.42 52.62,93.48 52.61,93.53 52.59,93.58 52.55,93.63 52.52,93.67 52.47,93.7 52.43,93.73 52.38,93.75 52.32,93.77 52.27,93.77 52.21,93.77 52.16,93.76 52.1,93.74 52.05,93.72 52.01,93.69 51.97,93.65 51.93,93.6 51.91,93.55 51.89,93.5 51.87,93.45 51.87,93.39 51.21,93.39 51.21,94.01 51.56,94.36 51.56,95.29 51.81,95.55 53.13,95.55 53.49,95.91 54.36,95.91
+DC_IN on BOTTOM (solid shape): 51.81,93.96 51.81,93.24 51.39,92.81 51.39,92.26 51.14,92 50.2,92 50.05,92.15 50.05,94 50.17,94.12 51.65,94.12
+DC_IN on BOTTOM (solid shape): 55.08,80.53 55.02,80.23 55.21,79.98 55.21,78.74 55.02,78.56 53.65,78.56 53.5,78.41 53.5,77.44 53.04,76.98 52.58,76.98 52.33,77.24 52.31,77.37 52.25,77.49 52.25,78.1 52.68,78.53 52.68,79.12 54.25,80.69 54.92,80.69
+DC_IN on IN3 (solid shape): 51.84,94.01 51.84,92.55 51.69,92.41 51.18,92.41 51.02,92.56 51.02,93.95 51.17,94.1 51.75,94.1
+DC_IN on IN3 (solid shape): 55.03,80.77 55.03,80.44 55.01,80.31 55.03,80.18 55.03,79.78 54.8,79.55 54.41,79.55 54.16,79.8 54.16,80.74 54.32,80.9 54.91,80.9
+DC_IN on TOP: 58.98,96.82 57.08,96.82 56.82,96.57 56.82,94.66 56.95,94.53 58.98,94.53 59.24,94.79 59.24,96.57
+DC_IN on IN1: 58.6,96.82 52.89,96.82 50.73,94.66 50.73,93.52 51.36,92.88 58.22,92.88 58.86,93.52 58.86,96.57
+DC_IN_SS on TOP (solid shape): 57.94,92.12 58.46,92.12 58.74,91.83 58.74,90.31 57.84,89.41 53.41,89.41 52.99,88.99 52.99,87.58 51.86,86.45 51.86,84.41 51.75,84.3 49.52,84.3 49.34,84.48 49.34,87.72 49.09,87.97 49.15,88.06 49.26,88.05 49.89,88.34 49.26,88.62 49.15,88.61 49.09,88.7 49.09,89.86 49.44,90.2 52.38,90.2 53.31,91.13 55.29,91.13 55.3,91.13 55.59,91.14 55.79,91.36 55.79,91.37 55.94,91.51 55.94,92.52 56.01,92.59 57.46,92.59
+DCIN_JACK on TOP (solid shape): 50.04,95.14 50.04,94.7 50.09,94.65 50.59,94.15 50.89,94.15 50.96,94.09 50.96,92.31 50.68,92.04 48.95,92.04 48.82,91.91 48.82,90.22 48.32,89.71 42.73,89.71 42.05,90.38 42.05,92.34 41.03,93.37 40.36,93.37 40.09,93.09 40.09,92.22 40.64,91.66 40.64,90.55 40.16,90.06 38.89,90.06 37.98,90.98 37.98,94.99 39.25,96.26 48.92,96.26
+DCIN_JACK on BOTTOM (solid shape): 48.82,94.26 48.82,90.17 48.36,89.7 48.33,89.69 48.28,89.67 48.23,89.65 48.19,89.62 48.15,89.58 48.12,89.54 48.1,89.49 48.08,89.44 48.07,89.41 48.01,89.35 39.02,89.35 38.16,90.22 38.16,93.06 40.06,93.06 40.06,92.6 40.42,92.25 41.89,92.25 41.89,92.25 48.15,92.25 48.15,93.35 41.63,93.35 41.61,93.37 40.36,93.37 40.06,93.06 38.16,93.06 38.16,94.2 39.02,95.07 48.01,95.07
+EDP_VDD on TOP (solid shape): 73.25,86.74 73.25,85.68 72.76,85.18 72.76,84.97 72.48,84.69 70.29,84.69 70.01,84.98 70.01,86.19 69.45,86.19 69.45,86.37 69.98,86.37 69.98,86.87 70.22,87.11 72.88,87.11
+LCDVDD on TOP (solid shape): 69.27,92.51 69.27,91.61 69.14,91.49 68.87,91.49 68.76,91.37 68.76,89.1 68.91,88.95 70.41,88.95 70.55,88.81 70.55,87.76 69.86,87.07 69.86,86.52 69.32,86.52 69.32,86.06 69.88,86.06 69.88,85.39 69.88,85.39 69.88,84.18 69.84,84.15 69.01,84.15 67.78,85.37 67.78,88.57 66.22,90.13 66.22,90.98 66.48,91.23 67.49,91.23 68,91.74 68.41,91.74 68.66,91.99 68.66,92.51 68.75,92.6 69.18,92.6
+LCDVDD on BOTTOM (solid shape): 67.62,90.98 68.89,90.98 69.02,90.85 69.02,90.22 67.62,90.22 67.37,89.96 66.48,89.96 66.22,90.22 66.22,90.98 66.35,91.11 67.49,91.11
+PBATT on TOP (solid shape): 40.57,22.23 40.57,21.26 40.82,21 44.96,21 45.27,20.7 45.27,17.78 44.68,17.19 43.18,17.19 41.13,15.13 38.76,15.13 38.16,15.74 38.16,18.04 37.65,18.55 37.65,22.4 37.77,22.53 40.27,22.53
+PWR_SRC on TOP (solid shape): 60.57,51.1 62.6,51.1 62.6,51.61 63.11,51.61 63.17,51.55 63.17,46.4 62.98,46.2 62.01,46.2 61.82,46.01 60.58,46.01 59.17,47.41 59.17,50.97 59.81,51.61 60.57,51.61
+PWR_SRC on TOP (solid shape): 48.19,43.99 49.71,43.99 50.09,43.61 50.09,40.18 49.84,39.92 47.05,39.92 46.79,40.18 46.79,41.16 46.28,41.16 46.28,41.41 46.79,41.41 46.79,41.96 46.28,41.96 46.28,42.21 46.79,42.21 46.79,43.1 46.92,43.23 46.92,44.12 47.17,44.37 47.81,44.37
+PWR_SRC on TOP (solid shape): 180.1,111.21 180.1,109.97 180.12,109.96 180.12,109.74 180.13,109.62 180.16,109.51 180.6,108.62 181.4,108.02 181.4,100.94 182.2,96.6 182.2,94.64 181.21,93.65 179,93.65 178.9,93.75 178.9,109.01 177.58,110.33 170.92,110.33 169.09,108.5 165.16,108.5 164.9,108.25 164.47,108.25 164.34,108.31 164.19,108.33 164.13,108.39 164.13,109 163.15,109.98 159.07,109.98 158.63,109.54 158.63,108.66 158.38,108.41 157.2,108.41 157.05,108.56 157.05,109.37 156.5,109.37 156.5,109.66 157.05,109.66 157.05,110.17 156.5,110.17 156.5,110.46 157.05,110.46 157.05,111.19 157.25,111.39 163.62,111.39 164.12,110.88 164.13,110.87 164.91,109.84 166.15,109.45 167.65,109.45 168.9,109.85 169.68,110.9 170.23,111.45 179.86,111.45
+PWR_SRC on BOTTOM (solid shape): 29.62,31.3 29.62,26.86 29.47,26.72 28.42,26.72 28.34,26.79 28.34,28.78 28.28,28.83 27.46,28.83 26.99,28.36 26.99,28.3 26.61,27.92 26.61,27.74 26.34,27.47 23.66,27.47 23.5,27.3 23.5,26.38 23.38,26.26 22.74,26.26 22.47,25.98 22.07,25.98 22.06,25.98 20.43,25.98 20.34,26.07 20.34,29.21 20.34,29.22 20.34,29.34 20.82,29.82 22.72,29.82 22.86,29.96 26.31,29.96 27.76,31.41 29.51,31.41
+PWR_SRC on BOTTOM (solid shape): 58.98,101.37 58.98,98.6 56.64,96.25 50.24,96.25 49.98,96.51 49.98,97.13 52.34,97.13 52.34,97.07 52.36,97.02 52.38,96.96 52.4,96.92 52.44,96.87 52.48,96.83 52.52,96.8 52.57,96.77 52.63,96.76 52.68,96.75 52.74,96.74 52.79,96.75 52.85,96.76 52.9,96.79 52.94,96.82 52.99,96.85 53.02,96.89 53.06,96.94 53.08,96.99 53.09,97.04 53.1,97.1 53.1,97.15 53.09,97.21 53.08,97.26 53.06,97.31 53.02,97.36 52.99,97.4 52.94,97.44 52.9,97.47 52.85,97.49 52.79,97.5 52.74,97.51 52.68,97.51 52.63,97.5 52.57,97.48 52.52,97.45 52.48,97.42 52.44,97.38 52.4,97.34 52.38,97.29 52.36,97.24 52.34,97.18 52.34,97.13 49.98,97.13 49.98,97.93 50.32,98.27 54.18,98.27 56.21,100.3 56.21,100.76 57,101.55 58.81,101.55
+PWR_SRC on BOTTOM (solid shape): outline of 4074 points within 47.55,26.79 190.74,111.81
+PWR_SRC on IN1 (solid shape): outline of 387 points within 20.43,22.64 36.71,31.31
+PWR_SRC on IN2 (solid shape): outline of 273 points within 156.24,93.8 182.2,111.57
+PWR_SRC on IN3 (solid shape): outline of 271 points within 156.21,93.9 182.2,111.55
+PWR_SRC on IN4 (solid shape): 164.12,111.2 164.12,110.88 164.13,110.87 164.91,109.84 166.15,109.45 167.65,109.45 168.9,109.85 169.68,110.9 170.23,111.45 179.86,111.45 180.1,111.21 180.1,109.97 180.12,109.96 180.12,109.74 180.13,109.62 180.16,109.51 180.6,108.62 181.4,108.02 181.4,100.94 182.2,96.6 182.2,94.26 181.72,93.77 178.87,93.77 178.44,94.2 178.44,107.31 178.81,107.68 178.81,109.1 177.58,110.33 171.3,110.33 169.47,108.5 164.47,108.5 163.12,109.85 160.52,109.85 159.72,109.05 156.65,109.05 156.4,109.3 156.4,111.34 156.8,111.74 163.59,111.74
+PWR_SRC on TOP: 24.44,22.65 23.68,23.41 21.53,23.41 20.44,24.5 20.14,24.8 20.14,25.75 20.44,26.05 20.44,28.87 21.03,29.46 22.76,29.46 23.23,29.93 26.06,29.93 26.06,29.92 28.28,29.92 28.83,30.48 32.12,30.48 32.47,30.13 32.47,28.85 32.95,28.37 35.49,28.37 36.89,26.97 36.89,26.35 36.88,26.34 36.89,26.33 36.89,24.3 36.85,24.27 35.37,24.27 35.17,24.07 35.17,22.78 35.17,22.65
+PWR_SRC on TOP: 76.75,100.24 76.58,100.41 76.58,102.56 76.59,102.57 76.59,102.87 76.89,103.17 79.1,103.17 79.48,102.79 79.48,101.32 79.43,101.27 77.77,101.27 77.61,101.12 77.61,100.41 77.44,100.24
+PWR_SRC on TOP: 61.84,56.56 61.84,58.61 62.11,58.87 62.11,59.46 61.57,59.46 61.57,59.69 62.11,59.69 62.11,60.24 61.57,60.24 61.57,60.5 62.11,60.5 62.11,60.98 62.13,61.01 64.06,61.01 64.16,60.91 64.16,60.45 64.34,60.27 65.1,60.27 65.31,60.47 65.31,60.88 65.43,61.01 65.87,61.01 65.94,60.93 65.94,58.36 65.65,58.07 64.24,58.07 62.54,56.37 62.03,56.37
+PWR_SRC on IN1: outline of 133 points within 57.28,93.6 182.2,111.81
+PWR_SRC on IN4: 65.7,41.94 55.39,31.63 55.38,31.63 55.28,31.56 55.21,31.46 55.21,31.45 54.03,30.27 41.13,30.27 34.27,23.41 21.36,23.41 20.12,24.65 20.12,31.23 20.15,31.26 20.15,35.1 21.27,36.22 27.46,36.22 31.04,39.8 31.05,39.8 33.65,42.4 33.74,42.42 33.81,42.35 33.83,42.32 33.82,42.27 33.79,42.25 33.44,41.88 33.77,41.49 33.82,41.49 33.94,41.5 34.05,41.56 34.06,41.56 34.18,41.72 34.2,41.92 34.19,41.97 34.2,42.05 34.27,42.09 34.46,42.2 34.56,42.4 34.56,42.44 34.59,42.51 34.66,42.54 38.11,42.54 38.14,42.5 38.15,42.54 40.24,42.54 40.47,42.46 40.7,42.54 42.73,42.54 42.74,42.55 42.89,42.55 42.9,42.57 44.61,42.57 45.17,43.13 45.17,44.34 45.87,45.05 48.49,45.05 49.64,46.2 57.76,46.2 58.65,47.09 58.65,52.69 58.67,52.77 58.68,52.84 58.67,52.92 58.65,52.99 58.65,56.72 58.69,56.73 58.96,57.09 58.69,57.46 58.65,57.47 58.65,57.64 58.66,57.65 58.66,58.14 59.81,59.29 63.17,59.29 63.49,58.97 63.49,56.31 62.29,55.11 62.29,51.5 63.4,50.39 63.4,47.49 65.7,45.2
+PWR_SRC_AC on BOTTOM (solid shape): 23.33,42.11 23.69,41.75 24.05,42.11 24.05,42.63 24.19,42.62 24.27,42.63 24.67,42.63 24.88,42.41 24.88,40.28 25.07,40.09 26.05,40.09 26.41,39.73 26.41,37.22 26.01,36.83 21.51,36.83 21.14,37.21 21.14,37.79 21.17,37.87 21.26,37.89 21.67,38.07 21.62,38.52 21.61,38.55 21.62,38.59 21.67,39.04 21.26,39.22 21.17,39.24 21.14,39.32 21.14,41.23 21.17,41.24 21.33,41.38 21.39,41.58 21.39,41.6 21.92,42.13 21.94,42.13 22.1,42.17 22.22,42.26 22.34,42.4 22.4,42.58 22.41,42.59 22.44,42.63 23.33,42.63
+PWR_SRC_AC on TOP: 23.4,37.41 25.9,37.41 26.05,37.56 26.05,39.47 25.48,40.04 24.76,40.04 24.47,40.33 23.4,40.33 23.29,40.23 23.29,37.52
+RSVD_VCC3P3_1 on TOP (solid shape): 261.78,69.53 261.78,67.5 261.67,67.39 261.03,67.39 260.93,67.49 260.93,68.77 259.24,70.46 259.24,70.75 259.08,70.9 259.08,71.16 259.15,71.22 260.09,71.22
+RTC_CELL_PCH on IN1 (solid shape): outline of 356 points within 128.52,50.21 132.9,58.21
+SDC_IN on TOP (solid shape): outline of 401 points within 43.63,65.83 66.3,89.65
+SDC_IN on BOTTOM (solid shape): 25.13,46.44 25.12,46.41 25.12,46.35 25.13,46.29 25.13,45.54 25.06,45.47 25.06,45.35 24.86,45.15 24.86,43.83 24.85,43.76 24.72,43.64 24.05,43.64 24.05,44.19 23.69,44.55 23.33,44.19 23.33,43.64 23.31,43.64 23.31,43.28 22.98,42.96 22.32,42.96 22.18,43.09 22.18,46.27 22.43,46.53 25.04,46.53
+SDC_IN on IN3 (solid shape): outline of 8076 points within 19.08,42.24 53.97,85.43
+TBTA_VBUS on TOP (solid shape): 10.15,70.4 10.15,69.87 9.98,69.7 6.79,69.7 6.53,69.95 6.53,70.04 6.57,70.12 6.66,70.14 6.86,70.14 7.04,70.24 7.08,70.28 7.37,70.28 7.83,70.74 9.82,70.74
+TBTA_VBUS on TOP (solid shape): 10.36,73.1 10.86,73.1 10.99,72.97 10.99,72.61 10.93,72.61 10.84,72.52 10.48,72.52 10.05,72.09 8.74,72.09 8.36,72.54 7.99,72.09 7.3,72.09 7.17,72.22 7.04,72.57 6.67,72.64 6.57,72.65 6.53,72.74 6.53,72.99 6.64,73.1 7.78,73.1 7.98,73.3 9.17,73.3 9.24,73.36 10.1,73.36
+TBTA_VBUS on BOTTOM (solid shape): 10.21,73.33 10.21,72.79 9.7,72.27 8.73,72.27 8.28,72.72 6.87,72.72 6.82,72.66 6.59,72.6 6.44,72.42 5.63,72.42 5.55,72.5 5.55,72.75 5.61,72.81 6.46,72.81 6.68,73.04 8.69,73.04 9.08,73.43 10.11,73.43
+TBTA_VBUS on BOTTOM (solid shape): 10.24,70.25 10.24,69.9 10.11,69.77 9.68,69.77 9.68,69.77 9.2,69.77 8.92,70.05 8.36,70.05 8.23,70.18 7.29,70.18 7.22,70.11 7.11,70.04 7.04,69.93 7.03,69.86 7.04,69.79 7.04,69.77 6.96,69.69 6.61,69.69 6.35,69.95 5.65,69.95 5.58,70.02 5.58,70.21 5.66,70.3 6.52,70.3 6.94,70.14 7.22,70.49 7.23,70.5 8.14,70.5 8.46,70.81 9.68,70.81
+TBTA_VBUS on IN1 (solid shape): outline of 284 points within 6.52,69.52 14.3,80.62
+TBTA_VBUS on IN2 (solid shape): outline of 270 points within 7.98,69.64 15.45,80.69
+TBTA_VBUS on IN3 (solid shape): outline of 629 points within 7.55,67.84 15.5,80.82
+TBTA_VBUS on BOTTOM: 11.2,77.02 10.79,77.43 10.79,80.3 11,80.51 14.22,80.51 15.28,79.45 19.2,79.45 19.36,79.29 19.36,77.46 18.59,76.69 16.73,76.69 16.41,77.02 16.04,77.29 15.68,77.02
+TBTA_VBUS_1 on TOP (solid shape): 12.03,60.05 12.03,57.83 11.77,57.57 10.25,57.57 10.05,57.77 10.05,59.99 10.33,60.27 11.81,60.27
+TBTA_VBUS_1 on TOP (solid shape): 42.77,61.16 44.24,61.16 44.24,61.7 44.69,61.7 44.69,61.15 45.44,61.15 45.44,61.7 45.89,61.7 45.89,61.16 46.58,61.16 46.64,61.1 46.64,60.36 46.04,59.76 40.42,59.76 39.91,59.25 39.91,59.08 39.48,58.64 34.62,58.64 34.46,58.8 34.46,61.35 34.72,61.61 38.19,61.61 38.59,62 41.92,62
+TBTA_VBUS_1 on TOP (solid shape): 25.88,59.9 25.88,59.71 26.09,59.5 26.18,59.5 26.28,59.4 26.28,58.98 26.27,58.97 26.27,58.21 25.99,57.93 25.99,56.48 25.88,56.37 24.96,56.37 24.82,56.51 24.82,59.04 25.02,59.24 25.02,59.36 25.14,59.49 25.25,59.49 25.48,59.72 25.48,59.87 25.58,59.97 25.82,59.97
+TBTA_VBUS_1 on BOTTOM (solid shape): 19.3,81.99 19.3,79.74 19.18,79.63 15.85,79.63 14.98,80.5 14.98,81.95 15.09,82.06 19.22,82.06
+TBTA_VBUS_1 on IN4: outline of 123 points within 9.02,50.85 36.33,82.13
+USB_EX2_PWR on TOP (solid shape): 27.57,20.18 27.57,18.41 27.4,18.24 25.39,18.24 25.18,18.46 25.18,20.24 25.33,20.39 27.36,20.39
+USB_EX2_PWR on TOP (solid shape): 17.64,29.81 17.64,29.32 19.24,27.71 20.18,27.71 20.27,27.62 20.27,25.68 20,25.41 19.38,25.41 19.03,25.76 18.48,25.76 18.31,25.59 17.34,25.59 16.72,26.22 16.72,27.14 16.25,27.61 15.89,27.61 15.2,28.3 15.2,29.9 15.43,30.13 17.32,30.13
+USB_EX2_PWR on IN2: 18.08,19.07 16.74,20.41 16.74,27.41 16.99,27.66 21.65,27.66 22.01,27.3 22.01,24.79 22.4,24.4 26.3,24.4 27.35,23.35 27.35,22.21 27.3,22.16 27.22,22.15 27.15,22.13 27.09,22.09 27.05,22.06 27.01,22.05 26.98,22.06 26.34,21.78 26.98,21.5 27.01,21.51 27.05,21.5 27.09,21.46 27.15,21.43 27.22,21.41 27.3,21.4 27.35,21.35 27.35,19.41 27,19.07 23.93,19.07 23.89,19.1 23.85,19.12 23.8,19.14 23.76,19.15 23.71,19.16 23.64,19.21 23.63,19.3 23.59,19.64 23.28,19.81 22.99,19.69 22.89,19.39 22.91,19.31 22.95,19.22 22.95,19.12 22.86,19.07
+UZ12_TPM on TOP (solid shape): 159.63,57.64 159.63,56.3 159.48,56.15 159.48,54.57 159.52,54.54 159.52,53.16 159.44,53.08 158.88,53.08 158.84,53.12 158.84,53.67 158.73,53.78 158.73,55.51 158.86,55.63 158.86,56.38 159.22,56.75 159.22,57.65 159.3,57.73 159.54,57.73
+VCHGR on TOP (solid shape): 42.85,27.73 42.85,26.34 40.82,24.3 40.82,23.34 40.62,23.14 38.45,23.14 38.32,23.27 38.32,24.01 37.9,24.43 37.9,25.2 38.45,25.2 38.8,25.56 38.45,25.92 37.9,25.92 37.9,27.73 38.16,27.99 42.6,27.99
+VCHGR on BOTTOM (solid shape): 42.85,27.86 42.85,26.34 42.73,26.21 41.58,26.21 41.33,26.46 41.33,27.86 41.46,27.99 42.73,27.99
+VHDMI_VCC on BOTTOM (solid shape): 16.04,54.78 16.04,54.29 16.09,54.24 16.1,54.24 16.39,53.94 16.39,53.2 16.72,52.88 16.72,52.07 16.4,51.76 12.48,51.76 12.26,51.98 12.26,53.48 12.93,54.15 15.21,54.15 15.45,54.4 15.45,54.73 15.61,54.89 15.94,54.89
+VHDMI_VCC on IN2 (solid shape): outline of 203 points within 12.17,48.28 24.22,54.54
BGATE_ISL9538 on BOTTOM (solid shape): 33.48,47.36 33.48,47 32.56,46.08 32.56,45.7 32.5,45.64 32.41,45.64 32.35,45.7 32.35,46.47 32.43,46.55 32.52,46.55 33.02,47.05 33.02,47.33 33.14,47.45 33.39,47.45
BGATE_ISL9538 on TOP: 37.85,23.86 35.94,23.86 35.69,24.1 35.41,24.1 35.3,23.99 35.3,22.8 35.55,22.55 35.97,22.55 36.08,22.66 36.08,22.96 36.29,23.17 38.06,23.17 38.16,23.27 38.16,23.8 38.09,23.86 37.85,23.86
BL_PWR_SRC_ON on TOP: 76.86,97.85 76.69,98.02 76.69,99.36 76.86,99.54 77.18,99.54 77.78,100.14 77.78,100.27 77.78,100.27 77.78,100.93 77.96,101.1 79.52,101.1 79.72,100.9 79.72,99.45 79.44,99.17 77.93,99.17 77.83,99.07 77.83,98.22 77.46,97.85
