# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D6: length 75.3
  IN1 w0.089: v1(94.67,55.5) 94.55,55.62 89.18,55.62 84.75,51.19 84.75,49.01 79.91,44.17 78.75,44.17 58.96,24.37 58.96,24.22 59.48,23.7 59.48,23.55 59.37,23.45 59.23,23.45 58.71,23.97 58.56,23.97 58.45,23.87 58.45,23.72 58.99,23.19 58.99,23.04 58.88,22.93 58.74,22.93 58.2,23.47 58.06,23.47 57.95,23.36 57.95,23.22 58.42,22.75 58.42,22.6 58.31,22.5 58.16,22.5 57.7,22.96 57.55,22.96 53.97,19.38 53.97,17.12 v1(54.68,16.41)
  BOTTOM w0.076: v1(94.67,55.5) 94.92,55.75 97.65,55.75 98.1,56.21 98.33,56.21 99.57,56.21 99.61,56.25 100.36,56.25 UC1.AN70
  BOTTOM w0.102: JDIMM1.17 54.18,16.91 v1(54.68,16.41)
DDR_A_D7: length 74.5
  IN1 w0.089: v1(91.81,54.91) 91.77,54.86 89.29,54.86 85.36,50.94 85.36,48.41 80.48,43.53 78.98,43.53 62.94,27.48 62.94,27.34 63.54,26.73 63.54,26.59 63.43,26.48 63.29,26.48 62.68,27.09 62.54,27.09 62.43,26.98 62.43,26.83 63.04,26.23 63.04,26.08 62.93,25.98 62.78,25.98 62.18,26.58 62.03,26.58 61.93,26.48 61.93,26.33 62.53,25.73 62.53,25.58 58.84,21.89 57.66,21.89 55.54,19.77 55.54,13.57 v1(55.11,13.13)
  BOTTOM w0.076: UC1.AN71 99.65,56.52 99.5,56.38 98.81,56.38 98.27,56.38 98.26,56.38 97.99,56.38 97.53,55.92 94.42,55.92 94.26,55.75
  BOTTOM w0.102: v1(91.81,54.91) 92.37,55.47 93.98,55.47 94.26,55.75 ; v1(55.11,13.13) 54.93,12.95 JDIMM1.20
DDR_A_D8: length 70.1
  IN1 w0.089: v1(56.76,13.08) 56.94,12.91 57.13,12.91 57.22,12.99 57.22,15.66 57.08,15.8 56.64,15.8 56.44,16 56.44,18.72 56.95,19.22 57.45,19.22 86.54,48.31 86.54,50.84 89.66,53.96 93.78,53.96 94.25,53.49 94.82,53.49 95.2,53.87 95.2,54.56 95.3,54.65 v1(95.63,54.65)
  BOTTOM w0.076: UC1.AR70 100.47,55.49 100.21,55.76 99.82,55.76 99.78,55.72 98.34,55.72 98.27,55.64
  BOTTOM w0.102: 98.27,55.64 97.85,55.22 96.2,55.22 v1(95.63,54.65) ; v1(56.76,13.08) 56.93,12.92 JDIMM1.28
DDR_A_D9: length 71.1
  IN1 w0.089: v1(94.59,54) 94.59,54.25 94.44,54.4 94.04,54.4 93.9,54.27 89.54,54.27 86.16,50.89 86.16,48.36 57.33,19.53 56.82,19.53 56.14,18.84 56.14,15.2 v1(56.73,14.61)
  BOTTOM w0.076: 95.5,55.27 95.62,55.4 97.77,55.4 98.26,55.88 98.47,55.88 99.71,55.88 99.75,55.92 100.61,55.92 100.85,55.68 101.39,55.68 UC1.AR68
  BOTTOM w0.102: v1(56.73,14.61) 55.93,13.8 JDIMM1.24 ; v1(94.59,54) 94.59,54.36 95.5,55.27
DDR_A_D10: length 68.5
  IN1 w0.089: v1(60.76,15.47) 60.32,15.47 59.62,16.18 59.62,18.87 86.34,45.59 86.85,45.59 86.95,45.49 86.95,44.87 87.06,44.77 87.2,44.77 87.31,44.87 87.31,45.49 87.41,45.59 87.56,45.59 87.66,45.49 87.66,44.87 87.77,44.77 87.91,44.77 88.02,44.87 88.02,45.49 88.12,45.59 92.8,45.59 95.3,48.09 95.3,50.71 96.51,51.91 96.78,51.91 97.13,52.27 97.13,52.68 v1(96.93,52.88)
  BOTTOM w0.076: v1(96.93,52.88) 96.93,53.16 97.23,53.47 97.53,53.47 97.83,53.77 98.94,53.77 99.24,54.08 99.88,54.08 UC1.AU71
  BOTTOM w0.102: v1(60.76,15.47) 59.43,14.14 JDIMM1.38
DDR_A_D11: length 70.1
  IN1 w0.089: v1(60.85,13.95) 61.03,13.76 61.52,13.76 61.78,14.02 61.78,15.41 61.4,15.79 61.4,19.35 85.9,43.85 92.36,43.85 96.91,48.4 96.91,48.5 97.88,49.48 99.27,49.48 100.13,50.34 100.13,53.23 v1(98.58,54.79)
  BOTTOM w0.076: UC1.AU68 101.92,54.92 101.72,55.12 101.48,55.12 101.45,55.1 100.86,55.1 100.71,55.04 100.56,55.04 100.34,55.1 100.23,55.1 100.15,55.07 100.12,55.06 99.75,55.06 99.59,55.22 99.01,55.22 98.58,54.78 v1(98.58,54.79)
  BOTTOM w0.102: v1(60.85,13.95) 60.43,13.53 JDIMM1.42
DDR_A_D12: length 68.6
  IN1 w0.089: v1(56.99,18.57) 57.23,18.57 86.12,47.46 86.26,47.46 86.65,47.07 86.8,47.07 86.9,47.17 86.9,47.32 86.51,47.71 86.51,47.85 86.62,47.96 86.77,47.96 87.14,47.58 87.29,47.58 87.39,47.69 87.39,47.83 87.02,48.21 87.02,50.88 89.79,53.66 93.65,53.66 94.12,53.18 95.97,53.18 96.12,53.34 96.12,53.48 95.77,53.83 95.77,53.98 95.88,54.08 96.02,54.08 96.37,53.74 96.52,53.74 96.96,54.17 96.96,55.32 96.75,55.52 96.44,55.52 96.23,55.32 v1(96.23,54.65)
  BOTTOM w0.076: 98.4,55.47 98.48,55.55 99.91,55.55 UC1.AR71
  BOTTOM w0.102: JDIMM1.29 57.18,18.76 v1(56.99,18.57) ; 98.4,55.47 97.96,55.03 97.33,55.03 96.95,54.65 v1(96.23,54.65)
DDR_A_D13: length 70
  IN1 w0.089: v1(97.74,54.62) 97.74,54.5 96.12,52.88 94,52.88 93.52,53.35 89.92,53.35 87.32,50.76 87.32,48.34 87.7,47.96 87.7,47.29 87.87,47.12 88.91,47.12 89.02,47.01 89.02,46.87 88.91,46.76 87.81,46.76 87.63,46.76 87.49,46.91 87.18,46.91 87.03,46.76 85.85,46.76 57.39,18.3 57.39,17.45 v1(56.99,17.05)
  BOTTOM w0.076: v1(97.74,54.62) 97.92,54.81 98.08,54.81 98.42,55.16 98.65,55.39 99.66,55.39 99.82,55.22 100.08,55.22 100.2,55.28 100.22,55.28 100.23,55.28 100.24,55.28 100.34,55.28 100.57,55.21 100.7,55.21 100.92,55.29 101.17,55.29 UC1.AR69
  BOTTOM w0.102: v1(56.99,17.05) 56.18,17.86 JDIMM1.25
DDR_A_D14: length 68.4
  IN1 w0.089: v1(60.18,18.7) 60.18,18.99 85.65,44.46 88.22,44.46 88.32,44.57 88.32,45.03 88.43,45.13 88.57,45.13 88.68,45.03 88.68,44.57 88.78,44.46 88.93,44.46 89.03,44.57 89.03,45.05 89.14,45.16 89.29,45.16 89.39,45.05 89.39,44.57 89.49,44.46 89.64,44.46 89.75,44.57 89.75,45.18 89.85,45.28 90,45.28 90.1,45.18 90.1,44.57 90.2,44.46 90.35,44.46 90.46,44.57 90.46,45.18 90.56,45.28 90.71,45.28 90.81,45.18 90.81,44.57 90.92,44.46 91.06,44.46 91.17,44.57 91.17,45.18 91.27,45.28 91.42,45.28 91.52,45.18 91.52,44.57 91.63,44.46 92.1,44.46 95.61,47.97 95.61,50.58 96.64,51.61 97.77,51.61 98.23,52.06 98.23,53.82 98.02,54.02 97.74,54.02 97.54,53.82 v1(97.54,53.01)
  BOTTOM w0.076: v1(97.54,53.01) 97.54,53.12 98.02,53.61 99.01,53.61 99.3,53.9 100.36,53.9 UC1.AU70
  BOTTOM w0.102: JDIMM1.41 v1(60.18,18.7)
DDR_A_D15: length 68.9
  IN1 w0.089: v1(98.91,53.24) 99.24,52.9 99.24,52.75 99.12,52.62 98.88,52.62 98.73,52.48 98.73,52.27 98.88,52.12 99.62,52.12 99.83,51.91 99.83,51.43 99.04,50.64 99.04,49.97 98.93,49.86 98.77,49.86 98.66,49.97 98.66,50.49 98.56,50.59 98.41,50.59 98.31,50.49 98.31,49.89 98.2,49.78 97.61,49.78 97.45,49.63 97.31,49.63 96.79,50.15 96.64,50.15 96.54,50.05 96.54,49.9 97.06,49.38 97.06,49.23 96.95,49.13 96.8,49.13 96.28,49.65 96.14,49.65 96.03,49.54 96.03,49.4 96.55,48.88 96.55,48.48 92.23,44.16 85.77,44.16 60.89,19.27 60.89,17.9 v1(60.16,17.17)
  BOTTOM w0.076: v1(98.91,53.24) 99.4,53.73 100.64,53.73 101.07,54.16 UC1.AU69
  BOTTOM w0.102: JDIMM1.37 59.18,18.16 v1(60.16,17.17)
DDR_A_D16: length 69.7
  IN4 w0.089: v1(99.91,13.36) 99.29,13.99 99.29,19.09 94.65,23.73 94.65,24.85 89.41,30.09 89.41,40.95 84.53,45.82 84.53,51.41 89.46,56.33 97.42,56.33 101.37,60.28 102.99,60.28 v1(103.56,59.72)
  BOTTOM w0.076: v1(103.56,59.72) 103.87,60.03 UC1.AF65
  BOTTOM w0.102: v1(99.91,13.36) 100.43,12.85 JDIMM1.194
DDR_A_D17: length 68.5
  IN4 w0.076: 95.6,54.15 95.15,54.59 94.61,54.59 93.91,55.29 91.32,55.29 ; 99.74,56.42 100.76,57.43 100.76,57.8 102.27,59.31 103.81,59.31 v1(104.22,59.72)
  IN4 w0.089: 91.32,55.29 89.72,55.29 85.45,51.03 85.45,46.84 90.32,41.97 90.32,30.61 96.19,24.74 96.19,24.59 95.71,24.12 95.71,23.97 95.82,23.87 95.97,23.87 96.44,24.34 96.59,24.34 96.69,24.24 96.69,24.09 96.22,23.61 96.22,23.47 96.32,23.36 96.47,23.36 96.94,23.84 97.09,23.84 97.19,23.73 97.19,23.59 96.72,23.11 96.72,22.96 100.57,19.12 100.57,18.64 v1(100.4,18.47) ; 99.74,56.42 98.93,55.6 98.64,55.6 98.12,55.08 98.12,54.46 97.81,54.15 95.6,54.15
  BOTTOM w0.076: v1(104.22,59.72) 104.27,59.77 104.27,59.93 UC1.AF64
  BOTTOM w0.102: v1(100.4,18.47) 100.68,18.75 JDIMM1.195
DDR_A_D18: length 68.9
  IN4 w0.076: v1(104.19,57.9) 103.64,57.35 102.41,57.35 102.1,57.04
  IN4 w0.089: v1(103.47,13.54) 103.75,13.54 103.93,13.71 103.93,15.56 103.51,15.97 103.51,20.7 92.41,31.8 92.41,43.36 92.31,43.47 91.93,43.47 91.83,43.57 91.83,43.72 91.93,43.82 92.31,43.82 92.41,43.93 92.41,44.07 92.31,44.18 91.1,44.18 91,44.28 91,44.43 91.1,44.53 92.31,44.53 92.41,44.64 92.41,44.78 92.31,44.89 90.92,44.89 90.82,44.99 90.82,45.14 90.92,45.24 92.31,45.24 92.41,45.35 92.41,45.5 92.31,45.6 90.92,45.6 90.82,45.7 90.82,45.85 90.92,45.96 92.57,45.96 94.73,48.12 94.73,50.55 95.48,51.3 96.01,51.3 96.32,51.61 97.58,51.61 98.3,52.33 99.53,52.33 100.59,53.39 100.59,53.53 102.1,55.04 102.1,57.04
  BOTTOM w0.076: UC1.AK65 v1(104.19,57.9)
  BOTTOM w0.102: JDIMM1.204 102.93,13 v1(103.47,13.54)
DDR_A_D19: length 69.9
  IN4 w0.076: v1(104.82,57.9) 104.39,58.34 103.43,58.34 103.36,58.27 102.77,58.27 102.76,58.27 102.76,58.27 102.33,57.85 102.19,57.85 100.88,56.53 100.88,54.88 99.8,53.8 98.85,53.8 98.65,53.59 96.55,53.59 96.45,53.49 96.45,52.96 96.24,52.75 96.07,52.75 95.94,52.88 94.09,52.88 93.91,52.7
  IN4 w0.089: v1(102.15,17.96) 101.76,18.35 101.76,19.68 100.02,21.41 100.02,21.56 100.46,22 100.46,22.15 100.36,22.25 100.21,22.25 99.77,21.81 99.62,21.81 99.52,21.92 99.52,22.06 99.96,22.5 99.96,22.65 99.86,22.75 99.71,22.75 99.27,22.32 99.12,22.32 99.02,22.42 99.02,22.57 99.46,23.01 99.46,23.15 99.35,23.26 99.21,23.26 98.77,22.82 98.62,22.82 98.51,22.92 98.51,23.07 98.95,23.51 98.95,23.66 91.5,31.11 91.5,42.49 86.99,47 86.99,50.9 89.67,53.59 92.82,53.59 93.7,52.7 93.91,52.7
  BOTTOM w0.076: UC1.AK64 v1(104.82,57.9)
  BOTTOM w0.102: JDIMM1.203 102.68,18.49 v1(102.15,17.96)
DDR_A_D20: length 69.2
  IN4 w0.089: v1(102.95,59.72) 102.55,60.11 101.64,60.11 100.23,58.69 100.23,57.69 98.94,56.41 98.47,56.41 98.08,56.02 89.58,56.02 84.84,51.28 84.84,46.59 89.71,41.71 89.71,30.25 94.96,25.01 94.96,23.86 99.59,19.22 99.59,15.12 99.82,14.89 v1(99.99,14.89)
  BOTTOM w0.076: v1(102.95,59.72) 102.95,59.91 UC1.AF66
  BOTTOM w0.102: v1(99.99,14.89) 99.43,14.32 JDIMM1.190
DDR_A_D21: length 68.7
  IN4 w0.076: 100.58,57.63 100.58,58.28 102.03,59.73 v1(102.31,59.73)
  IN4 w0.089: v1(100.34,16.94) 100.34,17.03 99.9,17.48 99.9,19.34 95.26,23.98 95.26,25.24 90.02,30.48 90.02,41.84 85.14,46.71 85.14,51.15 89.7,55.71 93.91,55.71 94.71,54.91 95.05,54.91 95.85,55.71 96.21,55.71 96.31,55.61 96.31,55.08 96.42,54.98 96.56,54.98 96.67,55.08 96.67,55.61 96.77,55.71 96.92,55.71 97.02,55.61 97.02,55.08 97.13,54.98 97.27,54.98 97.38,55.08 97.38,55.61 97.48,55.71 98.18,55.71 98.61,56.14 99.08,56.14 100.58,57.63
  BOTTOM w0.076: v1(102.31,59.73) 102.31,59.78 102.57,60.05 UC1.AF67
  BOTTOM w0.102: JDIMM1.191 99.68,19.11 99.56,18.99 99.56,17.73 v1(100.34,16.94)
DDR_A_D22: length 67.4
  IN4 w0.076: v1(102.92,57.9) 102.7,57.68 102.26,57.68 101.76,57.18 101.76,57.04 101.05,56.33 101.05,54.54 100.25,53.74 100.25,53.53 99.44,52.72 99.06,52.72
  IN4 w0.089: v1(102.22,16.44) 102.58,16.79 102.58,19.29 100.51,21.36 100.51,21.54 100.91,21.94 100.91,22.16 91.8,31.26 91.8,42.62 87.49,46.92 87.49,50.98 89.8,53.28 92.53,53.28 93.94,51.87 94.14,51.87 94.24,51.97 94.24,52.37 94.34,52.47 94.53,52.47 95.09,51.92 95.95,51.92 96.12,52.09 97.43,52.09 98.06,52.72 99.06,52.72
  BOTTOM w0.076: UC1.AK67 v1(102.92,57.9)
  BOTTOM w0.102: JDIMM1.207 103.68,17.89 v1(102.22,16.44)
DDR_A_D23: length 68.1
  IN4 w0.076: v1(103.55,57.9) 103.17,57.52 102.33,57.52 101.93,57.11 101.93,56.97 101.21,56.26 101.21,54.46 100.42,53.66 100.42,53.46 99.48,52.53 99.28,52.53
  IN4 w0.089: v1(103.49,15.09) 103.28,15.09 103.1,15.27 103.1,15.56 103.19,15.65 103.19,20.31 102.13,21.37 102,21.37 101.88,21.24 101.88,21.12 102.83,20.16 102.83,20.02 102.72,19.91 102.58,19.91 101.12,21.37 101.12,21.71 101.39,21.98 101.39,22.1 92.1,31.39 92.1,42.74 90.51,44.33 90.51,45.08 90.41,45.18 89.85,45.18 89.74,45.29 89.74,45.43 89.85,45.54 90.41,45.54 90.51,45.64 90.51,45.79 90.41,45.89 89.82,45.89 89.72,46 89.72,46.15 89.82,46.26 92.45,46.26 94.42,48.23 94.42,50.71 95.34,51.63 96.06,51.63 96.35,51.91 97.55,51.91 98.17,52.53 99.28,52.53
  BOTTOM w0.076: UC1.AK66 v1(103.55,57.9)
  BOTTOM w0.102: v1(103.49,15.09) 103.93,14.66 103.93,11.8 JDIMM1.208
DDR_A_D24: length 71.6
  IN4 w0.084: v1(96.36,60.37) 97.02,59.72 97.71,59.72 97.99,59.44
  IN4 w0.089: 97.99,59.44 97.99,59.26 96.91,58.17 89.16,58.17 82.97,51.98 82.97,45.1 87.85,40.22 87.85,28.4 97.22,19.02 97.22,18.16 97.4,17.98 97.4,14.2 v1(97.98,13.62)
  BOTTOM w0.076: 98.28,61.07 99.67,61.07 99.98,60.77 100.13,60.77 100.3,60.6 100.52,60.6 UC1.AF70
  BOTTOM w0.102: JDIMM1.186 98.43,13.17 v1(97.98,13.62) ; v1(96.36,60.37) 97.06,61.07 98.28,61.07
DDR_A_D25: length 73.9
  IN4 w0.084: 91.38,60.42 v1(95.13,60.42)
  IN4 w0.089: 91.38,60.42 88.39,60.42 80.86,52.89 80.86,44.22 85.73,39.35 85.73,27.56 89.11,24.18 89.11,20.91 91.3,18.72 92.13,18.72 92.45,18.39 92.45,14.83 92.64,14.65 93.03,14.65 93.71,13.96 93.86,13.96 94.01,14.1 94.15,14.1 94.26,14 94.26,13.85 94.11,13.7 94.11,13.56 94.46,13.21 v1(95.34,13.21)
  BOTTOM w0.076: UC1.AF68 101.9,60.41 101.38,60.67 101.32,60.69 100.85,60.69 100.78,60.76 100.37,60.76 100.19,60.95 100.05,60.95 99.61,61.39 98.6,61.39
  BOTTOM w0.102: JDIMM1.174 95.43,13.13 v1(95.34,13.21) ; 98.6,61.39 96.09,61.39 v1(95.13,60.42)
DDR_A_D26: length 71.5
  IN4 w0.089: v1(94.92,59.23) 94.8,59.35 94.8,59.74 94.48,60.05 88.45,60.05 81.16,52.77 81.16,44.35 86.04,39.47 86.04,27.68 89.41,24.31 89.41,21.04 90.28,20.17 90.42,20.17 90.78,20.53 90.93,20.53 91.04,20.43 91.04,20.28 90.67,19.92 90.67,19.78 90.78,19.67 90.93,19.67 91.29,20.03 91.43,20.03 91.54,19.93 91.54,19.78 91.18,19.42 91.18,19.27 91.35,19.1 93.15,19.1 93.26,18.99 93.26,18.35 93.36,18.24 93.51,18.24 93.61,18.35 93.61,18.99 93.72,19.1 94.16,19.1 94.42,18.84 94.42,18.4 v1(94.83,17.99)
  BOTTOM w0.076: 95.91,58.8 96.01,58.8 96.34,58.47 97.88,58.47 98.58,59.17 UC1.AH71
  BOTTOM w0.102: 95.91,58.8 95.35,58.8 v1(94.92,59.23) ; v1(94.83,17.99) 95.19,17.99 95.39,18.19 95.39,18.75 95.18,18.96 95.18,19.86 95.18,19.86 JDIMM1.173
DDR_A_D27: length 73.6
  IN4 w0.089: v1(98.76,60.27) 98.63,60.14 98.63,57.79 98.07,57.24 89.52,57.24 83.88,51.6 83.88,45.63 88.81,40.7 88.81,29.85 92.55,26.11 92.55,25.96 92.13,25.55 92.13,25.4 92.24,25.3 92.38,25.3 92.8,25.71 92.94,25.71 93.05,25.61 93.05,25.46 92.64,25.05 92.64,24.9 92.74,24.8 92.89,24.8 93.3,25.21 93.45,25.21 93.55,25.11 93.55,24.96 93.14,24.55 93.14,24.4 93.24,24.29 93.39,24.29 93.8,24.71 93.95,24.71 94.05,24.6 94.05,24.45 93.64,24.04 93.64,23.9 98.68,18.86 98.68,16.88 v1(98.21,16.41)
  BOTTOM w0.076: UC1.AH68 101.92,59.82 101.72,60.03 101.27,60.03 101.17,60.1 100.85,60.1 100.73,60.06 100.5,60.06 100.49,60.06 100.49,60.06 100.48,60.06 100.4,60.1 100.2,60.1 100.11,60.06 99.75,60.06 99.44,60.37 98.86,60.37 v1(98.76,60.27)
  BOTTOM w0.102: v1(98.21,16.41) 97.68,16.95 JDIMM1.183
DDR_A_D28: length 70.9
  IN4 w0.084: 97.39,59.95 v1(96.96,60.37)
  IN4 w0.089: 97.39,59.95 97.73,59.95 98.17,59.51 98.17,58.79 97.24,57.86 89.28,57.86 83.27,51.85 83.27,45.22 88.15,40.35 88.15,28.52 97.52,19.15 97.52,18.29 97.73,18.09 97.73,16.29 98.23,15.79 98.53,15.79 98.69,15.63 98.69,15.14 98.53,14.98 v1(97.96,14.98)
  BOTTOM w0.076: UC1.AF71 99.61,60.86 98.17,60.86 98.07,60.76
  BOTTOM w0.102: v1(96.96,60.37) 97.35,60.76 98.07,60.76 ; v1(97.96,14.98) 97.43,14.45 JDIMM1.182
DDR_A_D29: length 72.8
  IN4 w0.089: v1(98.25,17.94) 98.25,18 97.83,18.42 97.83,19.28 91.57,25.53 91.57,25.68 91.85,25.96 91.85,26.11 91.75,26.21 91.6,26.21 91.32,25.93 91.17,25.93 91.07,26.04 91.07,26.18 91.48,26.6 91.48,26.74 91.38,26.85 91.23,26.85 90.82,26.43 90.67,26.43 90.57,26.54 90.57,26.69 90.98,27.1 90.98,27.25 90.87,27.35 90.73,27.35 90.31,26.94 90.17,26.94 90.06,27.04 90.06,27.19 90.48,27.6 90.48,27.75 90.37,27.85 90.22,27.85 89.81,27.44 89.66,27.44 89.56,27.54 89.56,27.69 89.97,28.1 89.97,28.25 89.87,28.36 89.72,28.36 89.31,27.94 89.16,27.94 89.06,28.05 89.06,28.2 89.47,28.61 89.47,28.75 89.37,28.86 89.22,28.86 88.81,28.45 88.66,28.45 88.51,28.6 88.51,40.42 83.58,45.35 83.58,51.73 89.41,57.55 97.41,57.55 98.39,58.53 98.39,59.7 98.17,59.92 v1(98.17,60.25)
  BOTTOM w0.076: v1(98.17,60.25) 98.61,60.69 99.35,60.69 99.82,60.23 100.07,60.23 100.16,60.27 100.43,60.27 100.52,60.23 100.72,60.23 100.81,60.26 100.91,60.3 101.17,60.3 UC1.AF69
  BOTTOM w0.102: JDIMM1.187 98.68,18.36 v1(98.25,17.94)
DDR_A_D30: length 72.2
  IN4 w0.089: v1(94.86,17.22) 95.25,17.62 95.25,18.9 94.75,19.4 92.5,19.4 91,20.89 89.99,20.89 89.72,21.16 89.72,22.47 89.82,22.57 90.45,22.57 90.56,22.68 90.56,22.83 90.45,22.93 89.82,22.93 89.72,23.03 89.72,23.18 89.82,23.29 90.45,23.29 90.56,23.39 90.56,23.54 90.45,23.64 89.82,23.64 89.72,23.75 89.72,24.43 86.34,27.81 86.34,39.6 81.47,44.47 81.47,52.63 88.57,59.74 93.22,59.74 v1(93.64,59.31)
  BOTTOM w0.076: 95.84,58.43 95.97,58.31 97.95,58.31 98.54,58.9 100.08,58.9 100.32,59.02 100.47,59.17 UC1.AH70
  BOTTOM w0.102: v1(93.64,59.31) v2(94.52,58.43) 95.84,58.43 ; v1(94.86,17.22) 94.44,17.64 94.44,18.7 94.18,18.97 94.18,20 JDIMM1.169
DDR_A_D31: length 73
  IN4 w0.089: v1(95.37,14.76) 96.05,14.76 96.35,15.06 96.35,15.9 95.57,16.67 95.57,19.01 94.88,19.71 92.62,19.71 90.68,21.65 90.68,22.35 91.24,22.91 91.24,23.34 86.65,27.94 86.65,39.72 81.77,44.6 81.77,52.46 88.67,59.36 v1(92.35,59.36)
  BOTTOM w0.076: 97.96,58.09 98.61,58.74 100.11,58.74 100.19,58.77 100.67,58.77 101.07,59.17 UC1.AH69
  BOTTOM w0.102: 97.96,58.09 93.63,58.09 v1(92.35,59.36) ; JDIMM1.170 94.43,13.82 v1(95.37,14.76)
DDR_A_D32: length 63.7
  IN1 w0.089: v1(97.9,46.81) 97.64,46.81 95.68,44.85 95.68,44.6 95.98,44.3 95.98,44.15 94.17,42.34 89.7,42.34 89.52,42.16 89.52,41.78 89.35,41.61 85.85,41.61 63.67,19.42 63.67,15.75 v1(62.93,15.01)
  BOTTOM w0.076: UC1.BB65 103.63,50.92 103.63,50.49 103.52,50.38 103.52,50.31 102.49,49.27 99.87,49.27 99.19,48.59 99.19,47.77 98.23,46.81 v1(97.9,46.81)
  BOTTOM w0.102: v1(62.93,15.01) 62.57,15.01 61.43,13.87 61.43,13.71 61.43,13.7 JDIMM1.46
DDR_A_D33: length 65.5
  IN1 w0.089: v1(64.96,15.37) 65.42,15.83 65.42,19.52 86.34,40.43 91.8,40.43 91.94,40.57 91.94,41 92.1,41.17 95.03,41.17 v1(97.65,43.79)
  BOTTOM w0.076: 100.1,48.69 100.18,48.77 102.7,48.77 103.95,50.01 104.5,50.01 104.76,50.28 104.76,50.61 104.62,50.75 104.62,51.16 104.66,51.25 104.66,51.43 104.62,51.55 104.62,51.81 104.66,51.91 104.66,52.62 104.59,52.77 104.38,52.97 UC1.AW65
  BOTTOM w0.102: 100.1,48.69 99.88,48.46 99.88,47.42 99.43,46.98 99.43,45.41 97.81,43.79 v1(97.65,43.79) ; JDIMM1.62 65.43,14.91 v1(64.96,15.37)
DDR_A_D34: length 66.5
  IN1 w0.089: v1(99.93,45.5) 99.79,45.64 99.79,45.64 99.58,45.84 99.58,46.5 99.48,46.61 99.33,46.61 99.23,46.5 99.23,46.01 99.12,45.9 98.71,45.9 98.61,45.8 98.61,45.65 98.71,45.55 99.12,45.55 99.23,45.44 99.23,45.26 98.6,44.63 98.6,43.7 94.69,39.79 94.43,39.79 94.33,39.89 94.33,40.46 94.22,40.56 94.08,40.56 93.97,40.46 93.97,39.89 93.87,39.79 93.72,39.79 93.62,39.89 93.62,40.46 93.51,40.56 93.36,40.56 93.26,40.46 93.26,39.89 93.16,39.79 93.01,39.79 92.91,39.89 92.91,40.46 92.8,40.56 92.65,40.56 92.55,40.46 92.55,39.89 92.45,39.79 86.56,39.79 66.59,19.82 66.59,18.44 v1(66.16,18.01)
  BOTTOM w0.076: UC1.AW63 104.96,52.75 105.27,52.44 105.27,51.9 105.49,51.68 105.49,50.07 104.76,49.34 104.28,49.34 103.03,48.09 102.45,48.09 102.21,47.85 102.21,47.35
  BOTTOM w0.102: v1(66.16,18.01) 65.68,18.49 JDIMM1.63 ; 102.21,47.35 102.21,47.27 100.44,45.5 v1(99.93,45.5)
DDR_A_D35: length 65.3
  IN1 w0.089: v1(62.4,16.28) 62.07,16.61 62.07,19.12 85.43,42.48 87.34,43.16 87.61,43.26 92.61,43.26 97.48,48.13 97.48,48.23 98.05,48.8 98.86,48.8 v1(100.35,48.39)
  BOTTOM w0.076: UC1.AY63 104.85,52.22 104.85,51.97 104.79,51.78 104.79,51.59 104.82,51.46 104.82,51.21 104.79,51.13 104.79,50.87 104.93,50.73 104.93,50.21 104.55,49.83 104.01,49.83 102.76,48.59 100.55,48.59 v1(100.35,48.39)
  BOTTOM w0.102: v1(62.4,16.28) 61.18,17.51 JDIMM1.45
DDR_A_D36: length 64.1
  IN1 w0.089: v1(62.9,13.49) 62.47,13.92 62.47,15.35 63.36,16.24 63.36,19.55 85.72,41.91 89,41.91 89.21,42.12 89.21,42.46 89.39,42.65 94.04,42.65 94.89,43.5 94.89,43.64 94.73,43.8 94.73,43.95 94.84,44.06 95.22,44.06 95.37,44.2 95.37,44.98 97.79,47.4 v1(97.94,47.4)
  BOTTOM w0.076: 98.06,47.51 98.09,47.54 98.42,47.54 98.78,47.9 98.78,48.11 98.93,48.26 98.93,48.57 99.8,49.44 102.42,49.44 103.36,50.37 103.36,50.45 103.46,50.56 103.46,51.13 103.58,51.37 103.73,51.52 UC1.BA65
  BOTTOM w0.102: v1(62.9,13.49) 62.43,13.01 JDIMM1.50 ; 98.06,47.51 v1(97.94,47.4)
DDR_A_D37: length 64.6
  IN1 w0.089: v1(62.52,17.81) 63.06,18.34 63.06,19.68 85.6,42.22 87.38,42.22 87.48,42.32 87.48,42.77 87.59,42.88 87.73,42.88 87.84,42.77 87.84,42.32 87.94,42.22 88.09,42.22 88.19,42.32 88.19,42.85 88.3,42.95 88.44,42.95 88.55,42.85 88.55,42.32 88.65,42.22 88.8,42.22 88.9,42.32 88.9,42.85 89.01,42.95 92.73,42.95 93.13,43.35 93.29,43.35 93.63,43.02 93.78,43.02 93.88,43.12 93.88,43.27 93.54,43.61 93.54,43.75 93.65,43.86 93.8,43.86 94.17,43.49 94.31,43.49 94.42,43.59 94.42,43.74 94.16,43.99 94.16,44.23 97.78,47.85 97.78,48.11 98.08,48.4 v1(98.54,48.4)
  BOTTOM w0.076: v1(98.54,48.4) 98.54,48.63 98.72,48.81 99.44,49.53 99.47,49.53 99.54,49.6 102.35,49.6 103.19,50.44 103.19,50.52 103.3,50.63 103.3,51.16 103.37,51.33 103.41,51.4 103.41,51.44 103.46,51.57 103.46,51.85 103.73,52.12 UC1.AY65
  BOTTOM w0.102: JDIMM1.49 62.18,18.96 62.02,18.8 62.02,18.32 v1(62.52,17.81)
DDR_A_D38: length 65.1
  IN1 w0.089: v1(66.18,16.49) 66.18,16.11 66.31,15.98 66.48,15.98 66.89,16.4 66.89,16.71 66.6,17 66.6,17.32 66.89,17.61 66.89,19.69 86.68,39.48 86.81,39.48 86.92,39.38 86.92,38.81 87.02,38.71 87.17,38.71 87.27,38.81 87.27,39.38 87.37,39.48 94.81,39.48 99.52,44.2 99.52,44.34 99.26,44.6 99.26,44.75 99.37,44.85 99.52,44.85 99.77,44.59 99.92,44.59 100.16,44.84 100.16,45.15 100.49,45.47 100.49,46.43 v1(100.3,46.62)
  BOTTOM w0.076: 102.18,48.18 102.26,48.26 102.94,48.26 104.19,49.5 104.69,49.5 105.32,50.14 105.32,51.19 105.05,51.46 UC1.BA63
  BOTTOM w0.102: v1(100.3,46.62) 100.62,46.62 102.18,48.18 ; JDIMM1.59 64.68,17.84 66.03,16.49 v1(66.18,16.49)
DDR_A_D39: length 63.4
  IN1 w0.089: v1(100.38,47.22) 98.6,47.22 98.43,47.04 98.43,46.65 98.61,46.47 98.61,46.27 98.3,45.96 98.3,43.83 95.33,40.86 92.4,40.86 92.24,40.71 92.24,40.25 92.09,40.09 86.43,40.09 65.72,19.39 65.72,14.6 v1(64.94,13.81)
  BOTTOM w0.076: 101.22,48.06 101.59,48.42 102.88,48.42 104.12,49.67 104.62,49.67 105.13,50.18 105.13,50.94 UC1.BB63
  BOTTOM w0.102: v1(64.94,13.81) 64.43,13.3 JDIMM1.58 ; 101.22,48.06 v1(100.38,47.22)
DDR_A_D40: length 63
  IN1 w0.089: v1(102.61,46.42) 102.32,46.71 101.84,46.71 101.44,46.32 101.44,45.08 101.23,44.87 101.23,44.63 95.19,38.58 89.26,38.58 89.08,38.4 89.08,37.98 88.91,37.81 86.63,37.81 67.87,19.05 67.87,16.74 68.43,16.18 68.43,15.96 68.34,15.87 67.79,15.87 67.48,15.56 67.48,14.05 v1(66.92,13.49)
  BOTTOM w0.076: v1(102.61,46.42) 103.05,46.86 103.05,47.64 104.39,48.98 104.87,48.98 105.82,49.93 105.82,51.18 106.08,51.45 UC1.BA61
  BOTTOM w0.102: v1(66.92,13.49) 66.43,13 JDIMM1.66
DDR_A_D41: length 64.4
  IN1 w0.089: v1(102.61,47.73) 102.28,47.73 101.08,46.53 101.08,45.2 100.89,45 100.89,44.72 95.06,38.89 88.72,38.89 88.62,38.78 88.62,38.22 88.51,38.11 88.37,38.11 88.26,38.22 88.26,38.71 88.16,38.81 88.01,38.81 87.91,38.71 87.91,38.22 87.8,38.11 86.5,38.11 67.49,19.1 67.49,16.15 66.87,15.53 v1(66.87,15.01)
  BOTTOM w0.076: v1(102.61,47.73) 102.9,47.73 104.35,49.17 104.83,49.17 105.65,50 105.65,51.7 105.86,51.91 105.86,52.46 106.18,52.78 UC1.AW61
  BOTTOM w0.102: JDIMM1.70 67.43,13.55 67.43,13.55 67.43,14.46 v1(66.87,15.01)
DDR_A_D42: length 63
  IN1 w0.089: v1(104.46,44.77) 95.4,35.71 87.52,35.71 70.75,18.94 70.75,15.05 70.9,14.91 71.1,14.91 71.25,15.05 71.25,16.26 71.5,16.51 v1(71.73,16.51)
  BOTTOM w0.076: 104.96,46.32 105.36,46.71 105.36,47.88 107.51,50.03 107.51,50.92 UC1.BB59
  BOTTOM w0.102: JDIMM1.79 69.68,19.1 69.79,18.99 69.79,17.83 71.11,16.51 v1(71.73,16.51) ; 104.96,46.32 104.85,46.2 104.85,45.16 v1(104.46,44.77)
DDR_A_D43: length 65.1
  IN1 w0.089: v1(104.44,45.36) 103.58,44.5 103.58,44.42 95.19,36.02 87.4,36.02 70.45,19.07 70.45,14.65 70.54,14.56 71.02,14.56 71.16,14.42 71.16,14.24 71.02,14.1 70.42,14.1 70.33,14.01 70.33,13.76 70.65,13.44 v1(71.79,13.44)
  BOTTOM w0.076: UC1.AW59 106.76,52.97 106.55,52.77 106.48,52.67 106.48,51.9 106.52,51.8 106.52,51.53 106.48,51.45 106.48,51.25 106.52,51.16 106.52,50.8 106.31,50.6 106.31,49.73 105.07,48.49 104.61,48.49 103.94,47.82 103.94,46.54
  BOTTOM w0.102: v1(104.44,45.36) 103.94,45.86 103.94,46.54 ; v1(71.79,13.44) 71.64,13.44 70.93,12.72 JDIMM1.84
DDR_A_D44: length 62.6
  IN1 w0.089: v1(68.85,16.46) 68.68,16.46 68.3,16.84 68.3,19.05 86.75,37.5 89.31,37.5 89.42,37.61 89.42,38.02 89.52,38.13 89.67,38.13 89.77,38.02 89.77,37.61 89.88,37.5 90.02,37.5 90.13,37.61 90.13,38.15 90.23,38.25 90.38,38.25 90.48,38.15 90.48,37.61 90.59,37.5 90.73,37.5 90.84,37.61 90.84,38.15 90.94,38.25 95.29,38.25 101.54,44.5 101.54,44.72 101.85,45.03 101.85,45.29 102.31,45.75 v1(102.61,45.75)
  BOTTOM w0.076: 103.31,47.42 103.31,47.67 104.46,48.82 104.94,48.82 105.98,49.86 105.98,50.92 UC1.BB61
  BOTTOM w0.102: JDIMM1.67 66.68,18.63 v1(68.85,16.46) ; 103.31,47.42 103.31,46.45 v1(102.61,45.75)
DDR_A_D45: length 63.9
  IN1 w0.089: v1(68.8,17.99) 69.24,18.42 69.24,19.55 86.88,37.2 91.04,37.2 91.14,37.3 91.14,37.82 91.25,37.92 91.4,37.92 91.5,37.82 91.5,37.3 91.6,37.2 91.75,37.2 91.86,37.3 91.86,37.84 91.96,37.95 92.11,37.95 92.21,37.84 92.21,37.3 92.31,37.2 92.46,37.2 92.57,37.3 92.57,37.84 92.67,37.95 92.82,37.95 92.92,37.84 92.92,37.3 93.03,37.2 93.17,37.2 93.28,37.3 93.28,37.84 93.38,37.95 93.53,37.95 93.63,37.84 93.63,37.3 93.74,37.2 93.88,37.2 93.99,37.3 93.99,37.84 94.09,37.95 94.24,37.95 94.34,37.84 94.34,37.3 94.45,37.2 94.66,37.2 102.01,44.54 v1(102.01,44.58)
  BOTTOM w0.076: 103.61,46.32 103.61,47.72 104.54,48.65 105.01,48.65 106.15,49.79 106.15,50.66 106.35,50.87 106.35,51.12 106.31,51.21 106.31,51.48 106.35,51.57 106.35,51.77 106.32,51.86 106.28,51.96 106.28,52.22 UC1.AY61
  BOTTOM w0.102: v1(102.01,44.58) 102.03,44.6 102.3,44.6 103.61,45.91 103.61,46.32 ; JDIMM1.71 67.68,18.65 68.34,17.99 v1(68.8,17.99)
DDR_A_D46: length 63.9
  IN1 w0.089: v1(104.46,43.58) 103.83,43.58 95.63,35.38 87.64,35.38 73.23,20.98 73.23,20.38 73.15,20.29 72.82,20.29 72.73,20.2 72.73,20.02 72.82,19.93 73.25,19.93 73.34,19.84 73.34,19.67 73.25,19.58 71.86,19.58 71.77,19.49 71.77,19.31 71.86,19.22 73.22,19.22 73.3,19.13 73.3,18.96 73.22,18.87 72.69,18.87 72.6,18.78 72.6,18.6 72.69,18.51 73.15,18.51 73.23,18.42 73.23,17.2 73.08,17.04 72.86,17.04 72.7,17.2 72.7,17.81 72.57,17.94 v1(71.16,17.94)
  BOTTOM w0.076: 105.45,46.32 105.52,46.39 105.52,47.76 107.68,49.92 107.68,51.12 107.62,51.27 UC1.BA59
  BOTTOM w0.102: JDIMM1.83 70.68,18.42 v1(71.16,17.94) ; v1(104.46,43.58) 105.27,44.4 105.27,46.14 105.45,46.32
DDR_A_D47: length 64.6
  IN1 w0.089: v1(71.85,14.96) 72.29,15.41 73.59,15.41 73.74,15.56 73.74,16.03 73.64,16.13 72.65,16.13 72.55,16.24 72.55,16.38 72.65,16.49 73.64,16.49 73.74,16.59 73.74,21.06 87.76,35.08 95.8,35.08 103.44,42.72 v1(103.62,42.72)
  BOTTOM w0.076: UC1.AY59 107.41,52.12 107.68,51.85 107.68,51.66 107.81,51.23 107.84,51.15 107.84,49.83 105.77,47.75 105.77,46.32
  BOTTOM w0.102: JDIMM1.80 69.93,12.83 70.03,12.93 70.03,13.25 71.74,14.96 v1(71.85,14.96) ; 105.77,46.32 105.77,46.08 105.73,46.05 105.73,44.07 104.36,42.7 103.64,42.7 v1(103.62,42.72)
DDR_A_D48: length 52
  IN4 w0.076: 101.32,53.51 102.25,54.44
  IN4 w0.089: 102.25,54.44 v1(102.74,54.44) ; 101.32,53.51 101.32,52.7 98.79,50.17 97.17,50.17 95.97,48.97 95.97,47.57 95.78,47.38 95.78,30.14 95.93,29.98 96.08,29.98 96.45,30.36 96.6,30.36 96.71,30.26 96.71,30.11 96.33,29.73 96.33,29.58 96.43,29.48 96.58,29.48 96.96,29.86 97.1,29.86 97.21,29.75 97.21,29.61 96.83,29.23 96.83,29.08 96.94,28.98 97.08,28.98 97.46,29.35 97.61,29.35 97.71,29.25 97.71,29.1 97.33,28.73 97.33,28.58 97.44,28.47 97.59,28.47 97.96,28.85 98.11,28.85 98.21,28.75 98.21,28.6 97.84,28.22 97.84,28.07 97.94,27.97 98.09,27.97 98.47,28.35 98.61,28.35 98.72,28.24 98.72,28.1 98.34,27.72 98.34,27.57 104.84,21.07 v1(104.84,18.6)
  BOTTOM w0.076: v1(102.74,54.44) 103.08,54.79 UC1.AT66
  BOTTOM w0.102: JDIMM1.211 104.68,18.76 v1(104.84,18.6)
DDR_A_D49: length 51.4
  IN4 w0.089: v1(104.96,17.06) 105.83,16.19 106.04,16.19 106.19,16.34 106.19,16.55 105.27,17.47 105.27,21.08 98.92,27.42 98.92,27.67 99.24,27.99 99.24,28.15 96.08,31.31 96.08,47.12 96.28,47.32 96.28,48.85 97.37,49.94 98.87,49.94 99.51,50.58 102.19,53.26 102.19,53.8 102.31,53.91 102.63,53.91 v1(102.74,53.81)
  BOTTOM w0.076: UC1.AU66 v1(102.74,53.81)
  BOTTOM w0.102: v1(104.96,17.06) 105.68,17.78 JDIMM1.215
DDR_A_D50: length 54.7
  IN4 w0.076: 98.99,47.62 98.99,47.8 99.24,48.05 99.24,48.92 ; v1(103.65,56.35) 104.03,55.97 104.03,54.77 104.18,54.62 104.18,52.66 103.32,51.8
  IN4 w0.089: 99.24,48.92 101.26,50.95 102.21,50.95 103.06,51.8 103.32,51.8 ; 98.99,47.62 98.99,47.29 98.62,46.92 98.62,31.33 104.93,25.02 104.93,24.88 104.53,24.48 104.53,24.33 104.64,24.23 104.78,24.23 105.18,24.63 105.33,24.63 105.43,24.52 105.43,24.37 105.04,23.98 105.04,23.83 105.14,23.73 105.29,23.73 105.68,24.12 105.83,24.12 105.93,24.02 105.93,23.87 105.54,23.48 105.54,23.33 105.64,23.22 105.79,23.22 105.94,23.38 106.09,23.38 106.19,23.27 106.19,23.13 106.04,22.97 106.04,22.83 107.18,21.69 107.18,19.44 107.84,18.78 107.84,18.01 v1(108.98,16.87)
  BOTTOM w0.076: v1(103.65,56.35) 103.91,56.09 UC1.AP65
  BOTTOM w0.102: JDIMM1.225 108.18,19.73 108.18,19.73 108.18,17.5 108.8,16.87 v1(108.98,16.87)
DDR_A_D51: length 55.2
  IN4 w0.076: v1(103.65,56.98) 103.9,56.98 104.2,56.69 104.2,54.92 104.35,54.77 104.35,52.4 103.6,51.65
  IN4 w0.089: v1(109.03,18.42) 109.03,18.23 108.79,17.99 108.37,17.99 108.14,18.22 108.14,19.69 108.04,19.8 107.59,19.8 107.48,19.9 107.48,20.05 107.59,20.15 108.04,20.15 108.14,20.26 108.14,20.47 108.03,20.59 107.59,20.59 107.48,20.69 107.48,20.84 107.59,20.94 108.03,20.94 108.13,21.05 108.13,21.19 108.03,21.3 107.59,21.3 107.48,21.4 107.48,21.55 107.59,21.65 108.03,21.65 108.13,21.76 108.13,22.26 107.86,22.53 107.71,22.53 107.31,22.13 107.16,22.13 107.06,22.24 107.06,22.39 107.46,22.78 107.46,22.93 107.35,23.04 107.21,23.04 106.81,22.64 106.66,22.64 106.56,22.74 106.56,22.89 106.96,23.29 106.96,23.43 98.92,31.47 98.92,46.72 99.29,47.09 99.29,47.66 99.56,47.93 99.56,48.81 101.39,50.64 102.59,50.64 103.6,51.65
  BOTTOM w0.076: v1(103.65,56.98) 103.89,56.74 UC1.AN65
  BOTTOM w0.102: JDIMM1.229 109.18,19.67 109.18,19.67 109.18,18.56 v1(109.03,18.42)
DDR_A_D52: length 54.4
  IN4 w0.076: v1(102.74,56.35) 102.34,55.95 102.34,55.04 100.89,53.59 100.89,53.45 99.56,52.12 98.53,52.12 97.84,51.43 96.65,51.43 95.97,50.76 95.85,50.76
  IN4 w0.089: v1(105.45,13.67) 105.08,13.67 104.57,14.17 104.57,15.85 104.12,16.3 104.12,20.93 95.17,29.88 95.17,47.63 95.33,47.8 95.33,49.46 95.39,49.53 95.39,50.37 95.78,50.76 95.85,50.76
  BOTTOM w0.076: UC1.AN66 103.13,56.74 v1(102.74,56.35)
  BOTTOM w0.102: v1(105.45,13.67) 105.93,13.19 105.93,12.05 105.93,12.05 JDIMM1.216
DDR_A_D53: length 53.8
  IN4 w0.089: v1(105.22,15.17) 104.94,15.45 104.94,15.71 105.03,15.8 105.36,15.8 105.48,15.92 105.48,16.09 105.36,16.21 104.82,16.21 104.44,16.59 104.44,21.04 95.47,30.01 95.47,47.51 95.65,47.68 95.65,49.09 96.97,50.42 98.65,50.42 101.07,52.83 101.07,53.52 102.56,55.02 102.56,55.54 v1(102.74,55.71)
  BOTTOM w0.076: UC1.AP66 v1(102.74,55.71)
  BOTTOM w0.102: v1(105.22,15.17) 105.04,15.17 104.81,14.94 104.81,13.13 104.93,13.02 104.93,11.8 JDIMM1.212
DDR_A_D54: length 53.3
  IN4 w0.076: 102.14,51.12 101.19,51.12 99.62,49.56 99.47,49.56 98.92,49.01 98.92,48.24 98.65,47.96 ; 103.33,52.05 104.02,52.74 104.02,54.07 v1(103.65,54.44)
  IN4 w0.089: 102.14,51.12 103.07,52.05 103.33,52.05 ; v1(108.55,15.47) 108.35,15.27 107.94,15.27 107.53,15.67 107.53,18.65 106.77,19.42 106.77,21.67 103.99,24.44 103.99,24.59 104.39,24.98 104.39,25.13 104.29,25.23 104.14,25.23 103.74,24.84 103.6,24.84 103.49,24.94 103.49,25.09 103.89,25.49 103.89,25.63 98.3,31.22 98.3,47.05 98.58,47.33 98.58,47.9 98.65,47.96
  BOTTOM w0.076: UC1.AT65 104,54.79 v1(103.65,54.44)
  BOTTOM w0.102: v1(108.55,15.47) 107.93,14.85 107.93,11.8 JDIMM1.224
DDR_A_D55: length 52.6
  IN4 w0.076: v1(103.65,53.81) 103.65,52.8 103.07,52.22 101.9,52.22 98.67,48.98 98.14,48.98 98.05,48.89
  IN4 w0.089: v1(108.55,13.95) 107.23,15.27 107.23,18.53 106.46,19.29 106.46,21.54 102.91,25.09 102.91,25.23 103.2,25.52 103.2,25.67 103.1,25.77 102.95,25.77 102.67,25.49 102.52,25.49 102.41,25.59 102.41,25.74 102.8,26.13 102.8,26.27 97.25,31.82 97.25,46.64 97.5,46.88 97.5,48.35 98.05,48.89
  BOTTOM w0.076: UC1.AU65 103.98,54.14 v1(103.65,53.81)
  BOTTOM w0.102: v1(108.55,13.95) 108.75,13.95 109.06,13.64 109.06,13.06 108.93,12.93 108.93,11.98 108.93,11.98 JDIMM1.228
DDR_A_D56: length 52.5
  IN4 w0.076: 105.05,54.02 v1(105.48,54.44)
  IN4 w0.089: v1(111.24,16.92) 111.01,16.68 110.61,16.68 110.45,16.84 110.45,17.21 110.57,17.33 110.73,17.33 110.84,17.43 110.84,17.67 110.45,18.06 110.45,18.37 110.7,18.62 110.7,19.16 110.57,19.29 110.42,19.29 110.2,19.08 110.03,19.08 109.92,19.19 109.92,19.35 110.4,19.83 110.4,19.97 110.29,20.08 110.14,20.08 109.67,19.6 109.51,19.6 109.39,19.71 109.39,19.88 109.78,20.27 109.78,20.59 109.36,21.01 109.36,22.86 100.55,31.67 100.55,45.09 100.76,45.31 100.76,45.94 101.08,46.27 101.08,48.94 101.39,49.24 102.32,49.24 103.77,50.69 103.77,50.93 104.93,52.09 104.93,53.89 105.05,54.02
  BOTTOM w0.076: v1(105.48,54.44) 105.83,54.79 UC1.AT61
  BOTTOM w0.102: v1(111.24,16.92) 110.18,17.98 110.18,19.73 110.18,19.73 JDIMM1.233
DDR_A_D57: length 51.9
  IN4 w0.076: v1(105.48,53.81) 105.1,53.43 105.1,51.83 104.08,50.8
  IN4 w0.089: 104.08,50.8 104.02,50.74 104.02,50.47 102.49,48.94 101.8,48.94 101.39,48.53 101.39,46.14 101.07,45.82 101.07,45.18 100.85,44.96 100.85,36.95 100.96,36.85 101.42,36.85 101.52,36.74 101.52,36.59 101.42,36.49 100.96,36.49 100.85,36.39 100.85,36.24 100.96,36.13 101.42,36.13 101.52,36.03 101.52,35.88 101.42,35.78 100.96,35.78 100.85,35.67 100.85,35.53 100.96,35.42 101.42,35.42 101.52,35.32 101.52,35.17 101.42,35.07 100.96,35.07 100.85,34.96 100.85,34.82 100.96,34.71 101.42,34.71 101.52,34.61 101.52,34.46 101.42,34.36 100.96,34.36 100.85,34.25 100.85,34.1 100.96,34 101.42,34 101.52,33.9 101.52,33.75 101.42,33.64 100.96,33.64 100.85,33.54 100.85,33.39 100.96,33.29 101.42,33.29 101.52,33.19 101.52,33.04 101.42,32.93 100.96,32.93 100.85,32.83 100.85,32.68 100.96,32.58 101.42,32.58 101.52,32.47 101.52,32.33 101.42,32.22 100.96,32.22 100.85,32.12 100.85,31.9 109.67,23.09 109.67,21.13 111.01,19.79 111.01,18.68 v1(111.24,18.44)
  BOTTOM w0.076: UC1.AU61 105.81,54.14 v1(105.48,53.81)
  BOTTOM w0.102: JDIMM1.237 111.18,19.67 111.18,19.67 111.18,18.51 v1(111.24,18.44)
DDR_A_D58: length 55
  IN4 w0.076: 107.29,52.15 107.29,54.25 106.77,54.77 106.77,55.97 v1(106.39,56.35)
  IN4 w0.084: 104.96,49.34 104.96,49.35 105.91,50.3 105.91,50.77 107.29,52.15
  IN4 w0.089: 104.96,49.34 103.71,48.1 103.71,44.93 103.12,44.35 103.12,43.84 102.79,43.51 102.79,42.55 103.31,42.04 103.31,32.27 112.83,22.74 112.83,20.91 114.8,18.95 114.8,16.32 114.71,16.23 113.08,16.23 112.99,16.14 112.99,15.95 113.15,15.8 113.7,15.8 v1(114.06,15.45)
  BOTTOM w0.076: v1(106.39,56.35) 106.65,56.09 UC1.AP60
  BOTTOM w0.102: v1(114.06,15.45) 113.43,14.81 JDIMM1.246
DDR_A_D59: length 55.3
  IN4 w0.076: 104.01,47.48 104.01,48.16 105.13,49.28 ; 107.59,52.03 107.68,52.11 107.68,56.5 107.46,56.71 106.68,56.71 v1(106.39,57)
  IN4 w0.089: 107.59,52.03 106.21,50.65 106.21,50.36 105.13,49.28 ; 104.01,47.48 104.01,44.3 103.1,43.38 103.1,42.68 103.61,42.16 103.61,32.39 113.14,22.87 113.14,21.04 114.57,19.61 114.7,19.61 114.99,19.9 115.14,19.9 115.24,19.8 115.24,19.65 114.95,19.36 114.95,19.23 115.1,19.08 115.1,15.76 114.48,15.14 114.48,14.52 v1(114.85,14.15)
  BOTTOM w0.076: v1(106.39,57) 106.65,56.74 UC1.AN60
  BOTTOM w0.102: v1(114.85,14.15) 114.72,14.15 114.43,13.86 JDIMM1.250
DDR_A_D60: length 54.7
  IN4 w0.076: 100,48.67 101.12,49.78 102.36,49.78 ; 103.16,50.95 104.57,52.36 104.57,54.51 104.97,54.91 104.97,55.83 v1(105.48,56.35)
  IN4 w0.089: 102.36,49.78 103.16,50.58 103.16,50.95 ; v1(111.24,13.87) 110.32,13.87 110.16,14.02 110.16,14.24 110.32,14.4 110.55,14.4 110.67,14.52 110.67,14.69 110.55,14.81 110.15,14.81 109.84,15.12 109.84,18.4 108.75,19.49 108.75,22.6 99.94,31.42 99.94,43.83 99.52,44.24 99.52,46.43 99.9,46.8 99.9,48.56 100,48.67
  BOTTOM w0.076: UC1.AN61 105.87,56.74 v1(105.48,56.35)
  BOTTOM w0.102: v1(111.24,13.87) 110.93,13.55 110.93,11.8 JDIMM1.236
DDR_A_D61: length 54
  IN4 w0.076: v1(105.48,55.71) 105.48,55.01 104.75,54.28 104.75,52.21 103.47,50.92
  IN4 w0.089: v1(111.24,15.39) 110.28,15.39 110.15,15.53 110.15,15.71 110.28,15.85 110.68,15.85 110.8,15.97 110.8,16.14 110.68,16.26 110.24,16.26 110.15,16.35 110.15,18.53 109.06,19.62 109.06,22.73 100.24,31.55 100.24,45.23 100.46,45.45 100.46,46.07 100.78,46.39 100.78,48.96 101.36,49.54 102.37,49.54 103.47,50.64 103.47,50.92
  BOTTOM w0.076: UC1.AP61 105.86,56.09 v1(105.48,55.71)
  BOTTOM w0.102: v1(111.24,15.39) 109.93,14.08 109.93,11.98 109.93,11.98 JDIMM1.232
DDR_A_D62: length 54.5
  IN4 w0.076: 106.99,52.28 106.99,53.82 v1(106.39,54.42)
  IN4 w0.089: 106.99,52.28 105.61,50.89 105.61,50.25 103.4,48.05 103.4,45.06 102.82,44.47 102.82,43.97 102.35,43.5 102.35,42.02 103,41.37 103,32.14 111.94,23.2 111.94,23.04 111.84,22.94 111.41,22.94 111.31,22.83 111.31,22.69 111.41,22.58 111.84,22.58 111.94,22.48 111.94,22.17 112.11,22 112.42,22 112.51,21.91 112.51,21.74 112.42,21.65 112.07,21.65 111.98,21.56 111.98,21.38 112.07,21.29 112.4,21.29 112.49,21.2 112.49,20.83 112.88,20.44 112.88,20.31 112.54,19.97 112.54,19.81 112.65,19.7 112.77,19.7 113.13,20.06 113.26,20.06 113.38,19.93 113.38,19.81 112.96,19.39 112.96,19.26 113.09,19.14 113.21,19.14 113.63,19.56 113.76,19.56 114.49,18.82 114.49,16.7 114.4,16.61 114.16,16.61 114.06,16.72 114.06,18.01 113.88,18.19 v1(113.65,18.19)
  BOTTOM w0.076: v1(106.39,54.42) 106.77,54.79 UC1.AT60
  BOTTOM w0.102: v1(113.65,18.19) 113.83,18.19 114.18,18.53 JDIMM1.249
DDR_A_D63: length 53.6
  IN4 w0.076: v1(106.39,53.81) 106.39,52.11 105.3,51.02
  IN4 w0.089: 105.3,51.02 105.3,50.27 103.1,48.07 103.1,45.18 102.51,44.6 102.51,44.09 102.05,43.62 102.05,41.54 102.22,41.37 102.57,41.37 102.7,41.24 102.7,41.08 102.59,40.98 102.15,40.98 102.05,40.87 102.05,40.72 102.15,40.62 102.59,40.62 102.7,40.52 102.7,40.37 102.59,40.26 102.15,40.26 102.05,40.16 102.05,40.01 102.15,39.91 102.59,39.91 102.7,39.8 102.7,39.66 102.59,39.55 102.15,39.55 102.05,39.45 102.05,39.3 102.15,39.2 102.59,39.2 102.7,39.09 102.7,38.95 102.59,38.84 102.15,38.84 102.05,38.74 102.05,38.59 102.15,38.49 102.59,38.49 102.7,38.38 102.7,38.23 102.59,38.13 102.15,38.13 102.05,38.03 102.05,37.88 102.15,37.77 102.59,37.77 102.7,37.67 102.7,31.84 110.96,23.58 110.96,22.23 111.04,22.15 111.53,22.15 111.65,22.03 111.65,20.96 112.23,20.37 112.23,19.54 113.22,18.54 113.22,17.05 v1(113.6,16.67)
  BOTTOM w0.076: v1(106.39,53.81) 106.73,54.14 UC1.AU60
  BOTTOM w0.102: JDIMM1.245 113.18,19.67 113.18,19.67 113.18,17.09 v1(113.6,16.67)
DDR_A_DQS0: length 76.3
  IN1 w0.091: v1(93.63,56.75) 93.51,56.87 93.51,57.2 93.31,57.4 91.18,57.4 90.94,57.16 90.94,56.75 90.8,56.62 90.62,56.62 90.48,56.75 90.48,57.16 90.24,57.4 89.58,57.4 83.77,51.59 83.77,49.45 79.55,45.23 78.43,45.23 52.06,18.86 52.06,17.26 52.32,16.99 52.62,16.99 v1(52.82,16.79)
  BOTTOM w0.076: v1(93.63,56.75) 93.4,56.52 93.4,56.43 93.55,56.29 93.84,56.29 93.99,56.44 97.21,56.44 97.88,57.1 98.08,57.1 98.72,57.73 99.59,57.73 99.8,57.6 99.84,57.58 100.07,57.58 100.18,57.62 100.21,57.62 100.41,57.62 100.53,57.57 100.71,57.57 100.88,57.64 101.04,57.64 101.27,57.53 101.37,57.43 101.37,57.33 101.42,57.28 UC1.AM69
  BOTTOM w0.099: v1(52.82,16.79) 53.09,17.06 53.31,17.06 53.58,17.33 53.58,18.55 53.18,18.96 JDIMM1.13
DDR_A_DQS1: length 69.8
  IN1 w0.091: v1(95.19,52.37) 95.37,52.19 95.37,51.79 94.63,51.04 94.63,48.37 92.52,46.27 86.06,46.27 57.92,18.13 57.92,14.07 58.22,13.77 v1(58.97,13.77)
  BOTTOM w0.076: UC1.AT70 101.16,54.83 101.21,54.77 101.21,54.65 101.17,54.62 101,54.54 100.91,54.54 100.74,54.6 100.49,54.6 100.37,54.55 100.23,54.55 100.09,54.6 99.73,54.6 99.67,54.56 99.51,54.45 98.95,54.45 98.75,54.25 97.73,54.25 97.44,53.96 97.11,53.96 97.1,53.97 97.08,53.97
  BOTTOM w0.099: v1(58.97,13.77) 58.97,13.9 58.75,14.12 58.52,14.12 58.11,13.71 58.11,12.87 58.43,12.55 JDIMM1.34 ; v1(95.19,52.37) 95.38,52.55 95.38,53.06 96.29,53.97 97.08,53.97
DDR_A_DQS2: length 68.6
  IN4 w0.076: 92.52,54.09 92.68,54.09 92.69,54.09 92.83,54.09 93.73,53.2 95.47,53.2 96.04,53.77 98.58,53.77 98.83,54.03 99.27,54.03 100.24,55 100.24,56.27 102.16,58.19 102.45,58.19 102.69,58.43 102.69,58.43 102.7,58.44 103.17,58.44 v1(103.56,58.83)
  IN4 w0.091: v1(102.02,13.95) 102.02,14.99 101.72,15.29 101.4,15.29 101.24,15.45 101.24,19.4 97.87,22.77 97.87,24.04 91,30.91 91,42.28 86.34,46.94 86.34,50.96 89.47,54.09 92.52,54.09
  BOTTOM w0.076: UC1.AH65 103.87,59.14 v1(103.56,58.83)
  BOTTOM w0.099: JDIMM1.200 101.93,11.92 101.93,12.57 101.77,12.73 101.77,13.69 v1(102.02,13.95)
DDR_A_DQS3: length 72.2
  IN4 w0.076: 91.13,58.68 91.14,58.68 91.15,58.68 96.36,58.68 96.63,58.96 96.63,59.05 v1(96.88,59.31)
  IN4 w0.091: 91.13,58.68 88.96,58.68 82.47,52.18 82.47,44.89 87.33,40.03 87.33,28.21 92.87,22.67 92.87,22.33 92.22,21.69 92.22,21.5 92.35,21.36 92.54,21.36 93.19,22.01 93.53,22.01 93.77,21.77 93.77,21.43 93.12,20.79 93.12,20.6 93.26,20.46 93.45,20.46 94.09,21.11 94.43,21.11 96.27,19.27 96.27,17.8 96.37,17.7 96.56,17.7 96.69,17.82 v1(96.69,17.99)
  BOTTOM w0.076: v1(96.88,59.31) 96.79,59.31 96.53,59.05 96.53,58.94 96.67,58.8 97.62,58.8 98.36,59.55 99.7,59.55 99.79,59.6 100.09,59.6 100.23,59.56 100.37,59.56 100.49,59.61 100.74,59.61 100.91,59.54 101,59.54 101.17,59.62 101.21,59.66 101.21,59.78 101.16,59.83 UC1.AG70
  BOTTOM w0.099: v1(96.69,17.99) 96.76,17.91 96.76,17.66 96.61,17.5 96.31,17.5 96.19,17.63 96.19,18.79 96.68,19.27 JDIMM1.179
DDR_A_DQS4: length 64.7
  IN1 w0.091: v1(64.2,17.6) 64.47,17.33 64.59,17.33 64.74,17.49 64.74,19.79 86.06,41.11 89.88,41.11 90.02,41.24 90.02,41.61 90.25,41.85 90.59,41.85 90.83,41.61 90.83,41.24 90.97,41.11 91.16,41.11 91.29,41.24 91.29,41.61 91.53,41.85 94.75,41.85 96.61,43.7 96.78,43.87 96.78,44.17 96.62,44.32 96.62,44.93 97.09,45.39 97.57,45.39 v1(97.79,45.61)
  BOTTOM w0.076: 99.24,47.43 99.25,47.45 99.27,47.45 99.49,47.67 99.49,48.64 99.95,49.1 102.55,49.1 103.84,50.39 103.84,50.64 103.97,50.85 104,50.89 104,51.12 103.95,51.26 103.95,51.46 104,51.58 104,51.76 103.94,51.92 103.94,52.09 104.04,52.32 104.15,52.42 104.25,52.42 104.29,52.47 UC1.AY64
  BOTTOM w0.099: JDIMM1.55 63.68,18.91 63.59,18.83 63.48,18.83 63.36,18.71 63.36,17.59 63.74,17.21 63.96,17.21 64.2,17.45 v1(64.2,17.6) ; 99.24,47.43 98.57,46.76 98.57,45.7 98.2,45.33 97.98,45.33 97.79,45.52 v1(97.79,45.61)
DDR_A_DQS5: length 64
  IN1 w0.091: v1(104.44,47.22) 104.26,47.04 103.94,47.04 103.5,46.6 103.5,45.33 94.87,36.7 87.1,36.7 69.75,19.35 69.75,15.39 69.19,14.83 68.76,14.39 68.51,14.39 68.29,14.62 v1(68.29,14.73)
  BOTTOM w0.076: UC1.BA60 106.75,52.18 106.82,52.26 106.92,52.26 106.96,52.22 107.04,52.05 107.04,51.96 106.97,51.79 106.97,51.54 107.02,51.43 107.02,51.28 106.98,51.14 106.98,50.84 106.99,50.82 107.03,50.75 107.03,50.62 107.07,50.58 107.07,50.12 104.93,47.98 104.93,46.96 104.82,46.85 104.69,46.85 104.44,47.1 v1(104.44,47.22)
  BOTTOM w0.099: v1(68.29,14.73) 68.52,14.5 68.79,14.5 69.02,14.28 69.02,13.15 68.78,12.9 68.78,12.7 68.93,12.55 JDIMM1.76
DDR_A_DQS6: length 53.5
  IN4 w0.076: v1(103.65,55.71) 103.57,55.63 103.21,55.63 102.98,55.4 102.98,54.71 103.12,54.58 103.12,52.96 102.85,52.69 101.89,52.69 98.81,49.62 97.77,49.62 97.39,49.24 97.38,49.24 97.37,49.23
  IN4 w0.091: 97.37,49.23 96.8,48.66 96.8,47.14 96.58,46.92 96.58,31.54 100.02,28.1 100.02,27.91 99.75,27.64 99.75,27.3 99.98,27.06 100.32,27.06 100.6,27.33 100.79,27.33 100.92,27.2 100.92,27.01 100.65,26.74 100.65,26.4 100.89,26.16 101.23,26.16 101.5,26.43 101.69,26.43 101.82,26.3 101.82,26.11 101.59,25.87 101.59,25.46 105.78,21.26 105.78,17.65 106.05,17.39 106.33,17.39 v1(106.52,17.2)
  BOTTOM w0.076: UC1.AR65 103.92,55.44 v1(103.65,55.71)
  BOTTOM w0.099: v1(106.52,17.2) 106.7,17.38 106.93,17.38 107.21,17.65 107.21,18.54 107.03,18.72 107.03,19.13 107.18,19.28 JDIMM1.221
DDR_A_DQS7: length 53.7
  IN4 w0.076: 105.81,52.2 105.81,52.21 105.82,52.21 105.97,52.35 105.97,53.47 105.86,53.58 105.86,55.35 106.03,55.51 106.19,55.51 v1(106.39,55.71)
  IN4 w0.091: v1(112.92,13.84) 112.81,13.95 112.41,13.95 112.01,14.35 112.01,18.46 111.5,18.96 111.5,20.11 110.17,21.44 110.17,23.34 102.02,31.49 102.02,36.95 101.35,37.62 101.35,40.78 101.37,40.8 101.37,44.77 101.58,44.99 101.58,45.44 101.98,45.84 101.98,48.06 102.54,48.61 103.13,48.61 104.78,50.26 104.78,51.18 105.81,52.2
  BOTTOM w0.076: v1(106.39,55.71) 106.67,55.44 UC1.AR60
  BOTTOM w0.099: JDIMM1.242 112.43,12.49 112.17,12.75 112.17,14.04 112.45,14.32 112.7,14.32 112.92,14.1 v1(112.92,13.84)
DDR_A_DQS#0: length 76.3
  IN1 w0.091: v1(92.98,56.75) 93.06,56.75 93.33,57.03 93.33,57.12 93.24,57.22 91.25,57.22 91.12,57.09 91.12,56.67 90.88,56.43 90.54,56.43 90.3,56.67 90.3,57.09 90.17,57.22 89.65,57.22 83.95,51.52 83.95,49.37 79.63,45.05 78.51,45.05 52.24,18.78 52.24,17.33 52.4,17.17 52.69,17.17 52.85,17.33 v1(52.85,17.78)
  BOTTOM w0.076: v1(92.98,56.75) 93.24,56.5 93.24,56.36 93.48,56.12 93.91,56.12 94.06,56.27 97.28,56.27 97.95,56.94 98.15,56.94 98.78,57.57 99.55,57.57 99.71,57.46 99.79,57.41 100.09,57.41 100.23,57.46 100.37,57.46 100.49,57.41 100.74,57.41 100.91,57.47 101,57.47 101.17,57.39 101.21,57.36 101.21,57.23 101.16,57.18 UC1.AM70
  BOTTOM w0.099: JDIMM1.11 52.68,19.17 53.39,18.46 53.39,17.41 53.23,17.25 53.01,17.25 52.85,17.41 v1(52.85,17.78)
DDR_A_DQS#1: length 69.8
  IN1 w0.091: v1(58.99,14.46) 58.49,13.95 58.3,13.95 58.1,14.14 58.1,18.06 86.13,46.09 92.59,46.09 94.81,48.3 94.81,50.97 95.55,51.71 95.55,52.07 v1(95.84,52.37)
  BOTTOM w0.076: 97.08,53.79 97.1,53.79 97.11,53.8 97.51,53.8 97.79,54.08 98.79,54.08 98.82,54.08 99.02,54.29 99.56,54.29 99.78,54.43 100.07,54.43 100.21,54.38 100.41,54.38 100.53,54.44 100.71,54.44 100.88,54.37 101.04,54.37 101.27,54.48 101.37,54.58 101.37,54.72 101.48,54.83 UC1.AT69
  BOTTOM w0.099: v1(95.84,52.37) 95.79,52.37 95.56,52.59 95.56,52.99 96.36,53.79 97.08,53.79 ; v1(58.99,14.46) 58.84,14.3 58.44,14.3 57.93,13.78 JDIMM1.32
DDR_A_DQS#2: length 68.5
  IN4 w0.076: v1(102.95,58.85) 102.95,58.67 102.87,58.6 102.63,58.6 102.63,58.6 102.62,58.6 102.38,58.36 102.09,58.36 100.08,56.34 100.08,55.07 99.2,54.19 98.76,54.19 98.51,53.94 95.97,53.94 95.4,53.37 93.8,53.37 92.9,54.26 92.68,54.26 92.67,54.27
  IN4 w0.091: 92.67,54.27 89.39,54.27 86.16,51.03 86.16,46.86 90.82,42.2 90.82,30.83 97.69,23.96 97.69,22.7 101.06,19.32 101.06,15.37 101.33,15.11 101.62,15.11 101.83,14.9 101.83,14.34 101.44,13.95 v1(101.33,13.95)
  BOTTOM w0.076: UC1.AH66 103.22,59.13 v1(102.95,58.85)
  BOTTOM w0.099: v1(101.33,13.95) 101.39,13.95 101.58,13.75 101.58,12.74 101.43,12.59 JDIMM1.198
DDR_A_DQS#3: length 72.2
  IN4 w0.076: v1(96.23,59.31) 96.23,59.15 95.93,58.85 91.16,58.85 91.15,58.86 91.13,58.86
  IN4 w0.091: v1(96.66,17.12) 96.66,17.44 96.58,17.52 96.29,17.52 96.09,17.72 96.09,19.2 94.36,20.93 94.17,20.93 93.52,20.28 93.18,20.28 92.94,20.52 92.94,20.86 93.59,21.51 93.59,21.7 93.45,21.83 93.26,21.83 92.62,21.18 92.28,21.18 92.04,21.42 92.04,21.76 92.69,22.41 92.69,22.6 87.15,28.14 87.15,39.95 82.29,44.81 82.29,52.26 88.89,58.86 91.13,58.86
  BOTTOM w0.076: v1(96.23,59.31) 96.37,59.17 96.37,58.87 96.6,58.64 97.69,58.64 98.43,59.38 99.75,59.38 99.84,59.44 100.07,59.44 100.21,59.39 100.41,59.39 100.53,59.44 100.71,59.44 100.88,59.38 101.04,59.38 101.27,59.48 101.37,59.59 101.37,59.69 101.42,59.73 UC1.AG69
  BOTTOM w0.099: JDIMM1.177 96.18,19.8 96.18,19.8 96.18,19.05 96,18.88 96,17.55 96.24,17.32 96.47,17.32 v1(96.66,17.12)
DDR_A_DQS#4: length 64.7
  IN1 w0.091: v1(97.79,44.96) 97.54,45.21 97.16,45.21 96.8,44.85 96.8,44.4 96.96,44.24 96.96,43.79 94.83,41.67 91.6,41.67 91.47,41.53 91.47,41.17 91.23,40.93 90.89,40.93 90.65,41.17 90.65,41.53 90.52,41.67 90.33,41.67 90.2,41.53 90.2,41.17 89.96,40.93 86.13,40.93 64.92,19.72 64.92,17.41 64.66,17.15 64.43,17.15 v1(64.17,16.89)
  BOTTOM w0.076: 99.37,47.3 99.39,47.31 99.39,47.33 99.66,47.6 99.66,48.57 100.02,48.93 102.62,48.93 104,50.32 104,50.59 104.11,50.76 104.16,50.84 104.16,51.14 104.11,51.28 104.11,51.42 104.17,51.54 104.17,51.79 104.1,51.96 104.1,52.05 104.18,52.22 104.22,52.26 104.34,52.26 104.39,52.21 UC1.BA64
  BOTTOM w0.099: v1(97.79,44.96) 97.97,45.14 98.28,45.14 98.76,45.62 98.76,46.68 99.37,47.3 ; v1(64.17,16.89) 64.05,17.02 63.66,17.02 63.18,17.51 JDIMM1.53
DDR_A_DQS#5: length 64
  IN1 w0.091: v1(104.44,46.57) 104.44,46.64 104.22,46.86 104.02,46.86 103.68,46.52 103.68,45.25 94.95,36.52 87.18,36.52 69.93,19.28 69.93,15.32 69.32,14.7 68.83,14.21 68.56,14.21 v1(68.32,13.97)
  BOTTOM w0.076: UC1.AY60 106.85,52.47 106.89,52.42 106.99,52.42 107.1,52.32 107.2,52.09 107.2,51.93 107.14,51.76 107.14,51.58 107.19,51.46 107.19,51.26 107.14,51.12 107.14,50.89 107.16,50.85 107.2,50.8 107.2,50.69 107.24,50.65 107.24,50.05 105.1,47.91 105.1,46.89 104.89,46.68 104.55,46.68 v1(104.44,46.57)
  BOTTOM w0.099: JDIMM1.74 68.43,12.55 68.57,12.7 68.57,12.99 68.83,13.24 68.83,14.2 68.71,14.32 68.53,14.32 68.32,14.1 v1(68.32,13.97)
DDR_A_DQS#6: length 53.4
  IN4 w0.076: v1(103.65,55.08) 103.65,55.19 103.38,55.46 103.28,55.46 103.15,55.33 103.15,54.78 103.28,54.65 103.28,52.89 102.92,52.53 101.95,52.53 98.88,49.45 97.84,49.45 97.5,49.12 97.5,49.11 97.5,49.11
  IN4 w0.091: 97.5,49.11 96.98,48.59 96.98,47.07 96.76,46.84 96.76,31.62 100.2,28.18 100.2,27.84 99.93,27.56 99.93,27.38 100.06,27.24 100.25,27.24 100.52,27.51 100.86,27.51 101.1,27.27 101.1,26.93 100.83,26.66 100.83,26.47 100.96,26.34 101.15,26.34 101.42,26.61 101.76,26.61 102,26.37 102,26.03 101.77,25.8 101.77,25.53 105.96,21.34 105.96,17.73 106.13,17.57 106.29,17.57 106.52,17.79 v1(106.52,18.04)
  BOTTOM w0.076: UC1.AR66 103.29,55.44 v1(103.65,55.08)
  BOTTOM w0.099: JDIMM1.219 106.68,19.25 106.84,19.09 106.84,18.64 107.02,18.46 107.02,17.73 106.86,17.57 106.66,17.57 106.52,17.71 v1(106.52,18.04)
DDR_A_DQS#7: length 53.6
  IN4 w0.076: v1(106.39,55.08) 106.39,55.24 106.29,55.35 106.1,55.35 106.03,55.28 106.03,53.65 106.13,53.54 106.13,52.28 105.93,52.08
  IN4 w0.091: v1(112.94,14.63) 113.02,14.56 113.02,14.35 112.92,14.25 112.75,14.25 112.64,14.14 112.47,14.14 112.19,14.42 112.19,18.54 111.68,19.04 111.68,20.18 110.35,21.51 110.35,23.41 102.2,31.57 102.2,37.02 101.53,37.69 101.53,40.71 101.55,40.73 101.55,44.7 101.76,44.91 101.76,45.37 102.16,45.77 102.16,47.98 102.62,48.43 103.2,48.43 104.96,50.19 104.96,51.1 105.93,52.08
  BOTTOM w0.076: UC1.AR61 106.03,55.44 v1(106.39,55.08)
  BOTTOM w0.099: JDIMM1.240 111.93,11.8 111.93,12.57 111.98,12.63 111.98,14.12 112.37,14.51 112.82,14.51 v1(112.94,14.63)
