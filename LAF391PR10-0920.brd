# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MEM_INTERLEAVED: length 13.7
  BOTTOM w0.076: UC1.P2 140.18,66.39 140.41,66.39 140.67,66.5 140.85,66.68 142.24,66.68 142.3,66.61 142.44,66.61
  BOTTOM w0.102: 142.44,66.61 142.72,66.61 143.28,67.17 v2(143.43,67.17) 143.82,67.56 145.64,67.56 145.76,67.69 147.77,67.69 148.5,68.41 150.27,68.41 151.27,67.41 RC371.1 151.29,67.32 RC372.1
MEM_SMBCLK: length 36.2
  TOP w0.102: v1(137.55,66.2) 139.12,66.2 139.45,65.87 143.24,65.87 143.94,65.18 v2(144.12,65.18) 145.54,65.18 145.78,64.93 146.66,64.93 RC12.1 ; QC2.6 155.07,66.03 154.94,65.91 154.47,65.91 CC320.1 154.32,65.63 156.05,65.63 156.48,66.06 156.48,66.18 156.46,66.19 v1(156.46,67.19)
  IN4 w0.076: 139.47,66.2 v1(137.55,66.2)
  IN4 w0.089: 139.47,66.2 140.44,67.18 142.5,67.18 142.82,66.85 152.8,66.85 153.61,67.66 155.99,67.66 v1(156.46,67.19)
  BOTTOM w0.076: v1(137.55,66.2) 137.22,65.88 UC1.R7
MEM_SMBDATA: length 33.6
  TOP w0.102: v1(157.05,67.22) 157.26,67.22 157.37,67.33 QC2.3 ; v1(136.91,66.2) 136.91,66.14 137.34,65.71 138.93,65.71 139.25,65.39 v2(139.62,65.39) 143.04,65.39 143.74,64.69 145.34,64.69 145.58,64.45 RC14.1
  IN4 w0.076: 139.47,65.73 139.39,65.81 137.42,65.81 137.02,66.2 v1(136.91,66.2)
  IN4 w0.089: v1(157.05,67.22) 157.05,66.82 156.74,66.51 156.32,66.51 155.63,67.19 153.81,67.19 152.99,66.38 142.63,66.38 142.3,66.71 140.64,66.71 139.66,65.73 139.47,65.73
  BOTTOM w0.076: v1(136.91,66.2) 136.86,66.2 136.57,65.91 UC1.R8
MPHYP_PWR_EN: length 6.6
  TOP w0.102: v1(134.77,57) 134.56,56.79 v2(134.15,56.79) 133.57,56.79 133.41,56.63 133.41,53.58 133.66,53.32 RC387.1
  BOTTOM w0.076: v1(134.77,57) 135.16,57.39 UC1.AM10
MSCLK: length 67.6
  TOP w0.102: UE1.H10 266.45,48.53 v1(266.84,48.14) ; RE72.2 234.67,11.55 234.67,13.23 234.03,13.88 RE30.1 233.02,14.96 233.22,15.16 v3(233.26,15.16) 234.24,15.16 235.02,15.94 v1(235.02,16.05)
  IN2 w0.122: v1(266.84,48.14) 266.84,47.84 267.24,47.44 267.24,45.54 267.01,45.31 267.01,44.94 266.05,43.98 266.05,41.8 264.27,40.01 264.27,39.24 263.7,38.67 263.7,37.53 261.98,35.81 260.99,35.81 260.84,35.66 258.22,35.66 256.13,33.56 256.13,31.84 254,29.71 254,26.36 253.48,25.84 253.48,24.23 253.17,23.91 253.17,23.24 251.63,21.7 250.44,21.7 248.92,20.17 244.24,20.17 243.77,20.65 240.29,20.65 237.24,17.59 237.24,16.68 237.48,16.44 237.48,15.93 237.13,15.58 235.23,15.58 235.02,15.79 v1(235.02,16.05)
  BOTTOM w0.102: JDEG1.6 234.91,14.31 235.02,14.41 v1(235.02,16.05)
MSDATA: length 73.5
  TOP w0.102: v1(266.04,48.93) 265.64,49.33 UE1.G9 ; v1(234.43,16.04) 234.04,15.64 232.93,15.64 232.67,15.38 231.7,15.38 v3(231.47,15.15) 231.3,14.98 231.3,14.19 RE86.1 231.14,13.41 231.14,12.61 232.45,11.3 RE75.2
  IN2 w0.122: v1(266.04,48.93) 266.43,49.32 267.76,49.32 268.09,48.99 268.09,46.78 267.69,46.39 267.69,44.61 266.8,43.72 266.8,41.49 266.2,40.88 266.2,39.11 265.49,38.4 265.49,37.56 264.55,36.62 263.88,36.62 262.31,35.05 261.42,35.05 261.17,34.79 261.17,34.08 261.04,33.96 259.36,33.96 255.68,30.27 255.68,27.78 255.49,27.59 255.49,24.24 253.38,22.13 253.38,20.99 252.4,20.01 250.72,20.01 250.13,19.42 240.13,19.42 239.09,18.38 239.09,16.25 237.92,15.08 234.98,15.08 234.43,15.63 v1(234.43,16.04)
  BOTTOM w0.102: JDEG1.7 234.42,16.02 v1(234.43,16.04)
MUX1_DP_SEL: length 24.2
  TOP w0.076: RT89.1 21,62.53 v1(20.63,62.53)
  TOP w0.102: UT9.23 28.4,79.4 v1(28.48,79.47)
  IN4 w0.089: v1(28.48,79.47) 27.83,78.83 25.62,78.83 25.33,78.53 25.33,74.67 25.81,74.18 25.81,70.38 25.07,69.64 25.07,67.86 22.92,65.71 22.92,63.93 21.52,62.53 v1(20.63,62.53)
MUX1_DPEQ0: length 4.7
  TOP w0.102: UT9.14 v1(30.66,75.28)
  BOTTOM w0.102: v1(30.66,75.28) 30.77,75.18 RT140.1 RT306.1 RT139.1 33.67,75.78 34.07,75.78 v2(34.22,75.93)
MUX1_DPEQ1: length 9.2
  TOP w0.102: RT247.1 RT248.1 RT303.1 22.61,69.37 23.15,68.83 v2(23.49,68.83) 24.57,68.83 24.74,69.01 25.58,69.01 25.91,69.34 25.91,71.16 26.8,72.05 UT9.2
MUX1_FLIP_SEL: length 63.3
  TOP w0.102: RT410.1 32.91,80.54 RT411.2 32.59,80.54 v1(32.19,80.95) ; v1(33.39,65.83) RT69.2 ; v1(30.15,79.76) 30.15,79.48 UT9.21 ; v1(20.73,63.42) 20.39,63.42 20.25,63.56 19.85,63.56 19.61,63.8 19.61,64.51 RT375.1
  IN2 w0.122: v1(20.73,63.42) 21.05,63.11 21.05,61.55 19.87,60.37 19.87,59.36 20.5,58.72 21.65,58.72 24.28,56.09 31.16,56.09 33.01,57.94 33.01,60.73 33.84,61.56 33.84,65.52 33.52,65.83 v1(33.39,65.83)
  IN4 w0.089: v1(30.15,79.76) 29.5,79.76 29.13,80.14 27.65,80.14 26.85,79.35 25.28,79.35 24.03,78.1 24.03,75.15 25.33,73.86 25.33,71.77 23.84,70.28 23.84,67.71 22.85,66.72 22.22,66.72 21.19,65.69 21.19,63.88 v1(20.73,63.42)
  BOTTOM w0.102: v1(32.19,80.95) 31.75,81.38 31.35,81.38 31.12,81.15 31.12,81.05 30.15,80.08 v1(30.15,79.76)
MUX1_FLIP_SEL_R: length 40
  TOP w0.076: UT5.B2 28.94,64.06 28.94,65.12 29.12,65.29 30.63,65.29 31,65.67
  TOP w0.102: v1(19.11,73.96) 18.67,74.39 RT417.1 RT405.2 ; RT69.1 v1(31.17,65.83) 31,65.67
  IN4 w0.089: v1(31.17,65.83) 29.83,65.83 28.56,64.56 26.41,64.56 23.45,61.61 20.87,61.61 19.68,60.42 19.68,59.17 19.09,58.57 18.36,58.57 17.41,59.53 17.41,63.73 19.12,65.45 19.12,67.18 19.97,68.03 19.97,73.1 v1(19.11,73.96)
MUX1_I2C_EN: length 6.5
  TOP w0.102: UT9.17 v1(30.66,76.48)
  BOTTOM w0.102: CT213.1 32.87,78.48 33.08,78.28 RT145.1 RT301.1 RT300.1 30.99,77.85 30.66,77.52 v1(30.66,76.48) 30.3,76.48 30.03,76.76 v2(30.03,77.01)
MUX1_SSEQ0: length 3.9
  TOP w0.102: UT9.11 v1(30.66,74.08)
  BOTTOM w0.102: v2(30.15,74.08) v1(30.66,74.08) 30.92,74.34 RT137.1 RT138.1 RT302.1
MUX1_SSEQ1: length 12.3
  TOP w0.102: UT9.3 27.2,72.13 26.14,71.07 26.14,69.11 v2(25.76,68.73) 25.53,68.5 23.16,68.5 22.9,68.75 21.8,68.75 21.54,68.5 21.14,68.5 20.83,68.8 RT135.1 RT136.1 RT305.1
MUX1_USB_EQ0: length 9.1
  TOP w0.102: RT417.2 17.76,74.19 18.65,73.3 19.49,73.3 19.85,73.66 RT304.1 RT144.1 RT143.1 21.87,73.76 v2(24.48,73.76) 24.74,73.76 25.07,74.08 UT9.38
MUX1_USB_EQ1: length 7.5
  TOP w0.102: RT418.2 19.31,76.37 19.61,76.07 RT141.1 RT142.1 RT307.1 22.58,76.07 23.05,75.6 24.32,75.6 v2(24.59,75.33) 24.64,75.28 UT9.35
MUX1_USB_SEL: length 32.2
  TOP w0.102: RT376.1 19.36,63.9 19.36,63.29 v2(19.57,63.08) v1(20.12,63.08) 20.19,63.01 20.96,63.01 21.02,63.08 RT90.2 ; v1(29.16,79.46) 28.8,79.1 UT9.22
  IN4 w0.089: v1(20.12,63.08) 20.52,63.08 20.61,62.99 21.21,62.99 22.28,64.05 22.28,65.72 24.06,67.5 24.06,70.16 25.58,71.67 25.58,73.99 24.26,75.31 24.26,77.9 25.4,79.04 26.98,79.04 27.82,79.88 28.74,79.88 v1(29.16,79.46)
  BOTTOM w0.102: RT412.2 31.12,81.83 RT413.1 29.75,80.46 29.75,79.78 29.43,79.46 v1(29.16,79.46)
NB_MUTE#: length 92.7
  TOP w0.076: 260.91,55.93 260.91,55.42 261.04,55.29 261.04,55.24 261.62,54.66 UE1.A4
  TOP w0.102: 260.91,55.93 260.91,56.33 v1(261.04,56.46) ; RA48.1 257.05,24.63 v1(256.6,24.18) 256.15,24.62 DA8.1
  IN3 w0.122: v1(256.6,24.18) 258.16,24.18 260.23,26.25 267,26.25 267.46,26.71 271.7,26.71 v1(272.53,27.54)
  BOTTOM w0.102: v1(261.04,56.46) 262.2,57.62 262.2,59.66 264.2,61.67 270.26,61.67 270.67,61.26 271.94,61.26 272.62,61.95 276.13,61.95 280.85,57.22 280.85,54.15 279.4,52.7 279.4,51.79 281.23,49.96 281.23,46.08 279.46,44.31 279.46,41.53 278.55,40.63 278.55,39.48 279.25,38.78 281.77,38.78 283.65,36.9 283.65,34.97 281.23,32.56 v2(281.23,32.19) 281.23,31.92 279.71,30.4 279.71,28.01 278.07,26.38 275.16,26.38 274.44,27.1 272.98,27.1 v1(272.53,27.54)
NB_PSID: length 11.5
  TOP w0.508: v1(40.47,92.83) v2(41.37,91.93) PD4.3 PD4.2 42.24,87.7 42.64,88.09 PL3.2
  BOTTOM w0.508: v1(40.47,92.83) 40.5,92.8 PJPDC1.5
NGFF_CONFIG_0: length 21.3
  TOP w0.076: 267.14,42.85 266.63,43.35 266.63,43.69 265.79,44.53 UE1.N9
  TOP w0.102: v1(264.11,30.04) 264.37,30.3 264.37,30.3 265.43,31.36 265.43,31.55 265.43,31.91 265.82,32.29 266.05,32.29 266.58,32.82 266.58,35.4 266.99,35.81 v2(267.39,35.81) 269.28,35.81 269.52,36.05 RPE9.3 269.52,36.85 269.68,37 269.68,38.34 267.77,40.25 267.77,41.45 267.16,42.06 267.16,42.83 267.14,42.85
  BOTTOM w0.102: JNGFF2.21 263.75,29.71 264.09,30.04 v1(264.11,30.04)
NGFF_CONFIG_1: length 23.4
  TOP w0.076: 267.71,42.85 267.71,43.71 267.19,44.22 267.09,44.22 266.76,44.56 266.76,45 UE1.M10
  TOP w0.102: 267.71,42.85 267.71,42.16 268.34,41.52 268.34,40.61 270.31,38.64 270.31,37 270.52,36.8 RPE9.1 270.74,36.32 271.2,35.86 271.2,35.43 271.84,34.79 v2(271.84,34.62) v1(271.84,33.65)
  BOTTOM w0.102: v1(271.84,33.65) 271.4,33.65 270.95,33.19 270.95,32.69 271.45,32.18 271.45,31.92 272.85,30.53 273.61,30.53 274.12,31.03 274.88,31.03 275.75,30.17 JNGFF2.69
NGFF_CONFIG_2: length 22.9
  TOP w0.076: 267.47,42.85 266.8,43.51 266.8,43.76 266.42,44.13 UE1.N10
  TOP w0.102: v1(271.35,32.94) 271.4,32.99 271.4,34.87 270.93,35.34 270.93,35.51 270.7,35.73 270.31,35.73 270.02,36.03 RPE9.2 270.02,36.71 270.06,36.75 270.06,38.43 v2(269.61,38.88) 268.04,40.45 268.04,41.51 267.47,42.08 267.47,42.85
  BOTTOM w0.102: JNGFF2.75 277.25,29.76 277.12,29.89 276.53,29.89 276.03,30.4 276.03,30.53 275.14,31.42 273.99,31.42 273.49,30.91 272.79,30.91 271.84,31.87 271.84,32.56 271.45,32.94 v1(271.35,32.94)
NGFF_CONFIG_3: length 35.7
  TOP w0.102: v1(258.75,30.55) 258.75,30.78 258.96,30.98 261.09,30.98 v2(262.15,29.92) 262.44,29.64 263.5,29.64 263.68,29.82 263.68,30.18 263.71,30.21 263.71,30.21 263.95,30.45 263.95,30.45 264.02,30.53 264.28,30.53 265.21,31.45 265.21,32 265.73,32.52 265.96,32.52 266.35,32.91 266.35,35.51 267.17,36.32 RPE9.4 269.02,36.98 269.22,37.18 v1(269.22,37.56) ; UE1.F4 v1(262.04,49.72)
  BOTTOM w0.102: v1(262.04,49.72) 262.41,49.34 262.41,49.1 262.41,46.33 264.77,43.97 264.77,42.23 264.62,42.08 264.62,40.49 265.13,39.98 265.46,39.98 267.46,37.97 268.71,37.97 269.12,37.56 v1(269.22,37.56) ; JNGFF2.1 v1(258.75,30.55)
NRB_BIT: length 20
  TOP w0.102: v1(136.61,55.2) 136.23,55.2 136.1,55.33 136.1,57.29 136.4,57.59 136.82,57.59 137,57.41 137.64,57.41 138.36,56.69 139.31,56.69 141.22,54.78 147.59,54.78 147.83,55.03 148.16,55.03 149.04,55.9 v2(149.46,55.9) 149.65,55.9 150.25,56.5 150.44,56.5 RC186.1
  BOTTOM w0.076: UC1.AR7 136.84,55.44 v1(136.61,55.2)
NTC_GT: length 5.4
  TOP w0.102: PR635.2 73.11,63.7 v2(73.52,63.29)
  TOP w0.203: PU602.15 71.63,66.81 71.77,66.67 72.35,66.67 72.63,66.39 72.63,64.63 PR635.2
NVME_LED#: length 11.8
  TOP w0.102: v1(275.7,11.15) v2(275.7,10.56)
  IN1 w0.089: v1(275.7,11.15) 275.7,8.12 277.8,6.02 277.8,4.62 v1(278.69,3.73)
  BOTTOM w0.102: v1(278.69,3.73) 278.85,3.57 JNGFF3.10 ; v1(275.7,11.15) 275.9,11.35 275.9,11.86 275.77,11.98 RN100.1
ONE_DIMM#: length 25
  IN1 w0.089: v1(136.58,55.79) 136.72,55.79 137.04,55.47 137.04,54.96 137.29,54.71 137.93,54.71 138.1,54.53 138.61,54.53 138.85,54.29 141.77,54.29 142.22,53.84 145.58,53.84 146.35,53.08 151.07,53.08 152.54,51.61 v1(154.35,51.61)
  BOTTOM w0.076: UC1.AP7 136.88,56.09 v1(136.58,55.79)
  BOTTOM w0.102: v1(154.35,51.61) v2(153.92,52.04) 153.92,52.14 153.22,52.84 153.22,54.12 RC268.1 153.67,55.06 RC267.1
OTG_ID: length 3
  TOP w0.076: 27.62,58.89 27.62,58.97 27.44,59.15 27.44,59.44 27.69,59.69 UT5.E10
  TOP w0.102: 27.62,58.89 27.62,58.08 28,57.7 RT74.1
OTGEN/CMIN: length 3.2
  BOTTOM w0.203: PU901.20 28.5,43.84 28.44,43.9 27.2,43.9 PR919.2
  BOTTOM w0.254: PR919.2 26.38,43.08 PR960.2
PANEL_BKEN_EC: length 283.2
  TOP w0.102: v1(62,98.22) 62.13,98.09 64.09,98.09 64.47,97.71 64.47,97.1 64.24,96.87 64.24,96.14 64.7,95.68 64.7,94.04 v2(64.98,93.75) 65.35,93.39 67.37,93.39 67.57,93.6 69.47,93.6 69.85,93.98 70.9,93.98 71.26,93.61 71.26,92.94 72.35,91.85 DV2.2 ; v1(266.02,47.33) UE1.J9
  IN2 w0.122: v1(247.45,49.22) 246.82,48.59 245.55,48.59 245.27,48.31 244.57,48.31 242.14,45.87 241.71,45.87 240.85,45.01 240.85,45.01 238.5,42.66 237.74,42.66 234.96,39.88 234.12,39.88 233.88,39.65 232.95,39.65 232.39,39.09 231.79,39.09 231.35,38.64 231.35,38.36 231.1,38.11 226.66,38.11 225.78,37.23 212.78,37.23 211.54,38.48 206.1,38.48 204.65,39.93 203.37,39.93 202.2,41.1 198.14,41.1 187.88,51.37 187.88,55.04 184.32,58.59 184.32,61.23 182.33,63.23 182.33,63.69 172.36,73.65 172.36,77.21 170.77,78.81 170.12,78.81 169.4,79.53 169.09,79.53 166.2,82.42 165.31,82.42 164.89,82.84 164.89,87.07 163.3,88.66 163.3,91.74 162.65,92.4 157.86,92.4 152.8,97.46 143.13,97.46 141.5,99.09 138.46,99.09 137.99,99.56 136.33,99.56 135.86,99.09 131.6,99.09 131.13,99.56 129.44,99.56 128.96,100.05 127.21,100.05 118.75,108.5 113.16,108.5 111.3,110.37 107.87,110.37 106.56,109.06 105.7,109.06 105.2,108.56 100.79,108.56 98.47,110.88 85.29,110.88 83.89,109.47 79.41,109.47 77.8,107.86 72.51,107.86 71.91,108.46 67.45,108.46 67.1,108.46 67.1,108.46 66.81,108.46 64.65,106.3 64.65,102.49 63.3,101.14 63.3,98.68 62.84,98.22 v1(62,98.22)
  IN4 w0.089: v1(266.02,47.33) 265.65,47.71 265.07,47.71 264.81,47.96 264.81,49.96 264.64,50.14 264.29,50.14 263.96,50.47 263.96,50.69 263.72,50.94 261.89,50.94 261.66,50.7 261.66,50.39 261.66,50.38 261.66,49.56 261.42,49.32 260.79,49.32 260.41,48.94 256.85,48.94 255.99,49.81 254.54,49.81 254.06,49.32 253.19,49.32 252.71,49.81 248.59,49.81 248.01,49.22 v1(247.45,49.22)
PANEL_BKLEN: length 95.3
  TOP w0.102: DV2.3 72.35,93.55 73.11,94.31 73.72,94.31 74.31,93.72 74.71,93.72 75.11,93.32 75.26,93.32 75.8,92.78 76.84,92.78 77.5,93.44 77.5,94.89 78.31,95.7 79.46,95.7 79.91,96.15 80.66,96.15 81.72,97.21 81.72,99.49 82.15,99.92 82.48,99.92 82.86,99.54 82.86,97.66 86.11,94.41 86.57,94.41 87.28,93.7 v2(87.28,91.91) 87.28,91.13 87.98,90.43 v1(89.84,90.43)
  IN1 w0.089: v1(134.34,65.21) 133.96,64.83 133.29,64.83 133.18,64.94 127.46,64.94 125.31,67.1 122.3,67.1 121.84,67.56 121.84,68.39 121.34,68.88 115.88,68.88 115.75,69.01 107.5,69.01 106.76,69.74 106.76,75.3 103.87,78.19 103.87,78.6 103.25,79.22 103.25,82.24 101.98,83.51 101.98,88.42 100.17,90.23 93.07,90.23 92.47,90.83 90.56,90.83 90.16,90.43 v1(89.84,90.43)
  BOTTOM w0.076: v1(134.34,65.21) 134.34,65.26 133.97,65.63 UC1.R12
PBAT_CHARGER_SMBCLK: length 323.7
  TOP w0.076: 258.66,42.16 258.66,42.55 v1(258.97,42.87) 259.17,43.07 259.17,43.37 259.45,43.65 259.83,43.65 260.24,44.06 260.24,44.31 UE1.N2
  TOP w0.102: 258.66,42.16 RE43.1 ; PRP1.3 35.64,18.55 PD2.3 v1(36.29,17.24)
  IN1 w0.089: v1(36.29,17.24) 35.57,17.95 33.84,17.95 31.73,15.85 28.74,15.85 21.23,23.36 21.23,25.34 19.14,27.42 19.14,30.54 19.32,30.71 19.32,33.76 20.08,34.52 20.08,39.25 22.7,41.87 24.57,41.87 25,42.3 25.7,42.3 26.28,42.88 26.28,44.5 v1(25.49,45.29)
  IN2 w0.122: v1(258.97,42.87) 257.56,42.87 256.36,41.67 255.47,41.67 252.79,38.99 252.79,38.76 250.52,36.5 249.58,36.5 246.29,33.2 246.29,30.7 246.64,30.35 246.64,28.03 245.22,26.6 244.96,26.6 244.67,26.31 242.5,26.31 241.74,27.06 238.93,27.06 238.71,26.84 238.26,26.84 237.37,25.95 235.09,25.95 232.15,23.01 228.5,23.01 228.15,22.65 223.37,22.65 221.79,24.23 217.64,24.23 216.65,23.25 213.81,23.25 213.14,23.92 206.26,23.92 204.73,25.44 203.28,25.44 202.64,24.81 200.69,24.81 200.56,24.93 200.56,25.7 200.05,26.21 198.33,26.21 197.69,25.57 185.44,25.57 184.44,24.58 156.59,24.58 155,22.99 141.54,22.99 134.91,29.62 101.56,29.62 99.64,27.7 71.05,27.7 68.86,29.9 63.68,29.9 55.18,38.4 49.48,38.4 48.54,37.46 48.54,35.35 50.94,32.96 50.94,22.73 45.95,17.75 42.57,17.75 40.77,15.94 36.79,15.94 36.02,16.71 36.02,16.98 v1(36.29,17.24)
  BOTTOM w0.102: PR922.1 25.65,45.45 v1(25.49,45.29)
PBAT_CHARGER_SMBDAT: length 324.7
  TOP w0.076: 259.56,42.16 v1(259.56,42.87) 259.34,43.09 259.34,43.3 259.52,43.48 259.9,43.48 260.41,43.99 260.41,44.92 UE1.M3
  TOP w0.102: PRP1.2 35.14,18.05 PD1.2 v1(35.29,17.24) ; 259.56,42.16 259.56,42.16 RE37.1
  IN1 w0.089: v1(35.29,17.24) 35.06,17.47 34.02,17.47 31.92,15.38 28.54,15.38 20.76,23.16 20.76,25.14 18.67,27.22 18.67,30.73 18.85,30.91 18.85,33.96 19.61,34.72 19.61,39.44 22.51,42.34 24.37,42.34 24.8,42.77 25.5,42.77 25.81,43.08 25.81,44.17 v1(25.44,44.54)
  IN2 w0.122: v1(35.29,17.24) 35.52,17.02 35.52,16.5 36.58,15.44 40.97,15.44 42.78,17.24 46.16,17.24 51.44,22.53 51.44,33.17 49.05,35.56 49.05,37.25 49.69,37.89 54.97,37.89 63.47,29.39 68.65,29.39 70.84,27.2 99.85,27.2 101.77,29.12 134.7,29.12 141.33,22.48 155.21,22.48 156.8,24.08 184.65,24.08 185.65,25.07 197.9,25.07 198.54,25.71 199.85,25.71 200.06,25.49 200.06,24.73 200.48,24.3 202.85,24.3 203.48,24.94 204.53,24.94 206.05,23.41 212.93,23.41 213.6,22.75 216.86,22.75 217.85,23.73 221.58,23.73 223.16,22.15 228.36,22.15 228.71,22.51 232.36,22.51 235.3,25.45 237.58,25.45 238.47,26.34 238.92,26.34 239.14,26.56 241.54,26.56 242.29,25.81 244.88,25.81 245.17,26.1 245.42,26.1 247.14,27.82 247.14,30.56 246.79,30.91 246.79,33 249.79,35.99 250.73,35.99 253.29,38.55 253.29,38.78 255.68,41.17 256.57,41.17 257.74,42.34 259.26,42.34 259.56,42.63 v1(259.56,42.87)
  BOTTOM w0.102: PR920.1 26.07,44.54 v1(25.44,44.54)
PBAT_PRES#: length 327.6
  TOP w0.102: v1(266.04,49.72) 265.63,50.13 UE1.F9 ; v2(32.35,18.64) v1(33.36,18.64) PR1.2 33.41,17.9 PD1.3 34.64,18.25 PRP1.1 ; v1(29.28,47.15) 29.07,46.95 PR931.1
  IN1 w0.089: v1(33.36,18.64) 32.87,19.12 26.19,19.12 21.72,23.59 21.72,25.55 19.64,27.63 19.64,30.04 19.87,30.27 19.87,33.32 20.63,34.08 20.63,39.13 22.7,41.19 25.61,41.19 26.76,42.35 26.76,45.4 28.52,47.15 v1(29.28,47.15)
  IN2 w0.122: v1(29.28,47.15) 29.28,47.61 29.57,47.9 34.7,47.9 35.03,48.23 35.03,48.71 35.51,49.19 35.71,49.19 37.9,49.19 40.86,46.22 42.9,46.22 43.36,45.77 44.12,45.77 44.59,46.23 51.37,46.23 52.21,45.38 53.19,45.38 65.21,33.36 70.22,33.36 72.83,30.75 96.67,30.75 98.79,32.87 136.42,32.87 143.12,26.17 153.83,26.17 155.43,27.77 182.33,27.77 185.86,31.29 197.19,31.29 198.1,30.39 199.16,30.39 199.44,30.11 209.7,30.11 210.47,29.35 216.84,29.35 217.68,28.51 221.64,28.51 222.82,29.69 224.71,29.69 224.97,29.42 226.55,29.42 228.11,30.99 232.21,30.99 232.53,30.67 235.93,30.67 241.96,36.69 243.39,36.69 243.99,37.29 243.99,38.83 245.08,39.92 245.08,40.32 245.76,41 245.76,41.68 247.18,43.1 247.81,43.1 249.51,44.8 249.51,45.98 250.73,47.2 250.73,50.49 250.42,50.8 250.42,52.94 251.39,53.91 251.88,53.91 252.89,54.91 254.56,54.91 255.07,55.42 256.47,55.42 257.25,56.2 259.49,56.2 260.46,55.24 261.73,55.24 262.56,54.4 266.41,54.4 267.26,53.55 267.26,51.58 266.44,50.76 266.44,50.11 v1(266.04,49.72)
PBAT_PRES#_C: length 6.3
  TOP w0.102: PRP1.8 34.64,20.96 v1(34.47,21.13)
  BOTTOM w0.102: v2(34.57,26.03) 33.8,25.26 PBATT1.6 33.8,22.82 34.47,22.14 v1(34.47,21.13)
PBAT_SMBCLK_C: length 5.6
  TOP w0.102: v2(35.96,21.74) 35.68,21.46 v1(35.68,21.1) 35.64,21.06 PRP1.6
  BOTTOM w0.102: PBATT1.4 36.8,23.12 37.14,22.78 37.14,22.02 36.25,21.13 35.71,21.13 v1(35.68,21.1)
PBAT_SMBDAT_C: length 6
  TOP w0.102: v1(35.1,21.1) 35.14,21.06 PRP1.7 35.14,20.1 34.88,19.84 v2(33.39,19.84)
  BOTTOM w0.102: v1(35.1,21.1) 35.1,22.32 35.3,22.53 PBATT1.5
PBATT+_C:
  vias: v1(41.2,21.51) v1(41.53,22.04) v1(41.84,21.51) v1(42.35,24.56) v1(42.47,21.51) v1(42.68,22.07) v1(42.98,25.83) v1(42.98,25.19) v1(42.98,24.56) v1(43.24,21.51) v1(43.57,22.07) v1(43.62,25.83) v1(43.62,25.19) v1(43.62,24.56) v1(44.25,25.83) v1(44.25,25.19) v1(44.25,24.56) v1(44.89,25.83) v1(44.89,25.19) v1(44.89,24.56) v3(42.4,25.19) v3(45.57,24.94) v3(46.65,26.32)
PCH_3.3V_TS_EN: length 163
  TOP w0.102: RC282.1 150.33,54.94 v2(150.26,54.86) 150.02,54.63 148.72,54.63 148.66,54.57 148.02,54.57 147.77,54.33 140.49,54.33 138.81,56 138.38,56 137.53,56.85 137.18,56.85 136.99,56.66 136.99,56.21 v1(137.47,55.72) ; RV324.1 78.69,106.78 80.42,105.05 v1(80.42,102.87)
  IN2 w0.122: v1(80.42,102.87) 80.76,102.53 83.66,102.53 84.96,101.24 92.34,101.24 92.83,100.74 101.78,100.74 102.71,99.81 107.56,99.81 107.75,99.61 111.56,99.61 113.72,97.46 113.72,95.8 117.99,91.54 123.32,91.54 123.75,91.11 126.78,91.11 127.54,90.34 133.15,90.34 133.92,91.11 137.99,91.11 139.2,89.9 143.06,89.9 144.51,88.44 148.61,88.44 149.66,87.39 150.68,87.39 151.13,86.94 151.13,82.08 155.21,78 155.21,75.74 155.56,75.4 155.56,69.03 153.14,66.6 153.14,65.43 152.07,64.37 152.07,63.71 154.62,61.16 154.62,60.04 155.07,59.59 155.07,56.09 152.51,53.53 147.4,53.53 145.5,51.64 143.7,51.64 142.98,50.92 140.82,50.92 138.9,52.84 138.9,53.98 138.04,54.85 138.04,55.29 137.98,55.36 137.98,55.52 137.77,55.72 v1(137.47,55.72)
  BOTTOM w0.076: UC1.AP5 137.83,56.09 v1(137.47,55.72)
PCH_ALW_ON: length 114.8
  TOP w0.076: 265.91,42.85 265.91,43.48 265.66,43.73 265.13,43.73 265.12,43.73 264.85,43.73 264.72,43.86 264.72,44.12 264.51,44.33 264.51,45.02 UE1.M8
  TOP w0.102: RPE10.3 264.73,35.73 264.85,35.61 265.79,35.61 266.15,35.96 266.15,38.1 v1(265.97,38.27) 265.97,38.69 265.51,39.15 265.51,39.25 265.51,41.41 266.09,42 266.09,42.49 265.91,42.67 265.91,42.85 ; v1(182.58,60.78) v2(181.14,62.21) RZ65.1
  IN1 w0.089: v1(182.58,60.78) 183.75,59.61 183.75,58.67 192.26,50.16 192.26,48.71 195.72,45.25 196.03,45.25 198.42,42.86 200.22,42.86 200.99,42.08 202.37,42.08 203.61,40.84 206.18,40.84 206.96,40.05 208.71,40.05 209.88,38.88 212.17,38.88 214.01,37.04 227.23,37.04 227.95,36.32 232.29,36.32 233.54,37.56 234.32,37.56 234.55,37.33 234.76,37.33 236.09,38.67 240.61,38.67 241.79,39.86 243.62,39.86 243.82,40.05 245.8,40.05 247.55,38.3 248.44,38.3 248.81,37.93 256,37.93 256.09,38.02 259.52,38.02 259.97,37.56 261,37.56 261.04,37.52 263.08,37.52 263.83,38.27 v1(265.97,38.27)
PCH_BATLOW#: length 12
  TOP w0.102: RC72.1 135.1,47.55 134.01,48.64 134.01,49.02 134.45,49.45 134.45,50.44 133.2,51.69 133.2,52.96 v2(132.85,53.3) 132.55,53.6 132.55,54.05 v1(132.94,54.43)
  BOTTOM w0.076: v1(132.94,54.43) 133.23,54.14 UC1.AU13
PCH_CL_CLK1: length 132.7
  TOP w0.102: v1(151.21,79.86) 150.81,80.26 147.99,80.26 146.35,78.63 146.33,78.63 144.96,77.25 144.96,77.23 144.43,76.71 144.43,76.06 144.2,75.82 v1(144.2,73.74)
  IN1 w0.089: v1(151.21,79.86) 151.21,79.19 155.18,75.22 158.11,75.22 159.5,73.83 162.51,73.83 164.06,72.28 167.27,72.28 168.07,71.49 173.65,71.49 180.27,64.87 180.27,63.37 181.21,62.43 181.21,60.16 182.17,59.19 182.17,58.21 v1(190.83,49.55)
  BOTTOM w0.076: UC1.G3 139.62,70.46 140.15,70.46 140.46,70.56 140.59,70.69 140.59,70.95 140.91,71.27 140.91,71.94 142.71,73.74
  BOTTOM w0.102: 142.71,73.74 v1(144.2,73.74) ; JNGFF1.42 218.82,28.25 219.29,28.72 221.85,28.72 222.33,29.21 223.12,29.21 224.18,30.27 224.18,32.15 224.87,32.84 225.35,32.84 226.62,34.11 226.62,36.5 225.73,37.38 222.77,37.38 221.26,38.89 221.26,42.94 219.81,44.4 211.1,44.4 210.67,44.83 200.05,44.83 196.81,48.07 195.74,48.07 193.56,50.25 v2(192.68,50.25) 191.53,50.25 v1(190.83,49.55)
PCH_CL_DATA1: length 134.9
  TOP w0.102: v1(143.72,73.29) 143.72,76.02 143.95,76.26 143.95,76.91 144.1,77.05 144.1,78.12 144.92,78.94 144.93,78.94 145.74,79.75 146.79,79.75 147.79,80.74 151.01,80.74 151.79,79.95 v1(151.79,79.86)
  IN1 w0.089: v1(191.22,49.07) 191.29,49.15 191.29,49.78 182.73,58.34 182.73,59.3 181.68,60.35 181.68,64.13 173.85,71.96 168.26,71.96 167.47,72.75 164.26,72.75 162.71,74.3 159.7,74.3 158.31,75.69 156.74,75.69 154.11,78.33 152.73,78.33 151.79,79.27 v1(151.79,79.86)
  BOTTOM w0.076: UC1.G2 140.18,70.14 140.41,70.37 140.55,70.42 140.55,70.42 140.75,70.62 140.75,70.88 141.08,71.21 141.08,71.52 141.32,71.76
  BOTTOM w0.102: JNGFF1.40 218.63,28.75 219.09,29.21 220.45,29.21 220.93,29.69 222.81,29.69 223.7,30.58 223.7,32.36 224.74,33.4 225.23,33.4 226.12,34.29 226.12,36.24 225.51,36.85 222.62,36.85 220.78,38.69 220.78,42.74 219.64,43.89 210.85,43.89 210.39,44.34 v2(207.97,44.34) 203.54,44.34 203.43,44.24 203.43,43.96 203.33,43.86 203.13,43.86 203.03,43.96 203.03,44.24 202.93,44.34 202.72,44.34 202.62,44.24 202.62,43.96 202.52,43.86 202.32,43.86 202.22,43.96 202.22,44.24 202.11,44.34 201.91,44.34 201.81,44.24 201.81,43.96 201.71,43.86 201.5,43.86 201.4,43.96 201.4,44.24 201.3,44.34 201.1,44.34 201,44.24 201,43.96 200.89,43.86 200.69,43.86 200.59,43.96 200.59,44.24 200.49,44.34 199.85,44.34 196.61,47.58 195.54,47.58 193.72,49.4 191.55,49.4 v1(191.22,49.07) ; v1(143.72,73.29) 143.43,73 142.56,73 141.32,71.76
PCH_CL_RST1#: length 133.1
  TOP w0.102: v1(152.22,79.44) 152.14,79.36 147.77,79.36 146.52,78.11 146.5,78.11 145.75,77.36 145.75,77.34 144.92,76.51 144.92,75.86 144.68,75.62 144.68,73.39 144.23,72.94 v1(144.2,72.94)
  IN1 w0.089: v1(152.22,79.44) 155.51,79.44 157.82,77.14 157.94,77.14 158.38,77.57 158.53,77.57 158.68,77.42 158.68,77.3 158.19,76.81 158.19,76.68 158.32,76.56 158.44,76.56 158.93,77.05 159.06,77.05 159.19,76.92 159.19,76.8 158.74,76.35 158.74,76.22 158.87,76.1 158.99,76.1 159.44,76.54 159.56,76.54 160.41,75.7 161.89,75.7 162.71,74.88 162.8,74.88 164.45,73.22 167.66,73.22 168.46,72.43 174.05,72.43 182.15,64.33 182.15,60.55 183.27,59.43 183.27,58.47 191.77,49.96 191.77,48.76 v1(191.65,48.64)
  BOTTOM w0.076: UC1.G1 140.92,70.46 140.92,70.81 141.24,71.14 141.24,71.3 141.53,71.59
  BOTTOM w0.102: JNGFF1.38 218.45,29.25 219.45,30.25 220.43,30.25 221.08,30.9 221.08,31.33 221.16,31.42 221.54,31.42 221.67,31.29 221.67,30.6 222.03,30.25 222.69,30.25 223.22,30.78 223.22,32.56 224.62,33.96 225.02,33.96 225.61,34.54 225.61,35.99 225.25,36.34 222.44,36.34 220.3,38.49 220.3,42.54 219.43,43.4 v2(214.91,43.4) 210.57,43.4 210.11,43.86 204.02,43.86 203.53,43.38 200.05,43.38 196.33,47.1 195.34,47.1 193.52,48.92 191.93,48.92 v1(191.65,48.64) ; v1(144.2,72.94) 144.03,72.77 142.71,72.77 141.53,71.59
PCH_DPWROK: length 212.6
  TOP w0.102: v3(143.77,37.99) 144.12,37.64 v1(144.12,37.19) ; RE536.1 v1(279.3,56.69) ; CC266.1 144.71,37.78 v1(144.12,37.19) ; RC215.1 145.16,35.91 144.28,35.91 RC220.1 144.12,36.67 v1(144.12,37.19)
  IN1 w0.089: v1(274.4,32.05) 274.4,31.52 273.38,30.5 272.65,30.5 272.42,30.27 272.42,29.66 271.84,29.08 266.98,29.08 266.7,28.81 265.73,28.81 265.05,28.13 265.05,27.57 263.95,26.47 257.54,26.47 255.23,24.16 255.23,22.75 252.26,19.78 249.23,19.78 247.38,17.93 240.33,17.93 239.87,18.39 227.86,18.39 227.42,17.96 221.2,17.96 220.13,16.89 219.86,16.89 218.67,15.71 218.19,15.71 217.04,14.56 214.99,14.56 213.9,13.47 205.4,13.47 203.17,15.71 203.17,17.18 202.53,17.82 202.53,18.13 200,20.66 199.25,20.66 198.24,21.68 197.18,21.68 197.03,21.83 195.65,21.83 194.55,22.93 188.62,22.93 183.06,28.49 159.94,28.49 152.11,36.32 144.99,36.32 v1(144.12,37.19)
  IN3 w0.122: v1(274.12,55.55) 273.58,55 273.58,51.05 272.72,50.2 272.72,44.46 273.17,44.02 273.17,40.98 273.23,40.92 273.23,32.91 274.1,32.05 v1(274.4,32.05)
  BOTTOM w0.076: UC1.BB20 129.67,50.99 129.67,49.8 131.75,47.72 131.75,47.32
  BOTTOM w0.102: v1(144.12,37.19) 143.48,37.83 138.5,37.83 137.49,38.83 135.39,38.83 133.02,41.19 133.02,43.35 131.75,44.62 131.75,47.32 ; v1(279.3,56.69) 278.06,56.69 276.53,55.16 274.5,55.16 v1(274.12,55.55)
PCH_DPWROK_EC: length 17.1
  TOP w0.102: v1(275.58,56.63) 275.65,56.69 RE536.2 ; UE1.F8 v1(265.22,49.74)
  IN1 w0.089: v1(265.22,49.74) 264.84,50.12 264.84,52.36 265.02,52.54 265.62,52.54 266.54,53.45 268.79,53.45 270.74,55.41 272.1,55.41 273.32,56.63 v1(275.58,56.63)
PCH_JTAG_TCK: length 44.6
  TOP w0.102: v3(107.57,77.95) v1(107.57,78.53) 107.59,78.55 107.59,78.69 107.01,79.27 107.01,80.08 RC86.1
  IN4 w0.089: v1(89.84,99.89) 89.84,99.34 91.28,97.9 92.86,97.9 97.05,93.71 101.38,93.71 101.72,94.05 102.35,94.05 103.14,93.26 103.74,93.26 105.13,91.87 105.13,91.01 105.83,90.31 105.83,88.02 106.51,87.35 106.51,86.23 106.15,85.87 106.15,82.86 106.67,82.33 106.67,80.58 106.98,80.27 106.98,79.16 107.57,78.56 v1(107.57,78.53)
  BOTTOM w0.076: 107.62,78.23 107.62,78.13 107.9,77.86 107.9,75.34 108.62,74.61 108.62,74.02 108.43,73.82 108.43,73.54 108.48,73.43 108.69,73.22 UC1.B56
  BOTTOM w0.102: v1(89.84,99.89) 89.84,99.82 89.64,99.61 JXDP1.55 ; v1(107.57,78.53) 107.57,78.28 107.62,78.23
PCH_JTAG_TDI: length 31.7
  TOP w0.102: RC81.1 CC304.1 108.01,80.21 108.01,79.05 v1(108.02,79.04) 108.15,78.91 108.99,78.91 109.53,79.45 109.53,82.34 109.99,82.8 v3(109.99,84.37) 109.99,86.03 109.53,86.48 109.53,88.11 109.76,88.34 109.76,90.88 109.25,91.39 109.25,93.11 108.56,93.8 108.56,93.95 108.24,94.28 107.86,94.28 107.17,94.97 RC229.2
  BOTTOM w0.076: UC1.D59 107.56,72.03 107.63,72.29 107.63,72.41 107.71,72.69 107.76,72.84 107.77,72.86 107.77,72.89 107.77,73.13 107.75,73.19 107.75,73.45 107.76,73.48 107.77,73.5 107.77,73.93 107.66,74.04 107.66,74.97 107.66,75.11 107.43,75.33 107.43,77.39 106.97,77.85
  BOTTOM w0.102: v1(108.02,79.04) 107.92,78.94 106.86,78.94 106.58,78.66 106.58,78.24 106.97,77.85
PCH_JTAG_TDO: length 32
  TOP w0.102: v1(108.96,79.45) 109.33,79.81 109.33,81.96 108.86,82.43 106.61,82.43 106.2,82.84 106.2,83.79 108.01,85.59 v3(108.23,85.59) 109.3,86.66 109.3,88.2 109.53,88.43 109.53,90.27 108.16,91.64 106.63,91.64 103.31,94.97 RC230.2
  BOTTOM w0.076: UC1.A56 108.79,73.75 108.79,74.96 108.24,75.51 108.24,77.58 108.73,78.06 108.73,78.93
  BOTTOM w0.102: 108.73,78.93 108.73,79.21 v1(108.96,79.45) 109.02,79.45 109.04,79.43 109.24,79.43 109.86,80.04 CC303.1 RC82.1
PCH_JTAG_TMS: length 38.4
  TOP w0.102: RC228.2 107.99,99.79 108.87,98.9 108.87,97.28 v3(109.17,96.97) 110.85,95.3 112.07,95.3 112.7,94.66 112.7,94.33 113.64,93.39 114.13,93.39 v1(114.25,93.26)
  BOTTOM w0.076: UC1.C59 107.52,72.66 107.61,72.91 107.61,73.08 107.57,73.2 107.57,73.47 107.61,73.54 107.61,73.81 107.49,73.92 107.49,75.04 107.24,75.29 107.24,77.07 106.46,77.85
  BOTTOM w0.102: 106.46,77.85 106.35,77.96 106.35,78.76 106.79,79.19 107.57,79.19 107.84,79.47 108.28,79.47 108.87,80.06 RC130.1 109.55,80.53 109.55,81.3 110.85,82.6 112.71,82.6 115.31,85.2 115.31,92.21 v1(114.25,93.26)
PCH_PCIE_WAKE#: length 172.5
  TOP w0.076: v1(257.41,45.22) 258.31,45.22 UE1.L1
  TOP w0.102: RE274.2 271.58,42.41 v1(269.88,44.12) ; RC67.1 166.4,45.67 v1(166.43,45.64)
  IN1 w0.089: v1(166.43,45.64) 167.3,46.52 178.58,46.52 179.46,45.64 179.58,45.64 181.79,43.42 184.44,43.42 190.78,37.08 193.7,37.08 194.29,37.66 194.87,37.66 195.86,36.67 197.57,36.67 199.83,34.41 201.27,34.41 202.24,33.45 205.71,33.45 208.16,31 209.74,31 212.02,28.72 214.96,28.72 215.49,28.2 216.83,28.2 217.84,29.21 221.41,29.21 222.38,30.17 225.12,30.17 225.4,29.89 230.46,29.89 230.86,29.5 233.67,29.5 234.06,29.89 238.48,29.89 241.24,32.65 245.21,32.65 245.5,32.36 248.26,32.36 v1(248.72,32.81) ; v1(257.41,45.22) 257.5,45.31 268.28,45.31 268.28,45.31 268.61,45.31 268.61,45.31 268.69,45.31 v1(269.88,44.12)
  IN3 w0.122: v1(248.72,32.81) 248.72,35.44 253.31,40.03 253.31,42.71 254.58,43.98 255.14,43.98 255.78,44.62 256.81,44.62 v1(257.41,45.22)
  BOTTOM w0.076: 136.38,45.97 136.3,46.06 136.3,46.7 134.89,48.1 133.96,48.1 131.97,50.1 131.97,50.94 UC1.BB15
  BOTTOM w0.102: 136.38,45.97 137.03,45.33 138.64,43.71 144.59,43.71 148.54,39.76 162.07,39.76 165.03,42.72 165.03,43.99 166.43,45.39 v1(166.43,45.64)
PCH_PLTRST#: length 56
  TOP w0.102: RC62.1 RC244.1 ; RC62.1 161.15,52.79 162.23,51.71 v2(162.46,51.71) 164.98,51.71 166.2,52.93 166.2,61.05 166.73,61.59 166.73,62.63 RC60.1 ; RC62.1 160.98,53.18 160.81,53.35 UC7.2 ; RC244.1 159.81,52.79 159.49,52.47 v1(159.16,52.47) ; RC244.1 160.09,53.21 160.16,53.28 UC7.1
  IN2 w0.122: v1(135.66,56.32) 136.14,55.85 136.14,50.66 137.04,49.75 138.1,49.75 138.31,49.96 144.04,49.96 147.44,46.56 151.08,46.56 152.03,47.5 152.03,47.57 152.8,48.33 152.8,50.11 153.83,51.15 154.69,51.15 155.22,51.67 158.36,51.67 v1(159.16,52.47)
  BOTTOM w0.254: v1(135.66,56.32) 135.55,56.32 135.2,56.67 UC1.AN10
PCH_PLTRST#_5105: length 10.3
  TOP w0.076: 257.54,45.96 v2(257.81,45.96) 258.06,45.96 258.88,46.78 259.07,46.78 UE1.K1
  TOP w0.102: UE6.4 252.38,41.81 252.99,42.41 RE340.1 252.99,43.84 253.95,44.8 253.95,44.9 254.26,45.21 254.31,45.26 254.82,45.26 255.45,45.89 256.54,45.89 256.61,45.96 257.54,45.96
PCH_PLTRST#_AND: length 359.9
  TOP w0.102: v1(164.58,64.99) 164.79,64.78 RC325.1 ; UC7.4 161.46,55.03 161.89,54.59 RC65.1 162.72,54.85 162.72,55.48 v1(162.09,56.1)
  IN1 w0.089: v1(156.23,47.92) 156.23,47.46 158.28,45.41 159.34,45.41 160.63,44.12 160.63,42.8 161.35,42.08 169.23,42.08 169.84,41.47 176.81,41.47 181.49,36.8 184.21,36.8 188.8,32.2 195.03,32.2 195.76,31.47 196.32,31.47 198.84,28.95 200.46,28.95 201.41,28 202.25,28 203.32,26.93 203.32,26.86 204.91,25.27 206.71,25.27 207.57,24.41 208.31,24.41 210.04,22.68 210.04,20.62 211.28,19.38 212.69,19.38 213.05,19.74 213.05,19.82 214.24,21.01 215.95,21.01 216.45,21.5 217.1,21.5 218.45,22.84 221.31,22.84 221.94,22.22 v1(222.13,22.22) 222.43,22.22 222.94,22.72 231.85,22.72 232.74,23.62 237.85,23.62 239.96,21.51 241.48,21.51 v1(241.58,21.61) 241.89,21.61 242.05,21.45 244.46,21.45 244.7,21.21 245.18,21.21 245.75,21.79 245.88,21.92 246.9,21.92 247.35,22.37 247.35,22.38 247.7,22.73 249.13,22.73 249.52,23.12 251.93,23.12 252.15,23.34 252.15,26.59 253.93,28.37 253.93,28.95 254.77,29.79 255.17,29.79 255.96,29 260.81,29 261.73,29.92 261.73,30.82 262.02,31.11 264.14,31.11 264.43,31.4 271.09,31.4 272.27,32.58 272.27,32.79 v1(272.67,33.19)
  IN2 w0.122: v1(156.23,47.92) 156.24,47.92 157.75,49.42 161.92,49.42 162.23,49.73 162.23,50.52 161.87,50.89 161.87,55.88 v1(162.09,56.1) 162.12,56.13 162.12,58.05 161.3,58.87 161.3,62.45 160.99,62.76 160.99,67.84 160.77,68.06 160.77,68.52 160.37,68.91 ; 160.37,68.91 160.55,69.1 162.56,69.1 163.12,68.53 163.12,66.62 164.58,65.16 v1(164.58,64.99) ; 160.37,68.91 159.02,70.27 159.02,71.18 158.64,71.55 158.64,78.47 153.39,83.72 153.39,87.87 151.26,90.01 151,90.01 149.09,91.92 140.26,91.92 138.1,94.08 132.01,94.08 131.7,93.77 121.19,93.77 118.27,96.7 118.27,99.62 116.37,101.51 108.98,101.51 108.49,102 104.09,102 102.89,103.2 100.74,103.2 100.51,102.97 88.47,102.97 87.66,102.16 85.34,102.16 83.87,103.63 81.33,103.63 v1(80.9,104.06)
  IN4 w0.089: v1(80.9,104.06) 80.9,102.71 80.14,101.95 79.4,101.95 78.2,100.75 78.2,95.54 81.23,92.5 v1(81.23,91.87)
  BOTTOM w0.102: v1(81.23,91.87) 81.07,91.7 UR1.1 ; JNGFF3.50 268.85,3.92 267.98,4.79 263.95,4.79 262.47,6.27 259.64,6.27 258.45,7.46 258.45,8.25 257.86,8.84 256.59,8.84 256.33,9.1 255.04,9.1 254.74,9.4 254.74,9.96 RZ114.1 253.95,10.12 252.99,10.12 252.79,10.33 252.79,10.94 252.38,11.34 CZ61.1 251.75,11.92 251.57,12.11 251.37,12.11 250.89,12.11 250.09,12.91 250.09,15.06 249.69,15.47 249.69,15.93 249.45,16.17 247.43,16.17 246.05,17.55 246.05,18.31 245.52,18.84 244.4,18.84 243.97,19.27 242.8,19.27 241.99,20.09 241.99,21.51 241.89,21.61 v1(241.58,21.61) ; JNGFF2.50 271,35.17 271.66,34.51 272.12,34.51 272.67,33.96 v1(272.67,33.19) ; v1(222.13,22.22) 221.08,21.18 219.21,21.18 218.75,21.64 218.75,21.99 218.49,22.25 JNGFF1.66 216.64,22.25 216.04,22.86 214.89,22.86 214.6,23.15 214.6,25.36 214.99,25.75 JNGFF1.52
PCH_PLTRST#_EC: length 132.2
  TOP w0.102: UE6.2 255.01,41.16 RE375.2 255.53,40.76 255.53,39.42 256.34,38.6 256.34,36.5 255.71,35.86 v1(255.38,35.86) ; RC244.2 160.09,51.2 159.16,50.28 159.16,45.08 160.74,43.51 164.24,43.51 165.43,42.31 165.43,41.73 166.01,41.16 v2(173.74,41.16) 177.84,41.16 179.46,39.54 189.72,39.54 191.16,38.1 193.32,38.1 194.31,39.09 199.69,39.09 200.04,38.74 200.04,38.23 198.73,36.93 198.73,35.43 200.74,33.42 206.25,33.42 206.43,33.6 206.43,34.13 206.25,34.31 204.07,34.31 203.74,34.64 203.74,35.4 203.97,35.63 208.22,35.63 v1(208.81,36.22)
  IN1 w0.089: v1(208.81,36.22) 209.21,35.81 211.99,35.81 213.54,34.27 216.63,34.27 217.06,34.7 226.74,34.7 227.87,33.57 232.8,33.57 234.14,34.92 236.21,34.92 236.64,35.35 238.77,35.35 240.04,36.62 244.66,36.62 245.19,37.16 245.71,37.16 246.59,36.27 251.9,36.27 252.81,35.35 254.87,35.35 v1(255.38,35.86)
PCH_POPIRCOMP: length 10.3
  TOP w0.381: v1(131.08,53.81) 130.75,53.47 v2(130.75,53.25) 130.75,52.38 130.66,52.29 130.66,50.94 130.79,50.81 130.79,49.94 130.71,49.86 130.71,45.82 131.42,45.11 RC89.1
  BOTTOM w0.254: v1(131.08,53.81) 131.53,54.13 UC1.AU16
PCH_PRIM_EN: length 228.5
  TOP w0.102: RZ64.1 179.62,60.23 v1(180.6,59.25) ; PR406.1 174.88,98.24 175.21,97.91 175.21,96.74 175.54,96.41 v1(176.1,96.41) 177.45,96.41 178.19,97.15 178.19,103.3 176.3,105.18 174.33,105.18 PR504.1 173.31,105.41 172.17,104.26 171.66,104.26 171.48,104.44 168.39,104.44 166.6,106.23 v2(166.6,106.37) 166.6,106.73 165.63,107.7 PR312.1 ; v1(257.73,35.9) 257.8,35.98 RC442.2 RC441.2 ; UZ34.1 155.3,26.16 155.76,25.7 157.51,25.7 163.66,31.85 183.87,31.85 187.35,35.33 v1(188.04,35.33)
  IN2 w0.122: v1(231.58,34.97) 231.14,35.41 227.07,35.41 226.44,34.78 225.79,34.78 224.97,33.96 212.81,33.96 211.83,34.95 206.67,34.95 205.78,35.83 199.68,35.83 199.19,36.32 191.78,36.32 190.79,35.33 v1(188.04,35.33) 191.57,38.86 191.57,40.41 185.36,46.62 185.36,54.08 180.6,58.85 v1(180.6,59.25) ; v1(253.89,30.31) 253.89,32.06 v1(257.73,35.9)
  IN3 w0.122: v1(180.6,59.25) 180.27,59.58 180.27,71.67 178.62,73.33 178.62,75.71 175.78,78.54 175.78,80.52 175.21,81.09 175.21,88.92 174.93,89.2 174.93,91.67 176.1,92.84 v1(176.1,96.41)
  BOTTOM w0.102: v1(253.89,30.31) 252.57,30.31 251.69,31.19 249.43,31.19 247.65,29.41 247.65,28.11 245.6,26.06 245.42,26.06 245.04,25.68 242.22,25.68 239.93,27.96 239.93,35.44 239.05,36.32 237.33,36.32 235.57,34.57 231.98,34.57 v1(231.58,34.97)
PCH_PWROK: length 279.9
  TOP w0.102: v1(162.26,74.72) 159.29,74.72 v3(158.68,74.11) 158.68,72.01 159.8,70.89 164.72,70.89 165.94,69.67 168.13,69.67 170.97,66.82 170.97,61.77 169.32,60.11 169.32,46.89 RC411.1 168.69,45.97 v1(168.36,45.64) ; v1(60.6,63.13) 61,63.13 61.27,62.86 PR614.1
  IN2 w0.122: v1(66.65,95.27) 66.58,95.35 66.58,96.1 67.07,96.59 67.53,96.59 67.97,97.04 67.97,104.42 69.82,106.26 78.7,106.26 79.7,105.26 82.07,105.26 84.68,107.87 92.72,107.87 94.13,109.28 97.24,109.28 100.27,106.24 103.48,106.24 104.01,105.72 104.78,105.72 105.12,106.05 107.61,106.05 108.35,105.32 117.16,105.32 121.18,101.29 121.18,99.14 124.11,96.21 130.8,96.21 131.03,96.45 140.13,96.45 142.24,94.33 151.34,94.33 153.39,92.27 153.6,92.27 156.5,89.37 156.5,86.42 157.4,85.52 157.4,84.11 158.11,83.4 159.34,83.4 160.76,81.99 160.76,80.76 163.19,78.32 165.01,78.32 165.41,77.92 165.41,76.75 163.38,74.72 v1(162.26,74.72)
  IN3 w0.122: v1(60.6,63.13) 60.6,64.32 60.13,64.79 60.13,65.96 58.35,67.74 58.35,73.21 60.71,75.57 60.71,76.4 60.25,76.86 60.25,79.26 61.53,80.54 61.53,84.78 63.68,86.93 63.68,91.87 65.38,93.57 65.38,94 v1(66.65,95.27)
  BOTTOM w0.076: UC1.BA20 129.37,51.41 129.37,49.63 130.61,48.38 130.61,47.79 131.24,47.16 131.24,45.4
  BOTTOM w0.102: v1(168.36,45.64) 168.36,42.69 172.39,38.65 172.39,37.38 170.3,35.29 142.17,35.29 140.33,37.13 138.49,37.13 137.29,38.32 135.2,38.32 131.12,42.4 131.12,45 131.24,45.12 131.24,45.4
PCH_RSMRST#: length 74.6
  TOP w0.102: UZ6.1 203.18,36.24 203.36,36.42 203.36,37.57 203.91,38.12 207.78,38.12 v2(208.14,38.48) 210.22,40.57 v1(210.77,40.57) ; RE342.1 260.06,38.21 v1(260.06,40.35) 260.43,40.72 260.43,40.94 260.72,41.23 260.72,41.39 260.43,41.68 260.43,42.6 260.59,42.76 260.85,42.76 260.99,42.63 260.99,42.39 261.19,42.19 261.66,42.19 261.84,42.36 261.84,43.54 261.62,43.76 261.62,44.07 261.95,44.4 261.95,44.73 261.8,44.88 261.8,45 261.92,45.12 262.21,45.12 UE1.M5
  IN1 w0.089: v1(260.06,40.35) 259.6,40.81 257.23,40.81 256.85,40.43 253.61,40.43 252.65,41.4 246.66,41.4 245.85,40.59 243.49,40.59 242.7,41.37 242.7,41.93 242.56,42.07 242.07,42.07 241.49,41.49 240.52,41.49 238.95,39.92 233.23,39.92 233.1,39.8 229.42,39.8 228.55,38.93 222.51,38.93 221.39,40.05 216.18,40.05 215.74,40.5 210.84,40.5 v1(210.77,40.57)
PCH_RSMRST#_AND: length 288.1
  TOP w0.102: v1(146.23,37.19) 146.23,37.13 146.53,36.83 RC215.2 RC75.1 147.65,37.16 148.13,37.64 155.85,37.64 156.48,38.27 160.2,38.27 162.92,35.56 v2(172.15,35.56) 182.43,35.56 184.56,37.69 189.74,37.69 190.63,36.8 193.86,36.8 194.55,37.49 195.84,37.49 200.38,32.94 206.81,32.94 207.01,33.14 207.01,34.54 206.61,34.94 UZ6.4
  IN2 w0.122: v1(146.23,37.19) 148.65,34.78 167.86,34.78 171.79,38.71 171.79,45.08 171.2,45.67 171.2,48.29 169.69,49.8 169.69,53.56 168.89,54.37 168.89,58.85 167.67,60.07 167.67,60.93 167.24,61.36 167.24,63.31 167.67,63.74 167.67,66.37 167.71,66.4 167.71,67.57 164.83,70.45 160.79,70.45 160.37,70.87 160.37,71.74 160,72.11 160,77.12 160.53,77.65 160.53,78.5 159,80.03 159,80.52 158.65,80.87 158.16,80.87 154.75,84.28 154.75,88.64 152.87,90.52 152.67,90.52 151.82,91.37 151.56,91.37 149.61,93.32 141.76,93.32 139.64,95.44 131.45,95.44 131.15,95.14 121.74,95.14 119.94,96.94 119.94,100 119.96,100.01 119.96,100.36 116.04,104.28 107.17,104.28 106.4,105.05 105.53,105.05 105.2,104.71 99.54,104.71 99.15,104.32 88.84,104.32 87.76,105.41 84.95,105.41 v1(84.56,105.01)
  IN4 w0.089: v1(84.56,105.01) 84.56,104.34 83.82,103.61 83.82,99.16 84.59,98.4 86.36,98.4 87.33,97.43 92.66,97.43 94.04,96.06 94.04,94.94 94.54,94.43 95.56,94.43 v1(96.78,93.21)
  BOTTOM w0.076: UC1.AY17 130.86,52.17 130.75,52.06 130.66,51.94 130.59,51.76 130.59,51.59 130.63,51.46 130.63,51.21 130.59,51.13 130.59,50.87 130.79,50.67 130.79,49.45 133.17,47.07 133.17,46.2
  BOTTOM w0.102: v1(96.78,93.21) 96.87,93.21 RC124.1 ; 133.17,46.2 133.17,45.1 139.36,38.91 144.52,38.91 v1(146.23,37.19)
PCH_RTCRST#: length 211.8
  TOP w0.102: v1(144.39,52.35) 144.39,51.96 144.77,51.58 145,51.58 145.25,51.32 145.25,50.62 145.18,50.55 145.18,47.99 147.74,45.43 151.51,45.43 CC25.1 152,43.9 CMOS1.1 152.04,43.46 152.79,42.7 RC57.1 153.8,44.16 154.11,44.47 v3(155.33,44.47) 155.8,44 v1(155.8,43.59) ; v1(265.87,60.88) 265.49,61.26 265.49,63.57 RE94.2
  IN1 w0.089: v1(155.8,43.59) 156.2,43.59 156.93,44.32 158.96,44.32 159.62,43.66 159.62,42.55 162.62,39.54 176.97,39.54 180.97,35.54 183.23,35.54 187.89,30.88 194.52,30.88 195.25,30.15 195.84,30.15 198.33,27.66 199.93,27.66 200.84,26.74 201.73,26.74 202.06,26.41 202.06,26.29 203.28,25.07 203.28,24.33 203.61,24 206.15,24 208.31,21.84 208.31,19.81 208.63,19.49 v1(209.06,19.49)
  IN2 w0.122: v1(209.06,19.49) 209.22,19.66 209.22,20.58 210.18,21.54 213.06,21.54 213.73,20.87 217.09,20.87 218.5,22.27 220.53,22.27 221.5,21.3 223.48,21.3 223.94,20.84 232.38,20.84 234.1,22.56 234.1,23.18 234.69,23.77 238.47,23.77 239.56,24.86 240.03,24.86 240.42,25.24 241.06,25.24 241.64,24.66 242.83,24.66 243.11,24.94 244.53,24.94 244.8,24.67 246.17,24.67 247.04,25.55 247.04,26.45 247.89,27.3 247.89,30.99 247.58,31.3 v1(247.58,31.42)
  IN3 w0.122: v1(247.58,31.42) 247.58,35.04 250.98,38.44 250.98,39.52 252.38,40.92 252.38,43.2 254.1,44.92 254.1,45.03 254.46,45.39 256.09,45.39 257.1,46.4 258.5,46.4 258.65,46.55 258.65,47.85 259.77,48.97 259.77,51.33 261.74,53.3 262.85,53.3 263.14,53.01 264.36,53.01 264.87,53.51 265.49,53.51 265.87,53.13 266.12,53.13 267.96,54.97 267.96,55.86 269.55,57.45 269.55,58.85 267.36,61.03 266.02,61.03 v1(265.87,60.88)
  IN4 w0.076: 138.49,53.34 138.47,53.34 138.23,53.11 ; 137.2,53.13 136.64,53.13 135.92,52.41 134.76,52.41 134.17,53.01 133.66,53.01 133.26,53.41 132.57,53.41 132.32,53.66 132.32,53.8 132.32,54.11 131.53,54.9
  IN4 w0.089: 138.23,53.11 137.61,53.11 137.58,53.13 137.2,53.13 ; v1(132.01,56.92) 132.01,56.89 131.53,56.41 131.53,54.9 ; 138.49,53.34 139.77,53.34 140.3,53.87 142.96,53.87 143.82,53.01 144.2,53.01 144.39,52.82 v1(144.39,52.35)
  BOTTOM w0.076: v1(132.01,56.92) 131.9,56.92 131.54,57.28 UC1.AM16
  BOTTOM w0.102: JAPS1.9 210.7,16.6 210.46,16.85 209.63,16.85 208.84,17.64 208.84,19.27 v1(209.06,19.49)
PCH_RTCX1: length 24.9
  IN1 w0.076: v1(140.94,56.49) 139.57,56.49 138.74,57.32 138,57.32 137.77,57.55 137.29,57.55 136.55,58.3 136.14,58.3 135.84,58.59 135.31,58.59 134.68,59.23 133.28,59.23 133.1,59.05 132.59,59.05 132.52,58.97 131.88,58.97 131.58,58.67 131.58,58.37
  IN1 w0.089: v1(131.05,57.01) 131.19,57.01 131.58,57.4 131.58,58.37
  BOTTOM w0.076: v1(131.05,57.01) UC1.AM18
  BOTTOM w0.102: YC2.1 150.27,58.47 CC23.1 149.24,57.48 RC54.2 148.35,58.23 146.87,56.74 v2(145.57,56.74) 144.76,56.74 144.63,56.87 141.32,56.87 v1(140.94,56.49)
PCH_RTCX2: length 22.3
  IN1 w0.076: 141.42,56.16 v1(141.44,56.18) ; 133.15,58.01 133.33,58.01 133.41,58.09 134.87,58.09 135.18,58.4 135.78,58.4 136.08,58.1 136.45,58.1 137.16,57.39 137.7,57.39 138.02,57.07 138.64,57.07 139.45,56.26
  IN1 w0.089: 141.42,56.16 141.32,56.05 139.65,56.05 139.45,56.26 ; v1(130.14,57.03) 130.27,57.03 130.67,56.63 131.35,56.63 131.63,56.91 131.63,57.1 131.86,57.32 132.06,57.32 132.74,58.01 133.15,58.01
  BOTTOM w0.076: v1(130.14,57.03) 129.74,57.39 UC1.AM20
  BOTTOM w0.102: v1(141.44,56.18) 141.55,56.08 v2(146.71,56.08) 146.98,56.08 RC54.1 RC296.1
PCH_RTCX2_R: length 3.1
  BOTTOM w0.102: RC296.2 148.39,55.7 148.81,56.12 148.81,56.18 CC26.1 149.88,55.97 YC2.2
PCH_SMB_ALERT#: length 3.3
  TOP w0.102: v1(136.24,66.24) 136.24,65.89 v2(136.41,65.72) 136.52,65.62 136.52,64.83 136.23,64.54 RC23.1
  BOTTOM w0.076: v1(136.24,66.24) 135.96,65.96 135.8,65.96 135.51,65.67 UC1.R10
PCH_SPI_CLK: length 91
  TOP w0.102: v1(177.65,38.2) v3(179.34,38.2)
  IN1 w0.089: v1(177.65,38.2) 175.98,36.52 162.16,36.52 157.79,40.89 155.04,40.89 152.65,43.28 146.97,43.28 144.68,45.56 144.68,47.39 141.7,50.38 141.7,51.53 v1(142.13,51.96)
  IN2 w0.122: v1(177.65,38.2) 180.28,40.82 180.28,42.68 181.67,44.07 182.1,44.5 182.1,48.38 182.59,48.88 182.59,54.27 178.19,58.68 178.19,58.95 177.21,59.93 176.65,59.93 173.84,62.73 171.3,62.73 170.9,63.14 169.1,63.14 v1(168.57,62.62)
  BOTTOM w0.076: UC1.AV2 139.89,53.78 141.23,53.78 141.47,53.54 141.47,53.16 141.81,52.82 141.81,52.28 v1(142.13,51.96)
  BOTTOM w0.102: v1(168.57,62.62) 168.57,63.02 RC35.2 168.83,64.21 169.98,65.36 169.98,65.41 JSPI1.8
PCH_SPI_CLK_0_R: length 14.1
  BOTTOM w0.102: RPC1.6 166.57,52.62 166.41,52.78 165.7,52.78 v3(164.9,51.98) 164.74,51.81 163.75,51.81 RC29.1 163.25,52.31 163.25,52.68 163.38,52.8 163.38,54.78 162.5,55.66 161.59,55.66 161.4,55.85 161.4,56.4 161.59,56.59 162.35,56.59 163.99,54.94 UC5.6
PCH_SPI_CLK_1_R: length 14.3
  BOTTOM w0.102: RC408.2 165.64,48.43 165.64,47.61 165.54,47.51 163.61,47.51 163.5,47.61 163.5,48.09 163.39,48.21 162.83,48.21 162.73,48.1 v1(162.73,47.95) 162.72,47.94 162.72,47.61 162.62,47.51 162.34,47.51 162.23,47.61 162.23,49.16 162.06,49.34 RC28.1 161.24,49.77 161.24,50.14 161.04,50.34 160.46,50.34 160.33,50.21 160.33,50.03 160.2,49.91 159.97,49.91 159.85,50.03 159.85,50.24 159.74,50.34 158.04,50.34 157.92,50.21 157.92,49.93 158.15,49.7 UC6.6
PCH_SPI_CLK_2_R: length 15.7
  TOP w0.102: RZ63.2 165.42,65.68 164.66,65.68 RZ60.2 163.42,64.79 163.3,64.91 163.3,65.39 163.2,65.49 162.97,65.49 162.87,65.39 162.87,64.91 162.77,64.8 161.9,64.8 161.78,64.68 161.78,64.21 161.68,64.11 161.4,64.11 161.3,64.21 161.3,65.37 161.19,65.48 160.97,65.48 v2(160.32,64.82) 160.11,64.62 160.11,64.36 160.21,64.26 160.67,64.26 160.86,64.07 160.86,63.67 160.56,63.37 160.41,63.37 160.3,63.47 160.3,63.7 160.2,63.8 159.97,63.8 159.85,63.68 159.85,63.35 159.73,63.23 159.59,63.23 159.4,63.42 159.21,63.42 158.78,62.99 158.46,62.99 158.35,62.87 UZ12.19
PCH_SPI_CLK_R1: length 27.3
  TOP w0.102: v1(163.12,63.86) 163.12,64.05 163.23,64.16 163.49,64.16 RZ60.1 ; v3(164.94,49.63) 165.33,50.02 v1(165.33,50.23)
  IN2 w0.122: v1(165.33,50.23) 165.33,50.76 163.92,52.17 163.92,57.81 163.65,58.09 163.65,59.29 163.19,59.74 163.19,61.31 163.23,61.35 163.23,63.75 v1(163.12,63.86)
  BOTTOM w0.102: v1(163.12,63.86) 165.32,63.86 165.78,63.39 167.67,63.39 RC35.1 168.1,63.8 169.54,65.24 169.54,65.66 JSPI1.7 ; RPC1.3 166.57,50.86 166.3,50.59 165.7,50.59 v1(165.33,50.23) 165.33,49.65 RC408.1
PCH_SPI_CS#0: length 103.9
  TOP w0.102: v1(145.28,53.39) v3(146.32,53.39)
  IN1 w0.089: v1(176.71,39.04) 176.2,38.53 162.95,38.53 158.66,42.81 155.89,42.81 155.38,43.33 155.38,44.4 154.37,45.4 147.74,45.4 146.56,46.58 146.56,48.39 146.23,48.72 146.23,52.44 v1(145.28,53.39)
  IN2 w0.122: v1(176.71,39.04) 176.71,39.82 176.83,39.95 177.01,39.95 177.76,39.19 177.93,39.19 178.11,39.36 178.11,39.54 177.35,40.29 177.35,40.46 177.53,40.64 177.7,40.64 178.45,39.88 178.63,39.88 178.8,40.06 178.8,40.23 178.04,40.98 178.04,41.15 178.23,41.34 178.4,41.34 179.16,40.59 179.33,40.59 179.5,40.76 179.5,40.93 178.75,41.69 178.75,41.86 178.95,42.06 179.12,42.06 179.43,41.75 179.6,41.75 179.78,41.92 179.78,42.1 179.47,42.41 179.47,42.58 181.59,44.71 181.59,48.59 182.09,49.09 182.09,54.07 177.72,58.44 177.54,58.44 177.2,58.1 177.02,58.1 176.8,58.33 176.8,58.5 176.99,58.7 176.99,58.87 176.82,59.04 176.65,59.04 176.45,58.85 176.28,58.85 176.11,59.02 176.11,59.19 176.3,59.39 176.3,59.56 176.13,59.73 175.96,59.73 175.76,59.54 175.59,59.54 175.42,59.71 175.42,59.88 175.61,60.08 175.61,60.25 175.44,60.42 175.27,60.42 175.07,60.23 174.9,60.23 174.73,60.4 174.73,60.57 174.92,60.77 174.92,60.94 174.75,61.11 174.58,61.11 174.38,60.92 174.21,60.92 172.9,62.23 171.04,62.23 170.92,62.1 170.92,61.92 170.8,61.79 170.51,61.79 170.41,61.9 170.41,62.54 170.31,62.64 169.99,62.64 169.87,62.52 169.87,61.46 170.03,61.3 170.54,61.3 170.67,61.18 170.67,60.79 170.54,60.66 169.45,60.66 169.28,60.83 v1(169.28,62.17)
  BOTTOM w0.076: UC1.AU3 139.66,54.58 140.27,54.58 140.43,54.65 140.46,54.66 140.92,54.66 140.97,54.71 141.3,54.71
  BOTTOM w0.102: 141.3,54.71 142.58,54.71 142.83,54.45 144.15,54.45 145.22,53.39 v1(145.28,53.39) ; JSPI1.10 170.23,64.26 RC36.2 170.23,63.42 169.47,62.66 169.47,62.35 v1(169.28,62.17)
PCH_SPI_CS#0_R1: length 14.9
  BOTTOM w0.102: RC37.1 160.29,63.28 161.09,62.48 161.65,62.48 162.06,62.89 163.22,62.89 v3(163.76,63.42) 164.28,62.9 164.28,62.52 164.39,62.4 165.74,62.4 166.25,62.91 167.22,62.91 167.91,62.23 168.74,62.23 169.41,62.9 169.41,64.12 RC36.1 170.11,64.82 170.11,64.84 JSPI1.9
PCH_SPI_CS#0_R2: length 5
  BOTTOM w0.102: UC5.1 161.45,60.24 161.18,59.97 160.14,59.97 159.94,60.17 v3(159.94,60.83) RC37.2
PCH_SPI_CS#1: length 96.2
  TOP w0.102: v1(144.58,53.39) 144.91,53.06 v3(144.91,52)
  IN1 w0.089: v1(144.58,53.39) 145.76,52.21 145.76,48.53 146.09,48.19 146.09,46.34 147.6,44.83 153.09,44.83 155.58,42.34 158.45,42.34 162.82,37.97 v1(167.7,37.97)
  IN2 w0.122: v1(166.74,67.12) 166.23,66.62 166.23,60.94 166.6,60.58 166.6,58.94 167.88,57.66 167.88,53.95 168.69,53.15 168.69,49.39 169.56,48.51 169.56,45.45 169.11,45 169.11,44.57 169.23,44.44 170.66,44.44 170.79,44.32 170.79,44.08 170.66,43.96 169.23,43.96 169.11,43.84 169.11,43.59 169.23,43.47 170.66,43.47 170.79,43.35 170.79,43.1 170.66,42.98 169.23,42.98 169.11,42.86 169.11,42.62 169.23,42.49 170.66,42.49 170.79,42.37 170.79,42.13 170.66,42.01 169.23,42.01 169.11,41.88 169.11,41.64 169.23,41.52 170.66,41.52 170.79,41.4 170.79,41.15 170.66,41.03 169.23,41.03 169.11,40.91 169.11,40.61 169.23,40.49 170.66,40.49 170.79,40.37 170.79,40.13 170.66,40 169.23,40 169.11,39.88 169.11,37.77 168.6,37.26 165.43,37.26 165.28,37.41 165.28,37.82 165.43,37.97 v1(167.7,37.97)
  BOTTOM w0.076: 141.37,54.5 140.5,54.5 140.49,54.49 139.97,54.25 139.95,54.23 UC1.AU2
  BOTTOM w0.102: 141.37,54.5 142.47,54.5 142.77,54.2 144.02,54.2 144.58,53.64 v1(144.58,53.39) ; JSPI1.2 166.6,66.21 RC32.2 166.42,66.8 v1(166.74,67.12)
