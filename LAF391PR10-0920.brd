# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UPD1_SMBCLK_Q: length 24.7
  TOP w0.076: UT5.B5 29.44,62.56 30.3,62.56 30.46,62.4 30.83,62.4 v1(31,62.57)
  TOP w0.102: RT67.1 31.31,62.38 31.19,62.38 v1(31,62.57) ; RT58.2 37.66,65.96 38.05,65.57 QT1.6 37.46,65.39 v1(37.37,65.49) ; v1(21.81,64.56) 21.34,64.09 RT92.1 20.62,63.97 20.48,64.11 RT375.2
  IN2 w0.122: v1(21.81,64.56) 24.02,64.56 24.53,64.05 28.5,64.05 29.99,62.57 v1(31,62.57)
  IN4 w0.089: v1(31,62.57) 31.35,62.57 31.67,62.25 33.36,62.25 36.26,65.15 37.02,65.15 v1(37.37,65.49)
UPD1_SMBDAT: length 297.9
  TOP w0.076: UE1.B4 261.22,53.74 v1(261.22,54.45)
  TOP w0.102: v2(251.75,53.66) 251.75,53.11 v1(251.48,52.84) 250.79,52.84 RE302.1 ; v1(37.95,62.35) 37.95,62.69 RT59.1 37.57,63.92 37.74,64.09 QT1.4
  IN2 w0.122: v1(37.95,62.35) 37.95,61.13 37.39,60.57 37.39,55.16 36.55,54.33 34.27,54.33 31.42,51.48 26.7,51.48 25.96,50.75 25.96,49.7 29.01,46.66 31.55,46.66 32.2,47.31 32.2,47.48 32.35,47.63 34.81,47.63 35.28,48.11 35.28,48.61 35.61,48.94 37.77,48.94 40.73,45.97 42.78,45.97 43.24,45.51 44.25,45.51 44.72,45.98 51.26,45.98 52.11,45.13 53.09,45.13 65.11,33.11 70.12,33.11 72.73,30.5 96.88,30.5 99,32.62 136.26,32.62 142.96,25.92 153.94,25.92 155.53,27.52 182.64,27.52 186.17,31.04 197.09,31.04 198.05,30.08 199.12,30.08 199.33,29.86 209.58,29.86 210.41,29.04 214.48,29.04 215.35,28.17 220.1,28.17 220.19,28.26 221.82,28.26 222.1,27.97 223.1,27.97 223.46,28.33 226.33,28.33 227.64,29.64 232.49,29.64 233.02,30.17 236.14,30.17 242.16,36.2 243.6,36.2 244.23,36.83 244.38,36.83 246.06,38.51 246.06,40.6 247.4,41.94 247.87,41.94 250.04,44.11 250.04,45.8 251.23,46.99 251.23,51.13 250.94,51.42 250.94,52.43 251.35,52.84 v1(251.48,52.84) 251.8,52.84 252.02,52.62 253.04,52.62 253.42,53.01 253.67,53.01 254.44,53.77 255.96,53.77 256.98,54.78 258.5,54.78 259.26,54.02 259.77,54.02 260.2,54.45 v1(261.22,54.45)
UPD1_SMBDAT_Q: length 30.9
  TOP w0.076: v1(31,61.94) 30.82,62.12 30.45,62.12 30.22,62.36 29.74,62.36 UT5.A5
  TOP w0.102: v2(35.89,62.11) 36,62.21 v1(36,63.45) 36.28,63.45 RT59.2 36.86,63.28 36.86,63.9 36.67,64.09 QT1.3 ; RT376.2 19.59,65.45 21.11,65.45 RT93.1 20.91,64.69 v1(20.76,64.69) ; RT66.1 31.31,62.13 31.19,62.13 v1(31,61.94)
  IN4 w0.089: v1(31,61.94) 31.17,61.77 33.56,61.77 35.23,63.45 v1(36,63.45)
  BOTTOM w0.102: v1(20.76,64.69) 22.03,63.42 22.03,61.77 22.53,61.26 24.19,61.26 25.2,62.28 25.2,63.42 25.58,63.8 28.66,63.8 29.14,63.32 29.14,62.66 29.86,61.94 v1(31,61.94)
UPD1_SMBINT#: length 284.3
  TOP w0.102: RT60.1 34.04,51.96 34.88,51.12 34.88,49.47 35.18,49.17 35.18,49.17 35.58,48.78 v2(35.58,48.78) 36.49,48.78 37.25,48.01 v1(37.37,48.01) ; RE91.1 271.02,54.89 v1(270.97,54.94) ; UE1.F10 v1(266.04,50.51)
  IN1 w0.089: v1(266.04,50.51) 265.64,50.92 265.64,51.71 266.45,52.52 268.52,52.52 270.94,54.94 v1(270.97,54.94)
  IN2 w0.122: v1(37.37,48.01) 37.37,47.8 38.17,47 38.17,45.06 38.84,44.4 41.05,44.4 41.33,44.12 42.09,44.12 42.4,44.42 44.75,44.42 45.23,44.9 46.63,44.9 47.29,44.24 51.39,44.24 52.56,43.07 52.56,42.05 52.07,41.56 52.07,40.43 52.62,39.89 55.74,39.89 64.44,31.19 69.71,31.19 71.91,28.99 97.55,28.99 99.6,31.03 135.56,31.03 142.36,24.24 154.43,24.24 156.19,26.01 183.43,26.01 185.93,28.51 198.24,28.51 199.06,27.68 204.53,27.68 204.76,27.91 206.61,27.91 208.23,26.3 208.76,26.3 209.15,25.9 217.3,25.9 217.58,26.18 222.94,26.18 223.22,25.9 229.29,25.9 230.68,27.29 234.27,27.29 235.1,28.12 238.12,28.12 238.8,28.8 238.8,30.35 242.89,34.44 244.48,34.44 245.12,35.08 246.39,35.08 247.29,35.98 247.29,37.61 247.96,38.27 249.31,38.27 252.74,41.71 252.74,44.04 252.93,44.22 252.93,45.06 253.55,45.68 253.55,46.62 254.65,47.73 254.65,48.11 254.89,48.35 255.31,48.35 257.31,50.34 259.26,50.34 260.15,51.23 260.15,52.12 261.42,53.39 263.2,53.39 263.45,53.13 264.66,53.13 264.91,53.39 265.49,53.39 266.15,52.72 266.15,52.02 266.44,51.74 266.44,51.16 266.04,50.77 v1(266.04,50.51)
UPD1_SMBINT#_R: length 10.8
  TOP w0.076: 30.64,61.44 30.02,62.06 29.44,62.06 UT5.B6
  TOP w0.102: 30.64,61.44 v2(31.17,60.91) 32.03,60.91 33.18,59.76 RT68.1 RT60.2
UPD2_SMBCLK: length 14.9
  TOP w0.102: UE1.D7 264.04,51.73 v1(264.43,51.34)
  BOTTOM w0.102: RPE12.3 269.76,41.36 269.55,41.58 269.55,42.08 268.22,43.42 v2(267.39,43.42) 266.69,43.42 264.44,45.67 264.44,46.49 263.81,47.12 263.81,48.38 264.03,48.61 264.03,50.94 v1(264.43,51.34)
UPD2_SMBDAT: length 14.2
  TOP w0.102: UE1.E7 264.04,50.93 v1(264.43,50.54)
  BOTTOM w0.102: RPE12.4 270.26,43.02 268.78,44.51 268.27,44.51 267.9,44.88 v2(266.56,44.88) 266.37,45.07 266.37,45.99 265.48,46.88 265.03,46.88 264.85,47.07 264.85,47.64 264.82,47.66 264.82,50.15 v1(264.43,50.54)
UPD2_SMBINT#: length 15
  TOP w0.102: v1(253.9,55.57) 254.29,55.19 RE92.1 ; UE1.F5 v1(262.82,49.73)
  IN1 w0.089: v1(262.82,49.73) 262.48,50.07 262.48,50.8 262.31,50.97 259.52,50.97 258.63,51.86 256.98,51.86 256.21,52.62 256.21,54.66 255.3,55.57 v1(253.9,55.57)
  BOTTOM w0.102: v1(253.9,55.57) v2(254.53,55.57)
USB2_ID: length 247.8
  TOP w0.102: RT74.2 27.87,56.05 v2(27.87,53.12) 27.55,52.8 26.75,52.8 v1(26.55,53.01) ; v1(138.48,58.99) 138.51,59.02 139.71,59.02 140.54,58.19 142.88,58.19 143.93,59.24 145.59,59.24 146.14,59.79 RC337.1
  IN2 w0.122: v1(26.55,53.01) 26.37,52.83 23.83,52.83 23.47,53.18 20.73,53.18 12.45,61.46 12.45,63.93 12.07,64.31 12.07,67.84 12.86,68.63 12.86,71.5 13.19,71.83 14.13,71.83 16.84,74.55 16.84,77.64 15.88,78.61 15.88,80.46 16.23,80.82 18.6,80.82 20.35,82.57 30.41,82.57 30.89,82.09 38.18,82.09 44.86,88.77 52.3,88.77 53.11,89.57 53.11,92.13 54.11,93.14 54.47,93.14 62.92,93.14 63.05,93.01 65.08,93.01 65.46,93.39 67.6,93.39 69.26,95.05 69.26,98.83 70.41,99.98 70.41,101.39 72.45,103.42 73.4,103.42 74.99,105.01 77.31,105.01 80.29,102.03 83.45,102.03 85.61,99.87 88.06,99.87 88.47,99.46 92.97,99.46 93.58,98.85 98.36,98.85 98.74,98.46 102.97,98.46 103.76,97.67 107.64,97.67 109.66,95.65 109.66,94.07 114.25,89.48 117.78,89.48 118.98,88.29 134.14,88.29 136.97,85.45 144.21,85.45 145.22,84.45 145.22,82.35 147.04,80.52 147.04,77.97 145.18,76.1 145.18,72.48 145.49,72.17 145.49,70.38 146.5,69.37 147.42,69.37 148.05,68.74 148.05,67.64 146.27,65.86 146.27,62.23 145.7,61.66 145.7,59.38 146.06,59.02 146.06,58.24 145.06,57.24 141.5,57.24 140.77,57.96 140.01,57.96 139.25,58.72 138.75,58.72 v1(138.48,58.99)
  BOTTOM w0.076: UC1.AG3 139.13,59.53 138.59,58.99 v1(138.48,58.99)
USB2_VBUSSENSE: length 16.3
  TOP w0.102: RC338.1 149.46,59.91 149.7,60.16 v1(149.7,60.61) 149.7,60.89 v2(149.93,61.12)
  IN3 w0.122: v1(137.72,59.88) 138.24,60.4 140.72,60.4 141.17,59.95 142.02,59.95 142.78,60.72 143.98,60.72 144.23,60.47 146.89,60.47 147.41,59.95 149.24,59.95 149.7,60.41 v1(149.7,60.61)
  BOTTOM w0.076: UC1.AG4 138.4,59.53 138.05,59.88 v1(137.72,59.88)
USB3_PRX_C_DTX_N1: length 2.5
  TOP w0.094: UT9.4 27.6,71.84 27.71,71.74 27.71,71.65 27.48,71.42 27.16,71.42 26.95,71.21 26.95,70.96 CT112.2
USB3_PRX_C_DTX_P1: length 2.5
  TOP w0.094: UT9.5 28,71.84 27.9,71.74 27.9,71.57 27.56,71.24 27.23,71.24 27.14,71.14 27.14,70.96 CT111.2
USB3_PRX_DTX_N1: length 141.9
  TOP w0.094: v1(30.41,69.7) 30.21,69.9 30.03,69.9 29.27,69.13 28.18,69.13 28,68.95 27.15,68.95 26.95,69.15 26.95,69.34 CT112.1
  IN1 w0.076: v1(135.69,69.21) 135.51,69.39 135.06,69.39 134.93,69.26 133.96,69.26 133.43,68.73 132.69,68.73 132.41,69.01 132.41,71.27 132.41,71.27 132.41,71.29
  IN1 w0.089: v1(30.41,69.7) 30.53,69.82 32.26,69.82 32.59,69.49 33.56,69.49 33.84,69.77 34.64,69.77 37.04,72.17 47.04,72.17 47.58,72.71 49.56,72.71 49.96,72.31 54.54,72.31 57.66,75.43 57.66,77.01 64.44,83.79 68.43,83.79 71.34,86.7 72.38,86.7 73.65,87.96 74.03,87.96 74.7,88.64 75.24,88.64 76.46,89.86 77.45,89.86 78.29,90.7 82.63,90.7 85.45,93.52 86.57,93.52 86.82,93.77 92.21,93.77 92.67,94.24 93.29,94.24 93.7,93.82 100.77,93.82 101.94,92.65 102.5,92.65 102.54,92.6 103.36,92.6 103.79,92.17 103.79,91.54 105.36,89.96 105.36,88.46 110.03,83.79 110.03,82.11 109.4,81.48 109.4,79.29 109.28,79.17 109.28,77.97 110.52,76.73 110.52,75.74 111.41,74.85 112.3,74.85 112.53,74.85 113.26,75.59 116.03,75.59 118.17,73.45 124.14,73.45 124.57,73.02 125.08,73.02 126.51,71.58 131.16,71.58 131.5,71.93 131.96,71.93 132.41,71.48 132.41,71.29
  BOTTOM w0.076: v1(135.69,69.21) 136.04,69.21 136.11,69.14 UC1.H8
USB3_PRX_DTX_N2: length 153
  IN1 w0.089: v1(229.24,36.75) 229.44,36.95 229.44,37.24 229.35,37.33 228.83,37.33 228.73,37.44 214.25,37.44 212.41,39.28 210.2,39.28 209.02,40.46 207.12,40.46 206.3,41.27 203.74,41.27 202.34,42.67 201.02,42.67 200.44,43.25 198.63,43.25 192.69,49.2 192.69,50.29 184.15,58.83 184.15,60.09 182.78,61.47 182.78,64.39 174.27,72.9 169.51,72.9 168.72,73.69 164.66,73.69 162.99,75.37 162.89,75.37 162.08,76.17 160.6,76.17 158.72,78.05 158.14,78.05 155.81,80.39 153.27,80.39 152.81,80.84 151.34,80.84 150.98,81.2 144.83,81.2 143.61,79.98 143.46,79.98 142.45,78.97 142.45,78.27 141.17,77 141.17,76.8 139.64,75.26 138.6,75.26 137.67,74.34 137.67,73.73 136.4,72.46 136.4,71.7 136.2,71.5 136.2,71.06 137.47,69.8 137.47,69.16 137.06,68.75 136.77,68.75 v1(136.64,68.63)
  BOTTOM w0.076: UC1.J6 137.05,68.35 137.05,68.51 136.88,68.68 136.69,68.68 v1(136.64,68.63)
  BOTTOM w0.094: v1(229.24,36.75) 229.46,36.53 229.46,36.08 230.11,35.42 235.86,35.42 237.16,36.72 239.22,36.72 243.01,32.94 245.17,32.94 246.05,32.05 v4(248.87,32.05) 252.27,32.05 252.58,31.74 252.96,31.74 253.19,31.51 LI16.1 253.61,31.34 RI28.1
USB3_PRX_DTX_N3: length 205.5
  IN1 w0.076: 134.68,68.22 v1(134.75,68.15)
  IN1 w0.089: 134.68,68.22 134.6,68.3 134.01,68.3 132.97,67.26 132.44,67.26 132.03,67.66 132.03,67.81 131.7,68.14 131.7,68.14 131.54,68.3 130.61,68.3 129.56,69.34 125.35,69.34 125,69.7 125,71.14 123.41,72.73 117.87,72.73 115.88,74.72 114.53,74.72 114.07,74.26 111.18,74.26 109.93,75.51 109.93,76.49 108.64,77.78 108.64,78.76 108.45,78.95 108.45,79.15 108.38,79.22 108.38,79.96 105.85,82.5 105.85,83.59 104.35,85.09 104.35,89.43 102.65,91.13 102.65,91.66 102.24,92.07 101.71,92.07 100.54,93.24 98.38,93.24 97.74,92.6 94.01,92.6 93.42,93.19 87.38,93.19 86.69,92.5 85.25,92.5 82.86,90.11 78.51,90.11 77.68,89.28 76.69,89.28 75.47,88.06 74.93,88.06 74.26,87.39 73.88,87.39 72.6,86.1 71.76,86.1 68.84,83.18 64.65,83.18 59.62,78.15 59.62,76.5 54.74,71.62 47.5,71.62 47.41,71.54 43.46,71.54 42.71,70.79 40.81,70.79 40.48,71.11 39.68,71.11 39.2,71.6 37.28,71.6 35.41,69.73 35.41,68.84 35,68.43 32.34,68.43 31.91,67.99 30.03,67.99 28.99,69.03 25.74,69.03 25.13,68.43 25.13,60.09 24.06,59.02 24.06,56.82 24.44,56.44 24.44,55.67 22.61,53.84 22.61,51.51 20.81,49.7 20.81,43.07 19.11,41.37 19.11,34.84 18.42,34.16 18.42,31.03 18.27,30.89 18.27,26.92 20.3,24.89 20.3,23.06 22.25,21.1 22.25,20.54 22.05,20.34 21.76,20.34 v1(21.56,20.14)
  BOTTOM w0.076: v1(134.75,68.15) 135.02,68.15 UC1.J10
  BOTTOM w0.094: v1(21.56,20.14) 21.32,20.38 21.17,20.38 21.05,20.26 DI1.9 DI1.1 19.45,20.26 19.29,20.41 19.13,20.41 19.09,20.38 18.51,20.38 18.47,20.41 18.17,20.41 17.33,21.26 17.33,22.4 16.57,23.16 15.68,23.16 15.17,22.65 14.58,22.65 14.41,22.48 14.41,21.71 JUSB2.5
USB3_PRX_DTX_N6: length 210
  IN1 w0.089: v1(280.24,26.65) 280.64,26.25 282.67,26.25 283.47,27.05 283.47,28.68 283.19,28.95 283.19,30.43 281.67,31.95 281.67,35.34 282,35.67 282,40.38 279.5,42.88 277.78,42.88 277.61,42.72 272.9,42.72 272.87,42.69 267.69,42.69 265.43,41.07 262.51,41.07 261.35,42.23 260.53,42.23 260.4,42.11 257,42.11 256.39,41.5 254.39,41.5 253.62,42.27 253.46,42.41 251.14,42.97 249.91,42.97 249.14,43.15 247.8,43.79 242.32,43.79 238.87,42.4 238.28,41.8 234.55,41.8 234.14,41.4 231.83,41.4 231.53,41.09 218.25,41.09 212.64,42.22 208.07,42.22 207.27,43.02 204.42,43.02 202.88,44.57 201.71,44.57 186.82,59.46 184.53,64.08 184.53,65.12 179.07,70.59 177.34,74.12 176.3,75.16 169.7,75.16 169.39,75.46 167.21,75.46 166.6,76.07 165.54,76.07 164.6,77.01 163.96,77.01 163.86,77.11 163.58,77.11 163.2,77.49 163.2,77.98 160,81.18 152.46,83.55 149.41,86.61 144.53,86.61 136.96,79.04 136.96,78.08 137.32,77.73 137.32,74.8 137.09,74.57 137.09,73.96 135.82,72.69 135.82,71.93 135.44,71.55 135.13,71.55 134.75,71.17 134.75,71.17 134.24,70.66 134.24,70.28 v1(133.86,69.9)
  BOTTOM w0.076: UC1.G11 134.13,69.63 v1(133.86,69.9)
  BOTTOM w0.094: JUSB1.5 286.7,26.64 286.61,26.54 286.25,26.54 285.47,25.77 284.22,25.77 283.83,26.16 282.76,26.16 282.6,26.32 DI4.1 DI4.9 281.11,26.32 280.98,26.19 280.91,26.19 280.65,26.45 280.44,26.45 v1(280.24,26.65)
USB3_PRX_DTX_P1: length 141.8
  TOP w0.094: v1(30.41,70.28) 30.21,70.08 29.95,70.08 29.19,69.32 28.1,69.32 27.92,69.13 27.23,69.13 27.14,69.23 27.14,69.34 CT111.1
  IN1 w0.076: v1(135.64,69.92) 135.64,69.64 135.55,69.55 134.99,69.55 134.86,69.43 133.9,69.43 133.36,68.89 132.76,68.89 132.58,69.08 132.58,71.27 132.59,71.27 132.59,71.29
  IN1 w0.089: 132.59,71.29 132.59,71.55 132.03,72.11 131.43,72.11 131.08,71.76 126.59,71.76 125.15,73.2 124.64,73.2 124.21,73.63 118.24,73.63 116.11,75.77 113.19,75.77 112.45,75.03 111.48,75.03 110.7,75.81 110.7,76.8 109.46,78.05 109.46,79.09 109.58,79.22 109.58,81.4 110.21,82.04 110.21,83.87 105.54,88.54 105.54,90.04 103.97,91.61 103.97,92.25 103.43,92.78 102.62,92.78 102.57,92.83 102.01,92.83 100.84,94 93.78,94 93.36,94.42 92.6,94.42 92.13,93.95 86.75,93.95 86.49,93.7 85.37,93.7 82.55,90.88 78.21,90.88 77.38,90.04 76.38,90.04 75.16,88.82 74.63,88.82 73.95,88.14 73.57,88.14 72.31,86.88 71.27,86.88 68.36,83.97 64.37,83.97 57.48,77.08 57.48,75.51 54.46,72.49 50.04,72.49 49.64,72.89 47.5,72.89 46.96,72.35 36.97,72.35 34.56,69.95 33.76,69.95 33.48,69.67 32.67,69.67 32.33,70 30.69,70 v1(30.41,70.28)
  BOTTOM w0.076: v1(135.64,69.92) 135.93,69.63 UC1.G8
USB3_PRX_DTX_P2: length 153
  IN1 w0.089: v1(136.58,69.26) 136.9,68.93 136.99,68.93 137.29,69.24 137.29,69.72 136.02,70.99 136.02,71.57 136.22,71.78 136.22,72.54 137.49,73.81 137.49,74.42 138.52,75.45 139.56,75.45 140.99,76.88 140.99,77.07 142.27,78.35 142.27,79.04 143.39,80.16 143.54,80.16 144.76,81.38 151.06,81.38 151.41,81.02 152.88,81.02 153.34,80.57 155.88,80.57 158.22,78.23 158.8,78.23 160.68,76.35 162.16,76.35 162.96,75.55 163.06,75.55 164.73,73.87 168.8,73.87 169.59,73.08 174.34,73.08 182.96,64.46 182.96,61.54 184.33,60.17 184.33,58.9 192.87,50.37 192.87,49.27 198.71,43.43 200.51,43.43 201.1,42.85 202.42,42.85 203.81,41.45 206.38,41.45 207.19,40.64 209.1,40.64 210.28,39.46 212.49,39.46 214.33,37.62 228.81,37.62 228.91,37.51 229.42,37.51 229.62,37.32 229.62,36.95 v1(229.82,36.75)
  BOTTOM w0.076: UC1.H6 136.86,68.98 v1(136.58,69.26)
  BOTTOM w0.094: RI27.1 253.61,32.18 LI16.4 253.14,32.01 253.05,31.92 252.66,31.92 252.35,32.24 249.2,32.24 249.17,32.27 248.58,32.27 248.55,32.24 246.13,32.24 245.24,33.13 243.08,33.13 239.3,36.91 237.09,36.91 235.78,35.61 230.19,35.61 229.64,36.15 229.64,36.57 v1(229.82,36.75)
USB3_PRX_DTX_P3: length 205.5
  IN1 w0.089: v1(134.74,68.79) 134.43,68.48 133.94,68.48 133.66,68.2 133.66,68.2 132.9,67.43 132.51,67.43 132.21,67.74 132.21,67.88 131.61,68.48 130.68,68.48 129.64,69.52 125.42,69.52 125.18,69.77 125.18,71.22 123.49,72.91 117.95,72.91 115.95,74.9 114.46,74.9 114,74.44 111.26,74.44 110.11,75.59 110.11,76.56 108.82,77.86 108.82,78.84 108.63,79.03 108.63,79.22 108.56,79.29 108.56,80.04 106.03,82.57 106.03,83.66 104.53,85.16 104.53,89.5 102.83,91.21 102.83,91.74 102.32,92.25 101.78,92.25 100.61,93.42 98.3,93.42 97.67,92.78 94.08,92.78 93.5,93.37 87.31,93.37 86.62,92.68 85.17,92.68 82.78,90.29 78.44,90.29 77.6,89.46 76.61,89.46 75.39,88.24 74.86,88.24 74.19,87.57 73.81,87.57 72.52,86.29 71.69,86.29 68.76,83.36 64.57,83.36 59.44,78.23 59.44,76.58 54.67,71.8 47.42,71.8 47.34,71.72 43.39,71.72 42.64,70.97 40.88,70.97 40.55,71.29 39.76,71.29 39.27,71.78 37.21,71.78 35.23,69.81 35.23,68.92 34.92,68.61 32.27,68.61 31.83,68.17 30.1,68.17 29.06,69.21 25.66,69.21 24.95,68.5 24.95,60.17 23.88,59.1 23.88,56.74 24.26,56.36 24.26,55.75 22.43,53.92 22.43,51.58 20.63,49.78 20.63,43.15 18.92,41.45 18.92,34.92 18.24,34.23 18.24,31.11 18.09,30.96 18.09,26.84 20.12,24.81 20.12,22.98 22.07,21.03 22.07,20.62 21.98,20.52 21.76,20.52 v1(21.56,20.72)
  BOTTOM w0.076: v1(134.74,68.79) 134.93,68.98 UC1.H10
  BOTTOM w0.094: v1(21.56,20.72) 21.4,20.56 21.25,20.56 21.05,20.76 DI1.8 DI1.2 19.45,20.76 19.29,20.6 v4(18.8,20.6) 18.25,20.6 17.51,21.33 17.51,22.48 16.64,23.35 15.6,23.35 15.09,22.84 14.6,22.84 14.4,23.04 JUSB2.6
USB3_PRX_DTX_P6: length 210
  IN1 w0.089: v1(133.86,70.53) 135.06,71.73 135.36,71.73 135.64,72.01 135.64,72.77 136.91,74.04 136.91,74.65 137.14,74.87 137.14,77.65 136.78,78.01 136.78,79.11 144.45,86.79 149.48,86.79 152.56,83.71 160.09,81.33 163.38,78.05 163.38,77.57 163.66,77.29 163.93,77.29 164.04,77.19 164.67,77.19 165.61,76.25 166.68,76.25 167.29,75.64 169.47,75.64 169.77,75.34 176.38,75.34 177.49,74.22 179.21,70.7 184.71,65.2 184.71,64.12 186.96,59.57 201.78,44.75 202.95,44.75 204.5,43.2 207.35,43.2 208.14,42.41 212.65,42.41 218.27,41.27 231.45,41.27 231.75,41.58 234.06,41.58 234.47,41.98 238.21,41.98 238.77,42.55 242.29,43.97 247.84,43.97 249.2,43.32 249.94,43.15 251.16,43.15 253.54,42.57 253.74,42.4 254.46,41.68 256.32,41.68 256.93,42.29 260.33,42.29 260.46,42.41 261.42,42.41 262.59,41.25 265.37,41.25 267.63,42.87 272.8,42.87 272.83,42.9 277.54,42.9 277.7,43.06 279.57,43.06 282.18,40.46 282.18,35.6 281.85,35.26 281.85,32.02 283.37,30.5 283.37,29.03 283.65,28.75 283.65,26.97 282.74,26.07 v1(280.24,26.07)
  BOTTOM w0.076: v1(133.86,70.53) 134.12,70.28 UC1.F11
  BOTTOM w0.094: JUSB1.6 286.7,26.26 286.61,26.36 286.33,26.36 285.55,25.58 284.14,25.58 283.75,25.98 282.76,25.98 282.6,25.82 DI4.2 DI4.8 281.11,25.82 280.92,26.01 280.83,26.01 280.57,26.27 280.44,26.27 v1(280.24,26.07)
USB3_PRX_L_DTX_N2: length 14.1
  BOTTOM w0.094: JNGFF2.29 265.75,29.76 266.06,30.08 266.06,30.57 265.61,31.03 265.03,31.03 265.03,31.03 264.54,31.03 264.54,31.03 262.89,31.03 262.89,31.03 262.56,31.03 262.46,31.13 260.82,31.13 260.39,31.56 258.99,31.56 258.68,31.87 v4(255.96,31.87) 255.48,31.87 255.12,31.51 LI16.2 254.53,31.34 RI28.2
USB3_PRX_L_DTX_P2: length 14.2
  BOTTOM w0.094: RI27.2 254.53,32.18 LI16.3 255.35,32.01 255.4,32.06 255.63,32.06 255.67,32.09 256.26,32.09 256.29,32.06 258.75,32.06 259.07,31.75 260.46,31.75 260.9,31.31 262.54,31.31 262.64,31.22 262.89,31.22 265.11,31.22 265.69,31.22 266.25,30.65 JNGFF2.31
USB3_PTX_C_DRX_N1: length 4
  TOP w0.094: CT114.2 30.28,71.47 30.1,71.29 29.95,71.29 29.91,71.26 29.33,71.26 29.3,71.29 29.16,71.29 28.91,71.54 28.91,71.74 28.8,71.84 UT9.7
USB3_PTX_C_DRX_N2: length 2.2
  BOTTOM w0.094: CI29.1 252.19,33.43 252.84,33.43 252.94,33.32 LI17.1 253.61,33.15 RI30.1
USB3_PTX_C_DRX_N3: length 15.1
  BOTTOM w0.094: JUSB2.8 14.4,28.42 14.6,28.62 14.91,28.62 15.68,27.86 17.19,27.86 17.56,27.49 17.56,27.14 18.37,26.32 v4(18.37,25.64) 18.37,24.43 18.35,24.41 18.35,23.81 18.37,23.79 18.37,22.23 18.79,21.81 19.39,21.81 19.45,21.76 DI1.4 DI1.7 21.05,21.76 21.21,21.91 21.63,21.91 22.05,22.34 22.05,23.11 CI5.1
USB3_PTX_C_DRX_N6: length 17.2
  BOTTOM w0.094: CI13.1 281.96,27.72 281.82,27.59 281.82,27.23 281.61,27.02 281.07,27.02 281,27.09 279.63,27.09 279.16,26.62 279.16,26.38 279.2,26.34 279.2,25.74 279.16,25.71 279.16,25.3 v4(279.59,24.88) 279.8,24.66 280.85,24.66 281,24.82 DI4.7 DI4.4 282.6,24.82 282.76,24.66 283.68,24.66 284.28,24.06 284.28,21.52 284.61,21.19 285.59,21.19 286.24,20.54 286.61,20.54 286.7,20.64 JUSB1.8
USB3_PTX_C_DRX_P1: length 3.9
  TOP w0.094: CT113.2 31.03,71.66 30.2,71.66 30.03,71.48 v4(29.62,71.48) 29.23,71.48 29.1,71.62 29.1,71.74 29.2,71.84 UT9.8
USB3_PTX_C_DRX_P2: length 2.1
  BOTTOM w0.094: CI30.1 252.05,33.61 252.74,33.61 252.94,33.82 LI17.4 253.61,33.99 RI29.1
USB3_PTX_C_DRX_P3: length 15.1
  BOTTOM w0.094: CI4.1 21.87,22.61 21.87,22.42 21.55,22.1 21.21,22.1 21.05,22.26 DI1.6 DI1.5 19.45,22.26 19.19,22 18.87,22 18.57,22.3 v4(18.57,24.11) 18.57,25.27 18.59,25.29 18.59,26.02 18.56,26.06 18.56,26.4 17.75,27.21 17.75,27.56 17.26,28.05 15.75,28.05 14.99,28.81 14.53,28.81 14.4,28.94 JUSB2.9
USB3_PTX_C_DRX_P6: length 17.2
  BOTTOM w0.094: CI16.1 281.64,27.44 281.64,27.31 281.54,27.21 281.15,27.21 281.08,27.28 279.56,27.28 278.98,26.7 v4(278.98,26.04) 278.98,25.39 278.98,25.38 278.98,25.23 279.19,25.02 279.19,24.97 279.65,24.51 279.69,24.51 279.73,24.48 280.85,24.48 281,24.32 DI4.6 DI4.5 282.6,24.32 282.76,24.48 283.6,24.48 284.1,23.98 284.1,21.44 284.54,21 285.52,21 286.16,20.36 286.61,20.36 286.7,20.26 JUSB1.9
USB3_PTX_DRX_N1: length 133
  TOP w0.094: v1(33.36,71.62) 33.16,71.82 33,71.82 CT114.1
  IN1 w0.089: v1(33.36,71.62) 33.07,71.62 33.07,71.63 32.56,71.63 32.36,71.82 32.36,72.59 32.67,72.9 35.8,72.9 36.46,73.56 39.53,73.56 39.93,73.96 41.03,73.96 41.33,74.27 42.32,74.27 43.06,73.53 46.23,73.53 47.3,74.6 48.72,74.6 49.13,74.19 50.88,74.19 51.18,73.89 52.53,73.89 61.88,83.23 61.98,83.23 64.47,85.72 66.93,85.72 70.57,89.36 72.8,89.36 72.85,89.31 73.49,89.31 73.71,89.53 73.71,90.22 75.11,91.62 77.32,91.62 77.93,92.22 80.7,92.22 80.96,92.48 82.53,92.48 82.71,92.66 82.71,94.03 83.55,94.87 86.04,94.87 86.29,95.12 91.67,95.12 91.8,95.24 91.8,95.65 92.16,96.01 92.74,96.01 93.17,95.58 101.81,95.58 103,94.39 103.68,94.39 105.77,92.3 105.77,91.43 106.71,90.5 106.71,89 110.16,85.55 116.82,85.55 117.4,86.13 123.53,86.13 126.18,83.47 128.66,83.47 131.42,80.71 131.42,77.48 131.59,77.31 132.72,77.31 133.15,76.89 v1(133.25,76.89)
  BOTTOM w0.076: 133.92,75.8 133.92,75.78 133.91,75.77 133.91,74.51 133.21,73.81 133.21,73.54 133.26,73.43 133.26,73.28 133.21,73.08 133.21,72.91 133.35,72.47 UC1.C13
  BOTTOM w0.094: 133.92,75.8 133.92,75.88 133.63,76.17 133.63,76.5 v1(133.25,76.89)
USB3_PTX_DRX_N2: length 147.4
  IN1 w0.089: v1(230.99,36.75) 231.16,36.91 231.16,37.42 230.61,37.97 229.04,37.97 228.99,38.01 214.49,38.01 212.65,39.85 210.54,39.85 209.35,41.04 207.4,41.04 206.58,41.86 203.97,41.86 202.52,43.3 201.23,43.3 200.41,44.12 199.47,44.12 193.3,50.29 193.3,50.52 184.79,59.03 184.79,60.48 183.37,61.9 183.37,64.64 174.53,73.47 169.75,73.47 168.94,74.29 164.88,74.29 163.22,75.94 163.12,75.94 162.31,76.75 160.94,76.75 160.25,77.44 160.25,78.33 159.24,79.34 157.66,79.34 156.04,80.97 153.65,80.97 153.09,81.53 151.62,81.53 151.36,81.78 143.97,81.78 143.36,81.18 143.36,80.74 139.53,76.91 138.51,76.91 v1(138.29,76.68)
  BOTTOM w0.076: UC1.B13 133.78,73.3 133.91,73.3 134.06,73.46 134.06,74.12 134.59,74.65 134.59,75.35 134.6,75.36
  BOTTOM w0.094: v1(230.99,36.75) 231.23,36.51 231.23,36.38 231.55,36.06 234.29,36.06 235.54,37.31 239.52,37.31 242.8,34.02 246.36,34.02 247.01,33.37 250.49,33.37 CI29.2 ; 134.6,75.36 134.6,75.54 134.78,75.72 136.3,75.72 137.47,76.88 138.09,76.88 v1(138.29,76.68)
USB3_PTX_DRX_N3: length 187.2
  IN1 w0.089: v1(19.44,24.26) 19.21,24.26 19.13,24.18 19.13,23.94 19.04,23.85 18.84,23.85 18.47,24.23 18.47,25.83 17.67,26.63 17.67,31.25 17.84,31.41 17.84,34.72 18.47,35.35 18.47,41.58 19.9,43 19.9,51.61 21.65,53.36 21.65,54.38 22.58,55.31 22.58,56.23 23.48,57.12 23.48,59.26 24.55,60.34 24.55,68.87 25.58,69.9 28.25,69.9 29.65,71.29 30.66,71.29 31.04,70.91 34.96,70.91 36.79,72.75 46.72,72.75 47.3,73.33 50.53,73.33 50.78,73.07 53.52,73.07 56.37,75.92 56.37,76.55 64.77,84.95 67.87,84.95 71.5,88.59 72.47,88.59 72.52,88.54 73.79,88.54 74.48,89.23 74.48,89.3 75.14,89.96 75.74,89.96 76.23,90.45 77.22,90.45 78.06,91.28 82.4,91.28 85.22,94.1 86.34,94.1 86.59,94.36 91.98,94.36 92.43,94.81 93.55,94.81 93.96,94.41 101.78,94.41 103,93.19 103.81,93.19 105.01,91.99 105.01,91.13 105.95,90.19 105.95,88.69 109.86,84.78 117.63,84.78 117.86,85.01 123.37,85.01 125.71,82.67 128.31,82.67 130.66,80.32 130.66,77.16 131.7,76.12 132.15,76.12 132.24,76.03 132.24,75.82 132.33,75.72 v1(132.6,75.72)
  BOTTOM w0.076: UC1.B15 132.53,73.59 132.53,74.06 132.2,74.39 132.2,75.63 132.29,75.72 v1(132.6,75.72)
  BOTTOM w0.094: CI5.2 21.8,24.48 21.8,24.69 21.6,24.9 20.88,24.9 20.24,24.26 v1(19.44,24.26)
USB3_PTX_DRX_N6: length 199.4
  IN1 w0.089: v1(137.69,77.91) 137.86,78.08 137.86,79.04 138.55,79.73 141.28,79.73 141.47,79.92 141.66,80.11 142.26,80.97 142.69,83.41 143.98,85.25 144.61,85.87 145.8,85.87 145.88,85.8 149.48,85.8 152.05,83.24 160.11,80.5 162.79,77.82 162.79,77.34 163.43,76.71 163.71,76.71 163.81,76.6 164.44,76.6 165.99,75.06 169.24,75.06 169.53,74.76 172.66,74.76 174.83,74.27 184.13,64.97 184.13,63.98 186.17,59.43 201.48,44.12 202.77,44.12 204.27,42.62 207.04,42.62 207.85,41.8 212.16,41.8 212.81,41.16 215.78,41.16 217.94,40.7 224.96,40.7 226.06,39.6 227.69,39.6 228.58,40.49 232.39,40.49 232.59,40.69 238.18,40.69 239.71,42.21 241.23,42.21 242.4,43.38 247.69,43.38 249.67,42.06 253.19,42.06 254.16,41.09 256.57,41.09 257.05,41.58 260,41.58 260.15,41.43 261.52,41.43 262.28,40.66 267.49,40.66 267.9,41.07 271.84,41.07 273.08,42.31 277.9,42.31 278.07,42.48 279.35,42.48 281.6,40.22 281.6,35.89 281.28,35.56 281.28,31.76 281.92,31.11 281.92,29.55 v1(282.14,29.33)
  BOTTOM w0.076: 133.1,77.41 133.08,77.41 133.07,77.42 132.69,77.42 132.5,77.22 132.08,77.22 131.83,76.97 131.83,72.92 131.86,72.82 131.86,72.62 UC1.D16
  BOTTOM w0.094: 133.1,77.41 133.66,77.41 134.65,76.42 135.82,76.42 136.82,77.41 136.82,77.95 137.21,78.34 137.78,78.34 137.88,78.25 137.88,78.09 v1(137.69,77.91) ; CI13.2 281.94,29.01 281.94,29.14 v1(282.14,29.33)
USB3_PTX_DRX_P1: length 133
  TOP w0.094: CT113.1 33,72.01 33.16,72.01 v1(33.36,72.21)
  IN1 w0.089: v1(133.22,76.3) 132.85,76.68 132.85,76.93 132.64,77.13 131.51,77.13 131.24,77.4 131.24,80.63 128.58,83.29 126.1,83.29 123.45,85.95 117.48,85.95 116.9,85.37 110.09,85.37 106.53,88.92 106.53,90.42 105.59,91.36 105.59,92.22 103.61,94.2 102.92,94.2 101.73,95.4 93.1,95.4 92.66,95.83 92.23,95.83 91.98,95.58 91.98,95.17 91.75,94.94 86.36,94.94 86.11,94.69 83.62,94.69 82.89,93.95 82.89,92.58 82.61,92.3 81.03,92.3 80.78,92.04 78.01,92.04 77.4,91.44 75.19,91.44 73.89,90.14 73.89,89.45 73.56,89.12 72.78,89.12 72.72,89.18 70.64,89.18 67.01,85.54 64.54,85.54 62.05,83.05 61.95,83.05 52.61,73.71 51.11,73.71 50.81,74.01 49.05,74.01 48.65,74.42 47.37,74.42 46.31,73.35 42.98,73.35 42.25,74.09 41.41,74.09 41.1,73.78 40.01,73.78 39.61,73.38 36.53,73.38 35.87,72.72 32.74,72.72 32.54,72.51 32.54,71.89 32.63,71.81 32.96,71.81 33.05,71.9 33.05,72.13 33.13,72.21 v1(33.36,72.21)
  BOTTOM w0.076: UC1.D13 133.18,72.26 133.18,72.41 133.05,72.86 133.04,72.89 133.04,73.11 133.1,73.3 133.1,73.39 133.04,73.5 133.04,73.87 133.75,74.58 133.75,75.77 133.74,75.78
  BOTTOM w0.094: v1(133.22,76.3) 133.4,76.13 133.74,75.79 133.74,75.78
USB3_PTX_DRX_P2: length 147.3
  IN1 w0.089: v1(138.29,77.27) 138.46,77.09 139.46,77.09 143.18,80.82 143.18,81.25 143.9,81.96 151.44,81.96 151.69,81.71 153.17,81.71 153.73,81.15 156.11,81.15 157.74,79.52 159.31,79.52 160.43,78.41 160.43,77.52 161.02,76.93 162.39,76.93 163.2,76.12 163.3,76.12 164.95,74.47 169.01,74.47 169.83,73.65 174.61,73.65 183.55,64.71 183.55,61.97 184.97,60.55 184.97,59.1 193.48,50.59 193.48,50.36 199.55,44.3 200.48,44.3 201.3,43.48 202.59,43.48 204.04,42.04 206.66,42.04 207.47,41.22 209.43,41.22 210.62,40.03 212.73,40.03 214.57,38.19 229.07,38.19 229.11,38.15 230.69,38.15 231.34,37.5 231.34,36.99 v1(231.58,36.75)
  BOTTOM w0.076: UC1.A13 133.66,73.47 133.84,73.47 133.9,73.53 133.9,74.19 134.43,74.72 134.43,75.18 134.42,75.19 134.42,75.36
  BOTTOM w0.094: v1(231.58,36.75) 231.42,36.59 231.42,36.46 231.63,36.24 234.21,36.24 235.46,37.49 239.59,37.49 242.88,34.21 246.44,34.21 247.09,33.55 250.52,33.55 CI30.2 ; 134.42,75.36 134.42,75.61 134.7,75.9 136.23,75.9 137.39,77.06 138.09,77.06 v1(138.29,77.27)
USB3_PTX_DRX_P3: length 187.3
  IN1 w0.089: v1(132.64,76.3) 131.78,76.3 130.84,77.24 130.84,80.4 128.39,82.85 125.79,82.85 123.45,85.19 117.78,85.19 117.56,84.96 109.94,84.96 106.13,88.77 106.13,90.27 105.19,91.21 105.19,92.07 103.89,93.37 103.08,93.37 101.86,94.59 94.04,94.59 93.63,94.99 92.36,94.99 91.9,94.54 86.52,94.54 86.26,94.28 85.15,94.28 82.32,91.46 77.98,91.46 77.15,90.63 76.15,90.63 75.67,90.14 75.06,90.14 74.3,89.38 74.3,89.3 73.71,88.72 72.6,88.72 72.55,88.77 71.43,88.77 67.79,85.13 64.69,85.13 56.19,76.63 56.19,75.99 53.45,73.25 50.86,73.25 50.6,73.51 47.22,73.51 46.65,72.93 36.71,72.93 34.88,71.09 31.12,71.09 30.74,71.47 29.57,71.47 28.17,70.08 25.51,70.08 24.37,68.94 24.37,60.41 23.3,59.33 23.3,57.2 22.4,56.3 22.4,55.39 21.46,54.45 21.46,53.44 19.71,51.69 19.71,43.08 18.29,41.65 18.29,35.43 17.65,34.79 17.65,31.49 17.49,31.32 17.49,26.55 18.29,25.75 18.29,24.15 18.77,23.67 v1(19.44,23.67)
  BOTTOM w0.076: UC1.A15 132.18,73.59 132.29,73.59 132.36,73.66 132.36,73.99 132.03,74.32 132.03,75.7 v1(132.64,76.3)
  BOTTOM w0.094: v1(19.44,23.67) 19.65,23.67 19.74,23.77 19.74,23.98 19.83,24.07 20.32,24.07 20.96,24.71 21.52,24.71 21.62,24.62 21.62,24.48 CI4.2
USB3_PTX_DRX_P6: length 199.3
  IN1 w0.089: v1(138.38,77.91) 138.17,77.91 138.09,77.99 138.09,78.07 138.04,78.12 138.04,78.97 138.63,79.55 141.36,79.55 141.79,79.99 142.43,80.9 142.86,83.33 144.12,85.13 144.68,85.69 145.73,85.69 145.8,85.62 149.41,85.62 151.95,83.08 160.01,80.35 162.61,77.75 162.61,77.26 163.35,76.53 163.63,76.53 163.74,76.42 164.37,76.42 165.92,74.88 169.16,74.88 169.46,74.58 172.63,74.58 174.74,74.11 183.95,64.89 183.95,63.94 186.02,59.32 201.4,43.94 202.7,43.94 204.2,42.44 206.97,42.44 207.78,41.62 212.08,41.62 212.73,40.98 215.76,40.98 217.92,40.52 224.88,40.52 225.99,39.42 227.77,39.42 228.66,40.31 232.47,40.31 232.67,40.51 238.25,40.51 239.78,42.03 241.3,42.03 242.47,43.2 247.63,43.2 249.61,41.88 253.12,41.88 254.08,40.91 256.64,40.91 257.13,41.4 259.93,41.4 260.08,41.25 261.45,41.25 262.21,40.48 267.57,40.48 267.97,40.89 271.91,40.89 273.15,42.13 277.98,42.13 278.14,42.3 279.27,42.3 281.42,40.15 281.42,35.96 281.09,35.63 281.09,31.68 281.74,31.04 281.74,29.35 281.62,29.23 281.49,29.23 v1(281.38,29.35)
  BOTTOM w0.076: 133.1,77.59 133.08,77.59 133.07,77.58 132.63,77.58 132.43,77.39 132.01,77.39 131.66,77.04 131.66,72.78 UC1.C16
  BOTTOM w0.094: 133.1,77.59 133.74,77.59 134.73,76.6 135.75,76.6 136.63,77.49 136.63,78.02 137.13,78.53 137.86,78.53 138.06,78.33 138.06,78.22 138.37,77.91 v1(138.38,77.91) ; CI16.2 281.66,28.93 281.66,29.07 v1(281.38,29.35)
USB3_PTX_L_DRX_N2: length 16.4
  BOTTOM w0.094: JNGFF2.35 267.25,29.75 267.39,29.89 267.44,29.89 267.56,30.02 267.56,30.48 266.43,31.62 265.76,31.62 265.76,31.61 265.28,31.61 265.28,31.62 262.8,31.62 262.7,31.72 261.34,31.72 260.31,32.75 259.21,32.75 259.02,32.56 257.04,32.56 255.99,33.61 255.99,33.6 255.39,33.6 255.1,33.32 LI17.2 254.53,33.15 RI30.2
USB3_PTX_L_DRX_P2: length 16.5
  BOTTOM w0.094: RI29.2 254.53,33.99 LI17.3 v4(255.71,33.82) 256.04,33.82 257.12,32.74 258.94,32.74 259.14,32.94 260.39,32.94 261.42,31.91 262.77,31.91 262.88,31.8 265.35,31.8 265.68,31.8 266.51,31.8 267.75,30.56 JNGFF2.37
USB20_N1: length 193.8
  TOP w0.076: v1(23.19,62.6) 23.27,62.52 24.41,62.52 24.45,62.56 24.82,62.56 UT5.K5
  IN2 w0.122: v1(136.22,62.01) 136.66,62.45 138.43,62.45 140.67,64.69 140.67,67.87 141.17,68.37 141.17,72.15 141.95,72.94 141.95,77.33 142.53,77.9 142.9,77.9 143.54,78.54 143.54,79.19 143.39,79.35 143.39,81.68 142.98,82.09 142.98,82.7 142.44,83.23 135,83.23 132.39,85.85 129.21,85.85 128.53,86.53 117.55,86.53 116.57,87.52 113.6,87.52 112.33,88.78 110.02,88.78 109.45,89.35 102.09,89.35 100.41,91.03 99.21,91.03 98.43,91.82 93.91,91.82 93.27,92.45 92.29,92.45 89.96,94.79 86.19,94.79 83.89,92.49 82.04,92.49 78.94,95.59 77.32,95.59 74.47,98.45 72.32,98.45 69.74,95.86 69.74,94.93 67.18,92.38 59.44,92.38 59.11,92.71 54.29,92.71 53.54,91.96 53.54,90.76 54.05,90.25 54.05,89.42 52.16,87.53 45.02,87.53 40.9,83.4 40.9,80.77 36.23,76.1 33.69,76.1 32.95,75.35 32.95,72.86 32.21,72.13 32.21,66.25 30.92,64.95 30.92,64.18 31.8,63.3 31.8,61.65 32.24,61.21 32.24,58.39 30.61,56.77 24.64,56.77 24.06,57.35 24.06,62.22 23.8,62.48 23.31,62.48 v1(23.19,62.6)
  BOTTOM w0.076: v1(136.22,62.01) 136.22,62.05 135.95,62.47 UC1.AB9
USB20_N2: length 140.8
  TOP w0.094: LI3.4 26.13,21.53 26.33,21.32 26.79,21.32 26.92,21.45 26.92,21.58 v1(26.72,21.78)
  IN1 w0.076: 127,61.58 127,61.58 128.61,63.19 132.33,63.19 132.61,62.92 132.61,62.65 132.95,62.3 133.26,62.3 134.22,61.35 135.67,61.35 135.92,61.1 135.92,60.63 136.28,60.27 136.94,60.27 137.11,60.45 137.11,60.7 v1(137.25,60.84)
  IN1 w0.089: v1(26.72,21.78) 26.78,21.72 26.78,21.08 28.33,19.53 32.77,19.53 33.17,19.93 44.32,19.93 45.58,21.19 46.65,21.19 49.81,24.35 51.92,24.35 63.87,36.31 63.87,38.35 70.03,44.5 70.79,44.5 72.79,46.5 76.23,46.5 77.32,47.6 79,47.6 81.59,50.19 81.59,52.26 89.15,59.81 95.58,59.81 95.66,59.74 97.69,59.74 98.12,59.31 100.61,59.31 101.48,60.17 104.4,60.17 105.44,59.13 105.44,58.87 106.71,57.6 125.18,57.6 126.04,58.47 126.04,60.61 126.91,61.48 126.91,61.49 127,61.58
  BOTTOM w0.076: UC1.AD6 137.81,61.4 v1(137.25,60.84)
USB20_N2_R: length 13.7
  TOP w0.094: JUSB2.2 15.9,25.98 16.09,25.79 16.47,25.79 17.85,24.42 v4(17.85,23.76) 17.85,22.62 18.14,22.33 18.33,22.33 18.36,22.36 19,22.36 19.03,22.34 21.11,22.34 22.12,21.32 22.59,21.32 22.69,21.42 DI2.3 23.56,21.32 24.07,21.32 24.28,21.53 LI3.3
USB20_N4: length 138.5
  TOP w0.094: v1(251.45,28.67) 251.68,28.45 251.77,28.45 251.9,28.57 252.08,28.57 252.26,28.76 LI8.1 252.65,28.9 RI48.1
  IN1 w0.076: v1(135.55,60.83) 135.49,60.83 135.11,60.45 135.11,59.69 135.32,59.47 137.9,59.47 138.1,59.67 138.85,59.67 139.48,59.05 140.11,59.05 142.69,56.47 142.69,56.14 142.87,55.96 142.88,55.96 142.9,55.94
  IN1 w0.089: v1(251.45,28.67) 251.17,28.4 250.57,28.4 249.56,29.41 248.86,29.41 246.11,26.66 245.75,26.42 245.68,26.35 245.46,26.2 245.32,26.14 245.09,25.98 245.08,25.98 244.65,25.74 242.23,25.74 240.42,27.56 237.9,27.56 237.5,27.15 229.37,27.15 229.04,27.48 223.45,27.48 222.87,26.9 218.18,26.9 216.85,25.57 212.45,25.57 209.55,28.47 206.71,28.47 204.27,30.91 202.04,30.91 200.54,32.41 199.17,32.41 196.83,34.74 190.33,34.74 184.59,40.48 181.16,40.48 177.72,43.92 170.58,43.92 170.22,44.27 165.57,44.27 164.51,45.34 163.52,45.34 156.47,52.39 156.47,52.87 155.03,54.31 152.47,54.31 152.3,54.48 147.3,54.48 146.46,55.32 143.52,55.32 142.9,55.94
  BOTTOM w0.076: v1(135.55,60.83) 135.55,61.03 UC1.AD9
USB20_N4_L: length 11
  TOP w0.094: RI48.2 253.73,28.76 LI8.2 254.13,28.76 254.26,28.63 254.74,28.63 v1(254.91,28.8)
  BOTTOM w0.094: v1(254.91,28.8) 255.59,28.8 255.88,29.08 v4(255.88,29.82) 255.88,30.58 256.74,31.44 258.53,31.44 258.81,31.16 259.62,31.16 260.13,30.65 260.13,30.45 260.67,29.91 260.67,29.72 260.75,29.64 JNGFF2.9
USB20_N5: length 114.7
  TOP w0.094: v1(73.31,101.6) 73.31,101.6 73.11,101.4 72.7,101.4 72.49,101.61 LZ1.4
  IN2 w0.122: v1(143.69,57.69) 143.47,57.92 143.47,58.19 145.23,59.96 145.23,61.79 145.84,62.4 145.84,66.91 144.86,67.89 144.86,71.63 143.81,72.68 143.67,72.68 143.29,73.06 143.29,74.88 146.54,78.13 146.54,80.42 144.78,82.18 144.78,83.46 143.31,84.93 135.36,84.93 132.44,87.85 118.31,87.85 117.25,88.92 114.21,88.92 109.93,93.2 107.81,93.2 107.34,92.73 106.45,92.73 101.3,97.89 97.54,97.89 97.01,98.42 93.4,98.42 92.79,99.03 88.29,99.03 87.89,99.44 85.45,99.44 83.29,101.6 79.84,101.6 79.31,101.07 74.45,101.07 74.08,101.44 73.48,101.44 v1(73.31,101.6)
  BOTTOM w0.076: UC1.AJ1 140.8,58.21 140.98,58.38 143.13,58.38 143.35,58.15 143.35,58.04 v1(143.69,57.69)
USB20_N5_R: length 6.2
  TOP w0.094: LZ1.3 70.81,101.61 70.6,101.4 70.31,101.4 70.11,101.2 70.11,100.35 69.45,99.69 69.01,99.69 68.98,99.73 68.39,99.73 68.36,99.69 67.56,99.69 v1(67.37,99.89)
  BOTTOM w0.094: v1(67.37,99.89) 67.56,99.69 67.7,99.69 67.86,99.85 JEDP1.12
USB20_N7: length 81
  IN1 w0.089: v1(144.32,57.67) 144.59,57.94 144.59,58.61 145.94,59.95 150.37,59.95 150.75,59.57 152.75,59.57 153.22,59.1 153.22,58.92 154.06,58.09 154.87,58.09 156.47,56.49 157.96,56.49 160.92,53.53 163.23,53.53 163.5,53.26 169.85,53.26 170.45,52.66 173.3,52.66 174.05,51.92 175.64,51.92 178.59,48.97 180.37,48.97 181.01,48.33 181.01,47.06 183.13,44.94 185.14,44.94 190.35,39.72 193.04,39.72 193.22,39.54 193.22,39.24 v1(193.42,39.04)
  BOTTOM w0.076: UC1.AH1 140.16,58.87 140.08,58.79 140.08,58.67 140.16,58.59 140.44,58.59 140.63,58.78 140.86,58.78 141.02,58.62 142.99,58.62 143.22,58.85 144.47,58.85 144.61,58.72 144.61,57.96 v1(144.32,57.67)
  BOTTOM w0.094: v1(193.42,39.04) 193.22,39.24 193.22,39.54 193.32,39.65 193.96,39.65 194.31,39.29 196.83,39.29 198.68,37.44 202.26,37.44 202.64,37.81 205.51,37.81 LI9.1 205.85,37.47 RI50.1
USB20_N7_L: length 3.7
  BOTTOM w0.094: RI50.2 206.76,37.48 LI9.2 207.14,37.64 207.29,37.8 207.66,37.8 207.69,37.77 208.29,37.77 208.32,37.8 208.93,37.8 209.07,37.66 209.3,37.66 209.46,37.5 JNGFF1.5
USB20_N8: length 124.6
  TOP w0.094: LV27.2 73.15,107.03 73.36,106.82 73.57,106.82 73.96,106.44 73.96,106.21 73.99,106.18 73.99,105.58 73.96,105.54 73.96,105.32 v4(73.09,104.45) 72.62,103.98 72.62,102.89 72.85,102.66 73.1,102.66 v1(73.3,102.86)
  IN2 w0.122: v1(73.3,102.86) 73.12,102.69 72.48,102.69 71.96,102.17 71.96,100.35 73.44,98.88 74.67,98.88 75.55,97.99 77.16,97.99 79.46,95.69 82.67,95.69 83.14,95.22 90.15,95.22 92.49,92.88 93.71,92.88 94.34,92.25 98.61,92.25 99.17,91.69 100.36,91.69 102.17,89.88 104.21,89.88 104.57,90.24 111.63,90.24 113.91,87.95 116.85,87.95 117.84,86.96 132.06,86.96 135.24,83.79 142.83,83.79 143.41,83.21 143.41,82.27 145.37,80.32 145.37,79.75 143.84,78.22 143.84,77.03 142.39,75.58 142.39,72.68 143.29,71.78 143.4,71.78 143.81,71.37 143.81,69.7 143.36,69.25 143.36,62.16 143.92,61.61 143.92,60.09 142.53,58.7 140.55,58.7 139.79,59.46 138.99,59.46 138.72,59.74 138.24,59.74 137.97,59.46 136.73,59.46 136.63,59.56 136.63,59.68 v1(136.86,59.9)
  BOTTOM w0.076: v1(136.86,59.9) 136.94,59.98 136.94,60.19 136.9,60.23 136.9,60.38 136.83,60.45 136.68,60.45 UC1.AF8
USB20_N8_R: length 9.7
  TOP w0.094: v1(66.48,105.18) 66.7,104.95 67.95,104.95 DV4.2 68.92,105.04 69.23,105.04 69.4,105.21 69.4,105.72 70.5,106.82 71.26,106.82 71.47,107.03 LV27.1
  BOTTOM w0.094: v1(66.48,105.18) 66.58,105.07 67.19,105.07 67.57,104.69 67.7,104.69 67.86,104.85 JEDP1.2
USB20_N9: length 166.2
  TOP w0.094: v1(276.95,32.16) 276.75,31.96 276.75,31.81 276.91,31.65 UI3.2
  IN1 w0.076: 145.06,56.89 145.04,56.89 145.04,56.9 142.89,56.9 141.35,58.44 v1(141.35,59.29)
  IN1 w0.089: 145.06,56.89 146.65,56.89 147.98,55.56 149.37,55.56 149.85,55.07 155.06,55.07 155.58,55.59 156.32,55.59 156.77,55.14 156.77,54 157,53.77 157,52.42 160.71,48.71 161.48,48.71 162.14,48.06 162.14,47.32 163.56,45.9 164.51,45.9 165.75,44.67 170.38,44.67 170.62,44.42 177.77,44.42 180.47,41.73 183.9,41.73 190.07,35.56 193.93,35.56 194.34,35.15 196.98,35.15 199.27,32.86 200.64,32.86 201.22,32.28 201.22,32.28 201.58,31.92 204.73,31.92 207.13,29.52 209.11,29.52 212.65,25.98 216.7,25.98 218.09,27.37 218.45,27.73 222.03,27.73 222.18,27.88 229.29,27.88 229.57,27.61 235.51,27.61 236.15,28.24 240.29,28.24 242.39,26.14 244.46,26.14 244.99,26.43 245.17,26.51 245.38,26.65 245.48,26.7 245.51,26.74 245.67,26.84 248.72,29.89 249.86,29.89 249.99,30.02 252.58,30.02 253.32,30.76 255.73,30.76 256.52,29.97 259.64,29.97 260.02,30.35 260.02,30.63 260.35,30.96 260.54,30.96 261.65,32.07 263.58,32.07 264.11,32.61 266.86,32.61 267.01,32.76 270.01,32.76 270.26,33.01 270.77,33.01 271.33,33.57 271.33,33.78 272.32,34.77 275.24,34.77 275.52,34.49 275.52,31.8 276.05,31.27 276.72,31.27 276.95,31.5 v1(276.95,32.16)
  BOTTOM w0.076: v1(141.35,59.29) 141.35,59.48 141.42,59.56 141.71,59.56 141.79,59.64 141.79,59.75 141.71,59.83 141.19,59.83 141.13,59.76 141.13,59.66 141.06,59.6 140.95,59.6 140.87,59.67 140.87,59.79 140.83,59.83 140.58,59.83 140.49,59.74 140.49,59.64 UC1.AG1
USB20_N9_R: length 14
  TOP w0.094: v1(283.52,22.78) 283.32,22.98 283.32,23.29 282.77,23.85 282.19,23.85 282.16,23.88 281.56,23.88 281.52,23.85 280.56,23.85 279.09,25.31 278.71,25.31 278.62,25.41 DI5.2 278.36,25.93 278.36,25.25 278.27,25.16 277.77,25.16 277.09,24.48 276.74,24.48 276.63,24.59 276.63,24.73 276.83,24.94 LI7.2
  IN1 w0.089: JUSB1.2 285.2,23.27 285.11,23.36 283.41,23.36 283.32,23.27 283.32,22.98 v1(283.52,22.78)
USB20_N10: length 161.3
  TOP w0.094: JUSH1.19 260.1,10.37 259.95,10.52 259.95,10.69 260.04,10.78 260.21,10.78 261.05,11.63 261.05,12.81 259.3,14.56 256.1,14.56 255.47,15.19 254.17,15.19 253.79,15.57 253.79,16.16 254.16,16.53 254.16,19.45 253.59,20.03 253.59,23.24 253.24,23.58 253.24,24.59 253.12,24.72 253.12,26.03 v4(252.7,26.45) 251.99,27.16 251.64,27.16 251.3,27.49 250.8,27.49 v1(250.6,27.69)
  IN1 w0.076: 142.1,55.82 142.1,55.83 142.09,55.84 142.09,56.29 141.19,57.2 140.53,57.2 139.26,58.47 137.88,58.47 137.65,58.24 137.4,58.24 137.3,58.33 137.3,58.62 v1(137.49,58.81)
  IN1 w0.089: v1(250.6,27.69) 250.43,27.52 250.32,27.52 250.12,27.72 250.12,28.01 249.76,28.37 248.7,28.37 246.67,26.35 246.67,25.88 245.94,25.14 243.44,25.14 242.9,24.61 241.71,24.61 240.72,25.6 240.72,26.03 239.86,26.89 238.13,26.89 237.8,26.56 229.26,26.56 229.14,26.44 225.4,26.44 225.26,26.31 218.47,26.31 216.59,24.43 212.7,24.43 212.43,24.15 211.15,24.15 210.8,24.51 210.8,25.87 209.6,27.07 207.48,27.07 206.66,27.89 206,27.89 203.56,30.32 201.81,30.32 200.31,31.82 198.81,31.82 197.18,33.45 196.5,33.45 195.78,34.16 190.07,34.16 184.38,39.85 180.98,39.85 177.55,43.28 170.32,43.28 169.9,43.7 165.19,43.7 164.34,44.55 163.5,44.55 155.84,52.21 155.84,52.69 154.79,53.74 152.23,53.74 152.07,53.9 146.87,53.9 146.1,54.66 142.93,54.66 142.1,55.49 142.1,55.82
  BOTTOM w0.076: v1(137.49,58.81) 137.49,59.08 137.31,59.27 UC1.AH7
USB20_P1: length 193.8
  TOP w0.076: v1(23.19,62.01) 23.53,62.35 24.38,62.35 24.43,62.31 24.69,62.31
  IN2 w0.122: v1(23.19,62.01) 23.43,62.25 23.71,62.25 23.83,62.13 23.83,57.25 24.54,56.54 30.71,56.54 32.47,58.3 32.47,61.31 32.03,61.74 32.03,63.39 31.15,64.28 31.15,64.86 32.44,66.15 32.44,72.03 33.18,72.77 33.18,75.26 33.79,75.87 36.32,75.87 41.13,80.67 41.13,83.31 45.11,87.3 52.25,87.3 54.28,89.33 54.28,90.34 53.78,90.85 53.78,91.87 54.39,92.48 59.01,92.48 59.35,92.14 67.28,92.14 69.97,94.83 69.97,95.77 72.42,98.22 74.37,98.22 77.23,95.36 78.84,95.36 81.94,92.26 83.99,92.26 86.29,94.56 89.86,94.56 92.2,92.22 93.18,92.22 93.81,91.59 98.33,91.59 99.12,90.8 100.31,90.8 101.99,89.12 109.36,89.12 109.93,88.55 112.23,88.55 113.5,87.28 116.48,87.28 117.46,86.3 128.43,86.3 129.12,85.62 132.29,85.62 134.9,83 142.35,83 142.75,82.6 142.75,81.99 143.16,81.59 143.16,79.25 143.31,79.1 143.31,78.63 142.81,78.13 142.43,78.13 141.72,77.42 141.72,73.03 140.94,72.25 140.94,68.46 140.44,67.96 140.44,64.79 138.34,62.68 136.57,62.68 136.39,62.51 135.53,62.51 135.41,62.38 135.41,62.19 v1(135.59,62.01)
  BOTTOM w0.076: UC1.AB10 v1(135.59,62.01)
USB20_P2: length 140.8
  TOP w0.094: LI3.1 26.13,20.93 26.33,21.14 26.87,21.14 27.11,21.37 27.11,21.58 v1(27.31,21.78)
  IN1 w0.076: v1(136.66,60.84) 136.72,60.84 136.95,60.61 136.95,60.52 136.87,60.44 136.35,60.44 136.08,60.7 136.08,61.17 135.74,61.51 134.28,61.51 133.33,62.47 133.02,62.47 132.77,62.71 132.77,62.99 132.4,63.36 128.54,63.36 126.93,61.75 126.92,61.75 126.91,61.73
  IN1 w0.089: v1(27.31,21.78) 26.96,21.43 26.96,21.15 28.4,19.71 32.69,19.71 33.1,20.11 44.25,20.11 45.51,21.37 46.58,21.37 49.74,24.54 51.85,24.54 63.69,36.38 63.69,38.43 69.95,44.68 70.71,44.68 72.71,46.68 76.15,46.68 77.25,47.78 78.92,47.78 81.41,50.26 81.41,52.33 89.07,59.99 95.66,59.99 95.74,59.92 97.77,59.92 98.2,59.49 100.54,59.49 101.4,60.35 104.47,60.35 105.62,59.2 105.62,58.95 106.78,57.78 125.1,57.78 125.86,58.54 125.86,60.68 126.64,61.47 126.91,61.73
  BOTTOM w0.076: UC1.AD7 137.03,61.4 136.66,61.03 v1(136.66,60.84)
USB20_P2_R: length 13.7
  TOP w0.094: JUSB2.3 15.9,25.42 16.09,25.61 16.4,25.61 17.66,24.34 17.66,24.08 17.63,24.05 17.63,23.47 17.66,23.43 17.66,22.55 18.06,22.14 v4(18.7,22.14) 21.04,22.14 22.04,21.14 22.59,21.14 22.69,21.04 DI2.2 23.56,21.14 24.07,21.14 24.28,20.93 LI3.2
USB20_P4: length 138.5
  TOP w0.094: v1(251.45,28.09) 251.62,28.26 251.85,28.26 251.97,28.39 252.18,28.39 252.31,28.26 LI8.4 252.67,28.09 RI47.1
  IN1 w0.076: 142.77,55.82 142.76,55.83 142.76,55.84 142.52,56.07 142.52,56.4 140.04,58.89 139.41,58.89 138.78,59.51 138.17,59.51 137.97,59.31 135.25,59.31 134.94,59.62 v1(134.94,60.83)
  IN1 w0.089: 142.77,55.82 143.3,55.28 143.3,55.27 143.43,55.14 146.38,55.14 147.23,54.3 152.23,54.3 152.39,54.13 154.95,54.13 156.29,52.8 156.29,52.31 163.45,45.15 164.43,45.15 165.5,44.09 170.14,44.09 170.5,43.73 177.65,43.73 181.08,40.3 184.51,40.3 190.25,34.56 196.75,34.56 199.09,32.23 200.46,32.23 201.96,30.73 204.2,30.73 206.63,28.29 209.48,28.29 212.37,25.39 216.92,25.39 218.25,26.72 222.95,26.72 223.52,27.3 228.96,27.3 229.29,26.97 237.57,26.97 237.98,27.37 240.34,27.37 242.16,25.56 244.69,25.56 245.17,25.82 245.18,25.83 245.41,25.98 245.54,26.04 245.79,26.21 245.87,26.28 246.23,26.53 248.94,29.23 249.48,29.23 250.5,28.22 251.32,28.22 v1(251.45,28.09)
  BOTTOM w0.076: v1(134.94,60.83) 134.94,61.07 UC1.AD10
USB20_P4_L: length 11.1
  TOP w0.094: v1(254.91,28.22) 254.68,28.44 254.23,28.44 254.05,28.26 LI8.3 253.59,28.09 RI47.2
  BOTTOM w0.094: v1(254.91,28.22) 255.31,28.61 255.67,28.61 256.06,29.01 256.06,29.47 256.1,29.51 256.1,30.11 256.06,30.15 256.06,30.5 256.82,31.26 258.45,31.26 258.73,30.98 259.54,30.98 259.94,30.58 259.94,30.37 260.48,29.83 260.48,29.76 260.25,29.53 JNGFF2.7
USB20_P5: length 114.7
  TOP w0.094: LZ1.1 72.49,101.01 72.7,101.22 73.12,101.22 v1(73.31,101.02)
  IN2 w0.122: v1(73.31,101.02) 73.35,101.02 73.39,101.06 73.39,101.08 73.51,101.21 73.98,101.21 74.35,100.83 79.4,100.83 79.94,101.37 83.19,101.37 85.35,99.21 87.79,99.21 88.2,98.8 92.69,98.8 93.31,98.19 96.91,98.19 97.44,97.66 101.2,97.66 106.35,92.5 107.43,92.5 107.9,92.97 109.83,92.97 114.11,88.69 117.15,88.69 118.22,87.62 132.34,87.62 135.26,84.7 143.21,84.7 144.55,83.36 144.55,82.08 146.31,80.33 146.31,78.22 143.05,74.97 143.05,72.97 143.57,72.45 143.72,72.45 144.63,71.54 144.63,67.79 145.61,66.81 145.61,62.5 145,61.89 145,60.05 143.23,58.29 143.23,57.82 v1(143.11,57.69)
  BOTTOM w0.076: UC1.AJ2 140.13,58.21 140.4,57.94 140.77,57.94 141.04,58.21 143.06,58.21 143.18,58.09 143.18,57.77 v1(143.11,57.69)
USB20_P5_R: length 6.1
  TOP w0.094: v1(67.37,99.31) 67.56,99.51 v4(68.69,99.51) 69.53,99.51 70.29,100.27 70.29,101.13 70.39,101.22 70.59,101.22 70.79,101.01 LZ1.2
  BOTTOM w0.094: v1(67.37,99.31) 67.56,99.51 67.7,99.51 67.86,99.35 JEDP1.13
USB20_P7: length 81
  IN1 w0.089: v1(144.91,57.67) 144.77,57.8 144.77,58.53 146.01,59.77 150.3,59.77 150.68,59.39 152.67,59.39 153.04,59.03 153.04,58.85 153.98,57.91 154.8,57.91 156.39,56.31 157.89,56.31 160.85,53.35 163.16,53.35 163.43,53.08 169.78,53.08 170.38,52.48 173.22,52.48 173.97,51.74 175.57,51.74 178.52,48.79 180.29,48.79 180.83,48.26 180.83,46.98 183.05,44.76 185.06,44.76 190.28,39.54 192.97,39.54 193.04,39.47 193.04,39.24 v1(192.84,39.04)
  BOTTOM w0.076: v1(144.91,57.67) 144.77,57.8 144.77,58.78 144.54,59.01 143.15,59.01 142.93,58.78 141.09,58.78 140.93,58.95 140.63,58.95 140.44,59.14 140.1,59.14 140.01,59.09 UC1.AH2
  BOTTOM w0.094: v1(192.84,39.04) 193.04,39.23 193.04,39.62 193.25,39.83 194.04,39.83 194.39,39.48 196.91,39.48 198.76,37.62 202.19,37.62 202.56,38 205.53,38 LI9.4 205.85,38.31 RI49.1
USB20_P7_L: length 3.7
  BOTTOM w0.094: RI49.2 206.76,38.31 LI9.3 207.17,38.14 207.32,37.99 v4(207.99,37.99) 208.62,37.99 208.62,37.99 209,37.99 209.15,37.84 209.3,37.84 209.46,38 JNGFF1.3
USB20_P8: length 124.6
  TOP w0.094: LV27.3 73.14,106.43 73.34,106.63 73.49,106.63 73.77,106.36 v4(73.77,105.88) 73.77,105.39 73.19,104.81 73.14,104.81 72.72,104.39 72.72,104.34 72.44,104.06 72.44,102.81 72.77,102.48 73.1,102.48 v1(73.3,102.28)
  IN2 w0.122: v1(73.3,102.28) 73.12,102.45 72.57,102.45 72.19,102.07 72.19,100.45 73.53,99.11 74.77,99.11 75.65,98.23 77.25,98.23 79.56,95.92 82.77,95.92 83.24,95.45 90.25,95.45 92.58,93.11 93.81,93.11 94.44,92.48 98.71,92.48 99.27,91.92 100.46,91.92 102.26,90.12 104.12,90.12 104.47,90.47 111.72,90.47 114.01,88.18 116.94,88.18 117.93,87.19 132.16,87.19 135.33,84.02 142.93,84.02 143.64,83.3 143.64,82.37 145.6,80.41 145.6,79.65 144.07,78.13 144.07,76.93 142.63,75.48 142.63,72.77 143.38,72.01 143.5,72.01 144.05,71.46 144.05,69.6 143.59,69.15 143.59,62.26 144.15,61.7 144.15,59.99 142.62,58.47 140.45,58.47 139.69,59.23 138.9,59.23 138.62,59.51 138.34,59.51 138.06,59.23 136.63,59.23 136.4,59.46 136.4,59.73 v1(136.22,59.9)
  BOTTOM w0.076: v1(136.22,59.9) 135.92,60.21 UC1.AF9
USB20_P8_R: length 9.6
  TOP w0.094: LV27.4 71.47,106.43 71.26,106.63 70.57,106.63 69.58,105.64 69.58,105.13 69.3,104.86 68.92,104.86 DV4.3 68.05,104.76 66.65,104.76 v1(66.48,104.59)
  BOTTOM w0.094: v1(66.48,104.59) 66.77,104.89 67.12,104.89 67.49,104.51 67.7,104.51 67.86,104.35 JEDP1.3
USB20_P9: length 166.2
  TOP w0.094: UI3.3 276.41,31.65 276.57,31.81 276.57,31.96 v1(276.37,32.16)
  IN1 w0.076: v1(141.95,59.28) 141.95,59.03 141.87,58.95 141.58,58.95 141.51,58.88 141.51,58.51 142.96,57.06 145.04,57.06 145.04,57.07 145.06,57.07
  IN1 w0.089: 145.06,57.07 146.73,57.07 148.06,55.74 149.44,55.74 149.93,55.25 154.98,55.25 155.5,55.77 156.39,55.77 156.95,55.21 156.95,54.07 157.18,53.84 157.18,52.5 160.79,48.89 161.56,48.89 162.32,48.13 162.32,47.39 163.63,46.08 164.58,46.08 165.82,44.85 170.46,44.85 170.7,44.6 177.85,44.6 180.55,41.91 183.98,41.91 190.15,35.74 194.01,35.74 194.41,35.33 197.05,35.33 199.34,33.04 200.72,33.04 201.4,32.36 201.4,32.35 201.65,32.1 204.8,32.1 207.2,29.7 209.18,29.7 212.73,26.16 216.62,26.16 218.02,27.55 218.38,27.91 221.95,27.91 222.1,28.06 229.37,28.06 229.64,27.79 235.44,27.79 236.07,28.42 240.36,28.42 242.46,26.32 244.42,26.32 244.91,26.6 245.08,26.67 245.28,26.8 245.37,26.85 245.39,26.88 245.56,26.98 248.22,29.65 248.64,30.07 249.79,30.07 249.91,30.2 252.51,30.2 253.24,30.94 255.81,30.94 256.59,30.15 259.57,30.15 259.84,30.42 259.84,30.7 260.28,31.14 260.46,31.14 261.58,32.25 263.5,32.25 264.03,32.79 266.78,32.79 266.93,32.94 269.93,32.94 270.18,33.19 270.69,33.19 271.15,33.65 271.15,33.85 272.24,34.95 275.31,34.95 275.7,34.56 275.7,31.87 276.12,31.45 276.64,31.45 276.77,31.58 276.77,31.76 276.68,31.85 276.56,31.85 276.37,32.04 v1(276.37,32.16)
  BOTTOM w0.076: v1(141.95,59.28) 141.95,59.82 141.78,59.99 140.52,59.99 UC1.AG2
USB20_P9_R: length 14
  TOP w0.094: v1(282.93,22.78) 283.14,22.98 283.14,23.21 282.69,23.66 v4(281.86,23.66) 280.48,23.66 279.01,25.13 278.71,25.13 278.62,25.03 DI5.3 278.36,24.51 278.36,24.88 278.27,24.97 277.85,24.97 277.17,24.3 276.66,24.3 276.44,24.52 276.44,24.73 276.23,24.93 LI7.3
  IN1 w0.089: v1(282.93,22.78) 283.14,22.98 283.14,23.35 283.33,23.54 285.11,23.54 285.2,23.63 JUSB1.3
