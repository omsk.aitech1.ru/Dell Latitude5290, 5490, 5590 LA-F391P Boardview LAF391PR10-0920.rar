# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD/MMCCMD: length 3
  BOTTOM w0.102: UR1.19 78.77,97.03 78.54,97.25 78.54,98.06 RR6.1
SD/MMCCMD_R: length 29.8
  TOP w0.102: v1(86.19,96.95) 86.62,96.95 86.98,97.3 JSD1.3
  IN2 w0.122: v1(86.19,96.95) 86.21,96.95 86.84,96.31 87.89,96.31 88.55,96.97 90.05,96.97 90.17,96.85 90.17,96.3 90.31,96.16 90.53,96.16 90.66,96.29 90.66,96.85 90.78,96.97 91.22,96.97 91.65,96.54 92.38,96.54 92.97,97.13 92.97,97.56 92.15,98.37 88.02,98.37 87.62,98.78 84.48,98.78 83.98,99.28 83.98,99.98 83.01,100.94 80.17,100.94 79.84,100.61 v1(79.84,100.05)
  BOTTOM w0.102: v3(78.03,101.14) 79.01,100.17 RR6.2 79.62,100.05 v1(79.84,100.05)
SD/MMCDAT0/RCLK+: length 4.2
  BOTTOM w0.089: RR10.1 75.74,97.69 76.08,97.69 76.61,97.16 v4(76.61,96.92) 76.61,95.2 76.71,95.1 76.85,95.1 76.9,95.15 UR1.16
SD/MMCDAT0/RCLK+_R: length 27.8
  TOP w0.089: v1(90.75,95.54) 90.88,95.66 90.88,97.12 90.58,97.42 JSD1.7
  IN4 w0.076: v1(73.45,97.57) 73.87,97.15 73.87,96.91 74.22,96.55 74.22,94.19 75.98,92.44 77.22,92.44 78.22,91.44 82.85,91.44 86,94.59 90.73,94.59 91.1,94.95 91.1,95.2 v1(90.75,95.54)
  BOTTOM w0.089: RR10.2 74.24,97.69 74,97.69 73.74,97.43 73.59,97.43 v1(73.45,97.57)
SD/MMCDAT1/RCLK-: length 4.2
  BOTTOM w0.089: UR1.15 76.9,94.75 76.85,94.8 76.59,94.8 76.31,95.08 76.31,97.04 75.96,97.4 75.74,97.4 RR9.1
SD/MMCDAT1/RCLK-_R: length 27.7
  TOP w0.089: v1(91.34,95.54) 91.18,95.7 91.18,97.14 91.48,97.44 JSD1.8
  IN4 w0.076: v1(73.45,96.99) 73.98,96.45 73.98,94.09 75.88,92.2 77.12,92.2 78.12,91.2 82.95,91.2 86.1,94.34 90.83,94.34 91.34,94.85 v1(91.34,95.54)
  BOTTOM w0.089: v1(73.45,96.99) 73.59,97.13 73.86,97.13 74.13,97.4 74.24,97.4 RR9.2
SD/MMCDAT2: length 3.7
  BOTTOM w0.102: RR8.1 80.78,97.59 v2(80.59,97.39) 79.92,97.39 79.46,96.92 79.46,96.39 79.57,96.28 UR1.21
SD/MMCDAT2_R: length 28.6
  TOP w0.102: v1(85,96.95) 85.18,97.13 JSD1.1
  IN2 w0.122: v1(81.01,100.05) 81.01,99.78 80.73,99.49 79.73,99.49 79.4,99.82 79.4,100.25 79.25,100.41 77,100.41 76.89,100.3 76.89,100.07 77,99.97 78.51,99.97 78.66,99.82 78.66,99.65 77.98,98.98 77.98,98.8 78.15,98.63 78.33,98.63 79,99.31 79.17,99.31 79.75,98.73 79.94,98.73 80.19,98.98 80.88,98.98 81.53,99.63 81.73,99.63 81.86,99.5 81.86,99.3 80.95,98.4 80.78,98.4 80.67,98.5 80.42,98.5 80.29,98.37 80.29,98.19 81.26,97.22 81.63,97.22 81.75,97.34 81.75,98.53 81.87,98.65 82.12,98.65 82.24,98.53 82.24,97.34 82.36,97.22 82.61,97.22 82.73,97.34 82.73,98.17 82.85,98.29 83.09,98.29 83.21,98.17 83.21,97.34 83.34,97.22 84.2,97.22 84.48,96.95 v1(85,96.95)
  BOTTOM w0.102: v3(81.59,101.14) 81.01,100.56 v1(81.01,100.05) 81.01,99.67 RR8.2
SD/MMCDAT3: length 3
  BOTTOM w0.102: RR7.1 79.89,97.94 v2(79.21,97.25) 79.17,97.21 UR1.20
SD/MMCDAT3_R: length 31.6
  TOP w0.102: v1(85.59,96.95) 86.08,97.43 JSD1.2
  IN2 w0.122: v1(80.43,100.05) 80.43,100.23 80.71,100.51 81.97,100.51 82.1,100.39 82.1,100.04 82.22,99.92 82.46,99.92 82.58,100.04 82.58,100.33 82.71,100.45 82.9,100.45 83.55,99.8 83.55,99.34 83.43,99.21 82.65,99.21 82.53,99.09 82.53,98.85 82.65,98.73 83.43,98.73 83.88,98.28 84.27,98.28 84.4,98.15 84.4,97.65 84.52,97.53 84.76,97.53 84.88,97.65 84.88,98.23 85,98.35 85.25,98.35 85.37,98.23 85.37,98.04 85.49,97.91 85.74,97.91 85.86,98.04 85.86,98.23 85.98,98.35 86.22,98.35 86.35,98.23 86.35,98.04 86.47,97.91 86.71,97.91 86.83,98.04 86.83,98.23 86.96,98.35 87.44,98.35 87.85,97.95 91.98,97.95 92.38,97.54 92.38,97.33 92.02,96.97 91.82,96.97 91.39,97.4 87.72,97.4 87.61,97.28 87.61,96.87 87.49,96.74 87.24,96.74 87.12,96.87 87.12,97.28 87,97.41 85.81,97.41 85.59,97.19 v1(85.59,96.95)
  BOTTOM w0.102: v3(79.81,101.52) 80.43,100.9 v1(80.43,100.05) 80.43,99.97 RR7.2
SD_GPIO: length 2.1
  BOTTOM w0.102: RR3.2 82.38,93.93 81.9,93.93 81.87,93.95 UR1.28
SD_RCOMP: length 13.8
  TOP w0.127: v1(147.18,65.2) 146.79,65.2 v2(146.56,65.43)
  TOP w0.381: v1(147.18,65.2) 147.56,65.58 148.44,65.58 RC96.1
  IN3 w0.381: v1(147.18,65.2) 146.01,64.03 139.92,64.03 138.56,62.67 138,62.67 137.56,62.23 v1(137.56,62.05)
  BOTTOM w0.254: UC1.AB7 137.22,62.44 137.56,62.11 v1(137.56,62.05)
SD_UHS2_D0N: length 21.4
  TOP w0.089: v1(89.2,110.46) 89.06,110.61 89.06,110.73 89.36,111.03 JSD1.17
  IN4 w0.076: v1(82.48,95.25) 82.14,94.9 82.01,94.9 81.79,95.12 81.79,96.67 83.19,98.07 83.19,104.28 88.86,109.95 88.86,110.12 v1(89.2,110.46)
  BOTTOM w0.089: UR1.25 81.89,95.15 81.99,95.05 82.28,95.05 v1(82.48,95.25)
SD_UHS2_D0P: length 21.5
  TOP w0.089: v1(88.62,110.46) 88.76,110.6 88.76,110.74 88.45,111.05 JSD1.16
  IN4 w0.076: v1(88.62,110.46) 88.62,110.05 82.95,104.38 82.95,98.17 81.55,96.77 81.55,95.02 81.91,94.66 v1(82.48,94.66)
  BOTTOM w0.089: v1(82.48,94.66) 82.39,94.75 UR1.26
SD_UHS2_D1N: length 26.8
  TOP w0.089: JSD1.19 91.18,110.98 91.48,110.68 91.48,110.23 91.78,109.93 92.17,109.93 v1(92.31,109.79)
  IN4 w0.076: v1(92.31,109.79) 92.25,109.85 91.42,109.85 90.38,110.89 87.46,110.89 85.37,108.81 85.37,108.56 82.35,105.53 82.35,102.41 80.59,100.64 79.83,100.64 79.43,100.24 79.43,99.02 80.29,98.16 80.29,96.94 v1(80.46,96.77)
  BOTTOM w0.089: v1(80.46,96.77) 80.32,96.62 80.32,96.32 80.37,96.26 UR1.23
SD_UHS2_D1P: length 26.8
  TOP w0.089: v1(92.31,110.37) 92.17,110.23 91.9,110.23 91.78,110.36 91.78,110.69 92.09,111 JSD1.20
  IN4 w0.076: v1(79.87,96.77) 80.05,96.94 80.05,98.06 79.19,98.92 79.19,100.34 79.73,100.88 80.49,100.88 82.11,102.51 82.11,105.63 85.13,108.66 85.13,108.91 87.36,111.13 90.48,111.13 91.52,110.09 92.03,110.09 v1(92.31,110.37)
  BOTTOM w0.089: UR1.22 79.97,96.27 80.02,96.32 80.02,96.62 v1(79.87,96.77)
SDWP: length 21
  TOP w0.102: QR1.1 90.25,90.95 90.25,90.26 89.92,89.94 87.9,89.94 v2(87.59,90.25) 86.87,90.96 86.87,93.53 86.4,94 85.94,94 83.15,96.8 82.2,96.8 80.88,95.47 80.15,95.47 79.86,95.18 79.86,94.38 80.74,93.5 v1(82.22,93.5)
  BOTTOM w0.102: UR1.29 82.17,93.55 v1(82.22,93.5)
SIM_DET: length 236.7
  IN2 w0.122: v1(124.39,107.74) 125.23,107.74 126.54,106.43 126.54,104.27 128.15,102.66 130.14,102.66 130.58,102.21 130.63,102.21 130.63,102.21 133.16,102.21 133.73,101.64 134.75,101.64 135.49,102.38 146,102.38 148.26,100.12 153.68,100.12 158.9,94.91 163.69,94.91 165.2,93.39 169.09,93.39 170.49,91.99 170.49,84.22 179.36,75.36 179.36,74.92 185.33,68.95 185.33,64.53 187.34,62.52 187.34,60.16 190.91,56.59 190.91,55.03 200.86,45.08 203.44,45.08 204.85,43.67 207.01,43.67 208.4,42.28 216.61,42.28 217.75,41.14 220.68,41.14 221.16,41.63 224.84,41.63 225.45,42.24 226.75,42.24 227.14,42.63 229.76,42.63 230.71,43.58 232.96,43.58 233.98,44.6 234.57,44.6 235.16,45.19 235.16,45.75 237.19,47.79 238.32,47.79 v1(238.71,48.18)
  BOTTOM w0.102: JSIM1.9 110.67,95.15 110.67,102.66 115.75,107.74 v1(124.39,107.74) ; JNGFF2.66 275,35.23 275.29,34.94 275.29,32.92 274.85,32.48 273.84,32.48 273.38,32.03 272.94,32.03 272.24,32.72 272.24,33.82 272,34.06 271.43,34.06 270.57,33.19 270.06,33.19 269.93,33.32 268.1,33.32 267.77,32.99 266.3,32.99 266.1,32.79 263.47,32.79 263.1,33.16 262.51,33.16 262.22,33.44 262.22,36.86 263.1,37.74 263.1,37.75 263.2,37.85 263.2,38.19 262.77,38.63 262.77,38.99 261.38,40.38 260.67,40.38 259.6,41.45 258.88,41.45 256.8,43.53 255.53,43.53 255.07,43.99 254.56,43.99 253.75,44.8 253.75,45.77 251.95,47.57 248.16,47.57 247.93,47.34 246.04,47.34 245.69,46.99 244.58,46.99 244.28,47.29 239.6,47.29 v2(239.27,47.63) v1(238.71,48.18)
SIO_EXT_SCI#: length 41.5
  TOP w0.102: v1(136.59,57.18) 137.54,57.18 138.36,56.35 138.98,56.35 v2(139.77,55.57) 140.78,54.56 147.68,54.56 147.92,54.8 148.25,54.8 149.02,55.56 149.72,55.56 150.42,56.26 150.61,56.26 150.84,56.49 151.27,56.49 151.76,56.97 RC237.1 ; RC561.1 147.01,45.16 144.24,47.93 144.24,50.96 144,51.2 142.19,51.2 141.7,51.7 141.7,53.25 v1(141.88,53.43)
  IN1 w0.076: v1(136.59,57.18) 136.1,56.69 136.1,56.38
  IN1 w0.089: 136.1,56.38 136.1,54.07 136.91,53.26 137.85,53.26 138.09,53.5 138.09,54.06 138.21,54.18 138.66,54.18 138.76,54.07 141.18,54.07 141.83,53.43 v1(141.88,53.43)
  BOTTOM w0.076: UC1.AN7 v1(136.59,57.18)
SIO_EXT_SMI#: length 13.8
  TOP w0.102: v1(144.28,79.88) 144.86,79.88 145.85,80.87 RC346.1
  BOTTOM w0.076: UC1.A6 139.09,73.33 139.3,73.53 139.3,73.81 139.45,73.97 141.45,73.97 142.12,74.64
  BOTTOM w0.102: v1(144.28,79.88) 144.49,79.67 v2(144.49,79.3) 143.89,78.71 143.89,78.59 143.61,78.32 143.61,77.55 144.02,77.14 144.02,76.54 142.12,74.64
SIO_EXT_WAKE#: length 179.3
  TOP w0.102: v1(268.44,44.91) UE1.M12
  IN2 w0.122: v1(219.13,20.58) 219.54,20.16 220.95,20.16 221.89,19.23 223.77,19.23 224.06,18.94 230.59,18.94 230.74,18.79 231.2,18.79 233.23,16.77 233.23,16.07 234.73,14.58 238.12,14.58 239.7,16.16 239.7,18.29 240.33,18.92 249.97,18.92 251.08,17.8 252.63,17.8 253.9,19.07 253.9,21.86 255.99,23.95 255.99,27.28 256.24,27.53 256.24,30.07 259.62,33.45 261.55,33.45 264.22,36.11 264.77,36.11 266.76,38.1 266.76,39.54 267.89,40.67 267.89,42.77 267.98,42.86 267.98,43.26 268.37,43.65 268.37,44.84 v1(268.44,44.91)
  IN4 w0.089: v1(219.13,20.58) 218.6,21.1 218.06,21.1 217.48,21.68 212.67,21.68 212.55,21.56 208.51,21.56 207.95,21 202.24,21 198.54,24.7 198.54,28.02 194.94,31.62 193.55,31.62 186.69,38.48 186.69,38.96 180.57,45.08 180.57,48.1 179.07,49.6 179.07,51.71 177.28,53.5 174.24,53.5 173.79,53.05 173.79,52.57 173.08,51.86 172,51.86 170.59,53.28 166.81,53.28 165.48,54.61 163.81,54.61 162.77,55.65 162.77,56.1 162.17,56.7 160.22,56.7 159.68,57.24 155.64,57.24 154.74,58.14 153.8,58.14 152.95,58.99 v1(152.44,58.99)
  BOTTOM w0.076: 143.32,60.53 143.18,60.66 142.61,60.66 142,61.27 140.89,61.27 140.85,61.3 140.49,61.3 UC1.AC1
  BOTTOM w0.102: v1(152.44,58.99) 152.24,59.19 150.99,59.19 RC283.1 150.31,59.88 149.23,59.88 149.04,59.69 146.7,59.69 146.27,60.12 v2(145.61,60.12) 143.73,60.12 143.32,60.53
SIO_PWRBTN#: length 323.6
  TOP w0.076: 269.2,47.42 268.24,47.42 268.14,47.32 267.61,47.32 UE1.K11
  TOP w0.102: 269.2,47.42 269.4,47.42 v1(269.58,47.24) ; v1(167.44,47.93) 168.83,49.32 v3(168.83,55.88) 168.83,60.31 170.49,61.97 170.49,66.62 167.93,69.19 165.74,69.19 164.52,70.4 159.46,70.4 158.12,71.75 158.12,74.24 159.09,75.21 v1(161.8,75.21)
  IN1 w0.089: v1(259.49,32.18) 259.36,32.18 259.08,31.9 257,31.9 256.67,32.23 251.51,32.23 249.98,33.77 245.55,33.77 245.32,33.99 241.22,33.99 238.07,30.84 234.61,30.84 234.6,30.86 231.91,30.86 231.45,31.31 227.94,31.31 227.74,31.11 221.99,31.11 221.53,30.65 217.95,30.65 216.98,29.68 212.74,29.68 210.14,32.28 208.33,32.28 205.82,34.78 202.95,34.78 202.33,35.4 199.51,35.4 197.76,37.16 196.07,37.16 195.08,38.15 194.09,38.15 193.5,37.56 190.99,37.56 184.66,43.89 182.47,43.89 180.22,46.15 179.62,46.15 178.78,46.99 168.38,46.99 v1(167.44,47.93)
  IN2 w0.122: v1(161.8,75.21) 163.02,76.42 163.02,77.79 160.26,80.55 160.26,81.04 159.39,81.91 159.39,82.65 159.14,82.9 157.9,82.9 156.9,83.91 156.9,85.31 156,86.21 156,89.16 153.39,91.77 153.19,91.77 151.13,93.82 141.99,93.82 139.87,95.94 131.24,95.94 130.94,95.64 121.95,95.64 120.48,97.12 120.48,100.99 116.67,104.8 108.16,104.8 107.41,105.55 105.32,105.55 104.99,105.21 103.8,105.21 103.3,105.71 93.65,105.71 92.99,106.38 91.34,106.38 v1(91.13,106.17) ; v1(269.58,47.24) 268.89,46.55 268.89,43.46 268.48,43.05 268.48,42.59 268.39,42.5 268.39,39.4 268.02,39.03 268.02,39.02 267.52,38.52 267.52,37.79 264.83,35.1 264.34,35.1 263.2,33.96 263.2,33.32 262.95,33.07 262.44,33.07 262.06,32.69 259.92,32.69 259.49,32.25 v1(259.49,32.18)
  IN4 w0.089: v1(93.49,99.53) 93.49,103.61 91.65,105.46 91.65,105.65 v1(91.13,106.17)
  BOTTOM w0.076: 135.94,46.67 134.68,47.93 133.91,47.93 131.79,50.05 131.79,51.41 UC1.BA15
  BOTTOM w0.102: v1(167.44,47.93) 167.7,47.67 167.7,46.91 166.93,46.15 166.93,45 165.54,43.61 165.54,42.46 162.35,39.28 148.34,39.28 144.39,43.23 138.44,43.23 136.69,44.99 136.25,45.42 135.94,45.73 135.94,46.67 ; RC241.1 CC269.1 95.26,94.93 94.8,95.4 94.65,95.4 93.14,96.91 JXDP1.41 93.14,99.17 v1(93.49,99.53)
SIO_SLP_A#: length 210.9
  TOP w0.076: 268.42,42.85 268.42,43.46 267.53,44.35 267.53,45.02 UE1.M11
  TOP w0.102: v1(268.91,41.98) 268.42,42.48 268.42,42.85
  IN1 w0.089: v1(201.99,11.98) 200.41,13.56 200.41,14.2 198.43,16.18 197.35,16.18 195.79,17.74 195.79,18.69 195.39,19.08 194.36,19.08 193.97,19.48 192.53,19.48 192.38,19.63 184.94,19.63 179.93,24.65 159.92,24.65 151.54,33.03 141.36,33.03 137.91,36.47 137.91,36.78 135.34,39.35 135.34,39.7 135.56,39.92 135.56,41.83 135.78,42.05 135.78,44.5 135.06,45.22 135.06,49.42 131.5,52.98 131.5,55.84 v1(131.09,56.26)
  IN2 w0.122: v1(268.91,41.98) 268.91,38.95 268.8,38.84 268.8,37.27 268.41,36.88 267.32,36.88 265.99,35.55 265.99,34.59 266.07,34.51 266.07,33.5 265.13,32.56 262.69,32.56 262.31,32.18 260.67,32.18 260.19,31.7 258.93,31.7 257.23,30 257.23,27.28 257.61,26.89 257.61,24.56 256.09,23.03 256.09,21.86 255.58,21.35 254.91,21.35 254.4,20.84 254.4,18.86 252.84,17.3 251.33,17.3 250.97,16.94 250.63,16.94 249.65,17.92 241.7,17.92 240.34,16.56 240.34,16.08 238.33,14.07 234.5,14.07 232.72,15.85 232.72,16.43 231.7,17.45 231.32,17.45 230.33,18.44 229.37,18.44 229.29,18.36 v1(227.26,18.36)
  IN3 w0.122: v1(227.26,18.36) 225.26,16.37 219.02,16.37 215.09,12.44 204.22,12.44 203.33,11.55 202.42,11.55 v1(201.99,11.98)
  BOTTOM w0.076: v1(131.09,56.26) 131.1,56.27 131.53,56.64 131.54,56.65 UC1.AN16
  BOTTOM w0.102: JAPS1.6 212.2,13.64 211.78,13.22 206.39,13.22 205.74,13.86 202.59,13.86 201.99,13.25 v1(201.99,11.98) ; v2(268.38,42.16) 268.56,41.98 v1(268.91,41.98)
SIO_SLP_LAN#: length 185.3
  TOP w0.102: v1(234.75,37.89) v2(233.99,37.89) 233.46,37.89 232.97,38.38 232.97,38.65 232.61,39.02 UZ2.5 ; v1(266.02,48.13) UE1.H9 ; RC68.1 RC344.1 165.79,45.98 v1(165.79,45.64)
  IN1 w0.089: v1(165.79,45.64) 166.19,45.24 170.34,45.24 170.62,45.51 178.24,45.51 179.25,44.5 179.25,43.76 180.27,42.74 184.03,42.74 190.4,36.37 194.39,36.37 194.8,35.96 197.31,35.96 199.57,33.7 200.94,33.7 201.91,32.74 205.13,32.74 207.56,30.31 209.46,30.31 211.78,27.99 214.63,27.99 215.14,27.48 217.08,27.48 218.12,28.52 221.7,28.52 222.65,29.47 223.35,29.47 223.97,28.85 228.43,28.85 v1(228.58,29)
  IN4 w0.089: v1(266.02,48.13) 266.29,48.13 266.76,47.67 267.68,47.67 269.07,46.28 269.07,44.65 265.96,41.54 263.95,41.54 261.5,39.09 260.63,39.09 260.38,39.34 257.19,39.34 255.23,37.38 250.25,37.38 249.07,36.21 240.17,36.21 239.03,37.34 237.17,37.34 236.38,38.13 235.14,38.13 234.9,37.89 v1(234.75,37.89)
  BOTTOM w0.076: 136.63,46.53 136.49,46.67 136.49,46.82 135.02,48.28 134.02,48.28 132.24,50.06 132.24,50.78 132.32,50.86 132.32,52.34 132.16,52.67 132.01,52.83 UC1.AW15
  BOTTOM w0.102: v1(234.75,37.89) 234.5,37.64 228.53,37.64 228.07,37.18 228.07,35.3 231.11,32.27 231.11,29.38 230.24,28.52 229.06,28.52 v1(228.58,29) ; v1(165.79,45.64) 164.52,44.37 164.52,42.97 161.82,40.27 148.71,40.27 144.79,44.2 138.85,44.2 136.63,46.42 136.63,46.53
SIO_SLP_S0#: length 210.6
  TOP w0.102: PR425.1 176.61,47.33 177.64,46.3 v2(181.96,46.3) 182.35,46.3 v1(182.6,46.55) ; PR426.1 172.15,95.07 v1(171.84,94.75) ; v1(140.09,88.97) 141.06,89.94 v1(145.62,89.94)
  IN1 w0.089: v1(190.61,40.15) 190.5,40.15 185.33,45.33 183.83,45.33 v1(182.6,46.55) 181.69,47.47 181.69,48.66 180.95,49.4 179.94,49.4 178.39,50.95 178.39,51.33 177.73,51.99 177.73,53.16 175.87,55.01 175.65,55.01 175.09,55.57 174.81,55.57 173.89,56.49 173.89,57.58 173.41,58.06 172.34,58.06 172.04,57.76 168.63,57.76 165.54,60.85 162.89,60.85 158.34,65.41 v1(158.05,65.41)
  IN2 w0.122: v1(145.62,89.94) 147.82,89.94 149.87,87.89 150.89,87.89 151.63,87.15 151.63,82.29 155.71,78.21 155.71,75.95 156.06,75.6 156.06,68.82 155.79,68.55 155.79,66.7 156.44,66.05 157.41,66.05 v1(158.05,65.41) 158.2,65.26 158.79,65.26 158.98,65.07 158.98,62.37 158.71,62.09 158.71,54.5 159.67,53.54 159.67,51.46 159.43,51.22 155.37,51.22 154.87,50.72 154.01,50.72 153.22,49.93 153.22,48.16 152.46,47.39 152.46,47.33 151.26,46.13 147.27,46.13 143.88,49.51 138.49,49.51 138.23,49.26 136.71,49.26 135.63,50.34 135.63,53.01 135.18,53.45 135.18,54.6 v1(134.77,55.02)
  IN4 w0.089: v1(145.62,89.94) 149.84,94.15 168.2,94.15 168.71,93.65 170.73,93.65 v1(171.84,94.75)
  BOTTOM w0.076: UC1.AT11 134.51,55.02 v1(134.77,55.02)
  BOTTOM w0.102: v1(158.05,65.41) 157.79,65.67 RZ363.1 157.76,66.11 RZ362.2 157.65,66.98 156.94,66.26 RZ112.1 ; JAPS1.15 207.7,15.34 208.42,16.06 208.42,16.69 207.24,17.87 207.24,20.32 206.81,20.75 206.05,20.75 202.98,23.82 202.98,29.92 197.26,35.63 192.54,35.63 190.17,37.99 190.17,39.72 v1(190.61,40.15) ; UZ35.1 139.87,88.75 v1(140.09,88.97)
SIO_SLP_S3#: length 349.8
  TOP w0.076: UE1.K9 265.62,46.89 266.06,46.45 269.01,46.45 270.31,45.16
  TOP w0.102: 276.89,33.47 276.93,33.47 v1(277.87,32.53) ; 276.89,33.47 276.86,33.5 276.86,34.38 276.58,34.65 276.58,35.24 276.42,35.4 276.42,35.95 278.06,37.59 278.06,38.55 277.8,38.81 RE280.1 276.94,38.35 274.21,38.35 273.78,38.78 273.78,40.81 274.1,41.13 UE5.1 274.67,41.72 274.68,41.72 v1(274.68,41.73) ; 276.89,33.47 275.19,33.47 275.06,33.6 275.06,35.1 274.55,35.61 UE3.2 ; 270.31,45.16 v1(270.9,45.16)
  IN1 w0.089: v1(277.87,32.53) 277.87,32.23 277.51,31.87 277.51,30.4 276.82,29.71 275.07,29.71 273.51,28.15 273.51,27.59 273.01,27.1 267.5,27.1 266.84,26.44 265.78,26.44 264.47,25.12 258.7,25.12 257.24,23.66 257.24,19.52 254.52,16.81 252.82,16.81 251.48,15.47 250.48,15.47 249.93,14.92 248.94,14.92 247.61,16.24 245.16,16.24 244.29,15.37 243.01,15.37 241.51,13.87 238.33,13.87 237.5,14.7 234.28,14.7 233.27,15.71 231.58,15.71 231.32,15.97 228.86,15.97 228.66,16.17 221.66,16.17 219.75,14.25 219.75,13.7 219.15,13.11 218.67,13.11 218.19,12.63 218.19,12.02 217.57,11.41 214.17,11.41 213.77,11.81 204.45,11.81 v1(202.87,13.38) 201.68,14.58 201.68,16.55 201.06,17.18 201.06,17.52 200.03,18.55 198.69,18.55 197.55,19.69 196.85,19.69 196.19,20.34 194.89,20.34 194.49,20.73 193.05,20.73 192.86,20.92 192.07,20.92 192.07,20.93 187.08,20.93 181.97,26.03 160.32,26.03 151.5,34.85 141.32,34.85 139.65,36.52 139.65,37.84 137.93,39.57 136.86,39.57 136.05,40.38 136.05,41.55 136.26,41.77 136.26,44.69 135.63,45.32 135.63,49.58 133.25,51.96 133.25,52.78 132.52,53.51 132.52,55.21 v1(132,55.73)
  IN2 w0.122: v1(132,55.73) 132.22,55.73 133.44,56.94 133.44,57.37 134.66,58.59 135.62,58.59 136.08,58.13 137.83,58.13 137.94,58.24 138.54,58.24 138.72,58.06 138.72,57.47 138.87,57.32 139.37,57.32 141.76,54.93 143.58,54.93 146.58,57.93 146.58,59.24 146.2,59.61 146.2,61.45 146.76,62.02 146.76,65.65 148.54,67.43 148.54,69.81 145.67,72.68 145.67,75.9 149.73,79.96 149.73,85.37 148.05,87.05 143.95,87.05 143.37,87.63 139.61,87.63 139.25,87.63 137.48,89.39 135.08,89.39 134.89,89.58 121.82,89.58 120.63,90.78 117.61,90.78 112.7,95.68 112.7,96.31 110.42,98.6 108.51,98.6 108.26,98.34 106,98.34 v1(105.72,98.62)
  IN4 w0.089: v1(274.68,41.73) 274.67,41.74 274.67,42.14 273.87,42.95 273.87,43.61 272.32,45.16 v1(270.9,45.16)
  BOTTOM w0.076: v1(132,55.73) 132.36,56.09 UC1.AP15
  BOTTOM w0.102: QE11.2 110.31,89.26 107.42,92.15 104.88,92.15 104.5,92.53 104.5,94.46 v2(104.18,94.78) 104.18,95.42 104.83,96.07 104.83,97.74 v1(105.72,98.62) ; JAPS1.2 214.2,13.98 212.96,12.73 206.19,12.73 205.54,13.38 v1(202.87,13.38)
SIO_SLP_S4#: length 496.9
  TOP w0.076: UE1.N12 268.12,44.53 269.52,43.13 269.52,43.07
  TOP w0.102: UZ34.2 155.95,27.22 155.78,27.4 155.17,27.4 154.89,27.12 154.89,26.06 155.63,25.32 157.79,25.32 164.06,31.59 v2(186.4,31.59) 187.96,31.59 v1(190.15,29.41) ; PR208.1 59.44,54.36 v1(59.47,54.34) ; 269.52,43.07 269.52,42.46 269.32,42.26 269.32,40.56 270.08,39.8 272.34,39.8 272.77,39.37 272.77,37.88 272.47,37.57 272.47,34.54 273.11,33.91 273.11,33.07 273.03,32.99 273.03,32.51 v1(273.11,32.43) ; v1(212.88,16.56) 212.88,15.54 212.81,15.46 212.81,11.5 214.3,10 218.62,10 PR513.1
  IN1 w0.089: v1(273.11,32.43) 272.65,31.98 272.55,31.98 271.3,30.73 271.3,30.37 271.1,30.17 266.48,30.17 266.18,30.47 263.97,30.47 263.71,30.2 263.71,29.1 263.4,28.79 261.92,28.79 261.27,28.14 256.16,28.14 255.02,27 253.95,27 253.01,26.06 253.01,23.04 252.27,22.3 250.18,22.3 249.33,21.44 247.59,21.44 247.24,21.09 246.23,21.09 245.52,20.39 244.35,20.39 244.11,20.63 239.52,20.63 238.53,21.61 234.4,21.61 234.18,21.4 231.27,21.4 231.19,21.31 227.73,21.31 227.2,21.85 223.48,21.85 223.02,21.39 218.16,21.39 217.38,20.61 217.38,18.51 216.72,17.85 213.92,17.85 213.54,17.46 213.54,16.89 213.2,16.56 v1(212.88,16.56) 212.13,17.31 208.85,17.31 207.07,19.1 207.07,20.52 206.06,21.53 205.47,21.53 204.14,22.86 203.22,22.86 202.19,23.88 202.19,24.35 201.93,24.61 200.74,24.61 200.36,24.99 200.36,25.6 199.78,26.18 198.58,26.18 198.38,25.98 196.68,25.98 195.89,26.77 195.89,27.8 195.27,28.42 192.59,28.42 191.29,29.71 190.45,29.71 v1(190.15,29.41) 187.75,29.41 183.23,33.93 177.5,33.93 176.64,34.79 160.41,34.79 158.3,36.9 v1(158.3,37.59)
  IN2 w0.122: v1(158.3,37.59) 158.3,36.41 159.2,35.51 167.87,35.51 171.29,38.92 171.29,44.87 170.7,45.46 170.7,48.08 169.19,49.6 169.19,53.35 168.39,54.16 168.39,57.87 167.1,59.15 167.1,60.79 166.74,61.15 166.74,66.14 167.19,66.59 167.19,67.38 164.62,69.95 160.58,69.95 159.87,70.66 159.87,71.53 159.5,71.91 159.5,77.33 160.02,77.86 160.02,78.3 154.24,84.08 154.24,88.43 v1(153.5,89.18) 153.3,89.18 151.61,90.86 151.35,90.86 149.41,92.81 141.51,92.81 139.38,94.94 131.66,94.94 131.36,94.64 121.53,94.64 119.44,96.74 119.44,99.89 115.83,103.5 107.99,103.5 107.73,103.76 106.97,103.76 106.19,104.54 105.74,104.54 105.41,104.21 99.85,104.21 99.46,103.82 88.63,103.82 87.55,104.9 85.16,104.9 84.76,104.5 80.1,104.5 78.6,106.01 70.08,106.01 68.25,104.19 68.25,96.94 67.21,95.89 v1(67.03,95.89)
  IN3 w0.122: v1(59.47,54.34) 59.24,54.57 59.24,66.21 58.25,67.2 57.76,67.2 57.36,67.61 57.36,67.99 57.97,68.6 57.97,74.21 58.51,74.76 58.51,77.87 61.28,80.64 61.28,84.89 63.3,86.9 63.3,91.99 64.95,93.65 64.95,95.17 65.68,95.89 v1(67.03,95.89) ; v1(134.98,86.08) 134.98,86.07 135.73,85.31 143.44,85.31 146.17,88.05 152.37,88.05 v1(153.5,89.18)
  BOTTOM w0.076: 134.2,47.48 133.89,47.48 131.46,49.91 131.46,51.97 UC1.BA16
  BOTTOM w0.102: UZ21.4 134.55,85.8 134.83,86.08 v1(134.98,86.08) ; JAPS1.5 212.7,16.38 v1(212.88,16.56) ; v1(158.3,37.59) 158.3,37.61 157.54,38.38 148.24,38.38 144.09,42.52 138.12,42.52 135.16,45.48 135.16,46.52 134.2,47.48
SIO_SLP_S5#: length 184.1
  TOP w0.076: UE1.N8 264.82,44.27 265.2,43.89 265.73,43.89 266.14,43.48 266.14,42.85
  TOP w0.102: v1(263.28,30.04) 263.28,30.4 264.1,31.23 v2(264.22,31.23) 264.31,31.23 264.61,31.53 264.98,31.9 264.98,32.1 265.65,32.77 265.87,32.77 266.12,33.03 266.12,35.61 266.37,35.86 266.37,38.65 265.74,39.29 265.74,39.34 265.74,39.34 265.74,41.32 266.32,41.9 266.32,42.64 266.14,42.83 266.14,42.85
  IN1 w0.089: v1(158.93,37.58) 158.93,36.83 160.72,35.04 177.16,35.04 178.03,34.16 183.41,34.16 187.62,29.94 194.23,29.94 196.17,27.99 196.17,26.89 196.85,26.21 198.28,26.21 198.48,26.41 199.9,26.41 200.59,25.73 200.59,25.09 200.84,24.84 202.09,24.84 202.42,24.51 202.42,23.99 203.32,23.08 204.35,23.08 205.54,21.89 206.2,21.89 207.29,20.8 207.29,19.2 208.96,17.53 212.22,17.53 212.65,17.09 v1(213.14,17.09) 213.14,17.55 213.66,18.07 216.64,18.07 217.14,18.58 217.14,20.68 218.7,22.24 221.06,22.24 221.69,21.61 222.78,21.61 223.28,22.1 227.3,22.1 227.87,21.53 231.1,21.53 231.18,21.61 233.86,21.61 234.75,22.5 237.95,22.5 239.61,20.84 244.2,20.84 244.44,20.6 245.43,20.6 246.14,21.31 247.15,21.31 247.5,21.66 249.24,21.66 250.1,22.51 252.19,22.51 252.79,23.11 252.79,26.16 253.85,27.22 254.92,27.22 256.06,28.37 261.04,28.37 262.72,30.04 v1(263.28,30.04)
  BOTTOM w0.076: 134.16,47.17 133.91,47.17 131.29,49.78 131.29,51.56 131.14,51.72 131.14,52.16 131.43,52.46 UC1.AY16
  BOTTOM w0.102: 134.16,47.17 134.71,46.62 134.71,45.46 137.89,42.29 144,42.29 148.27,38.02 155.63,38.02 156.85,36.8 158.16,36.8 v1(158.93,37.58) ; JAPS1.4 213.2,15.67 213.31,15.78 213.31,16.91 v1(213.14,17.09)
SIO_SLP_SUS#: length 161
  TOP w0.102: v2(260.42,36.17) 260.29,36.17 259.57,36.89 RC441.1 259.33,37.51 v1(259.23,37.6) 259.23,38.2 RE349.1
  IN1 w0.076: 138.6,56.26 137.63,57.22 137.23,57.22 137.1,57.22 136.44,57.88 136.05,57.88 135.72,58.21 135.31,58.21 134.8,57.7 133.76,57.7 133.61,57.55
  IN1 w0.089: 138.6,56.26 140.35,54.5 141.86,54.5 142.3,54.07 145.67,54.07 146.44,53.31 151.15,53.31 152.45,52.01 154.72,52.01 155.4,51.33 155.4,50.42 157.03,48.79 157.56,48.79 162.49,43.86 164.16,43.86 164.9,43.12 169.67,43.12 170.2,42.59 177.42,42.59 181.94,38.07 184.41,38.07 188.93,33.55 195.58,33.55 196.3,32.84 196.73,32.84 199.34,30.22 201.1,30.22 201.58,29.74 202.24,29.74 204.66,27.31 206.43,27.31 207.24,26.49 209.27,26.49 210.21,25.55 210.21,24.23 211.17,23.27 216.37,23.27 218.34,25.23 220.7,25.23 220.93,25 222.03,25 222.26,25.23 223.89,25.23 224.23,25.57 225.34,25.57 225.64,25.87 229.46,25.87 229.54,25.95 238,25.95 238.37,26.32 239.11,26.32 239.22,26.21 239.22,25.6 240.9,23.92 245.05,23.92 245.5,24.36 245.97,24.36 247.28,25.67 248.01,25.67 248.8,26.46 250.53,26.46 251.67,27.61 251.72,27.61 251.9,27.78 v1(251.97,27.78) ; v1(132.01,56.33) 132.39,56.33 133.61,57.55
  IN3 w0.122: v1(251.97,27.78) 252.56,28.37 252.56,29.76 251.01,31.31 251.01,31.93 253.93,34.84 v1(254.56,34.84)
  IN4 w0.089: v1(259.23,37.6) 259.23,37.8 259.01,38.02 258.42,38.02 257.84,37.44 256.69,37.44 255.78,36.52 255.78,35.68 254.94,34.84 v1(254.56,34.84)
  BOTTOM w0.076: UC1.AN15 132.45,56.66 132.07,56.33 v1(132.01,56.33)
SIO_SLP_SUS#_R: length 8.6
  TOP w0.076: 259.33,39.22 RE349.2 ; 261.52,42.85 261.66,42.99 261.66,43.47 261.42,43.71 261.42,44.33 UE1.N4
  TOP w0.102: RE561.1 258.47,38.36 259.33,39.22 ; RE349.2 259.35,39.58 259.55,39.78 v2(259.55,40.22) 259.55,40.38 260.2,41.03 260.2,42.64 260.53,42.97 260.91,42.97 261.17,42.72 261.39,42.72 261.52,42.85
SIO_SLP_WLAN#: length 184
  TOP w0.102: v1(166.81,41.58) 178.36,41.58 179.99,39.95 190.07,39.95 190.48,39.54 190.92,39.54 191.38,40 193.65,40 193.93,39.72 199.95,39.72 201.88,37.79 202.9,37.79 203.71,38.6 206.25,38.6 206.79,39.14 206.79,39.8 208.69,41.7 v3(210.3,41.7) 212.4,41.7 213.03,41.07 217.63,41.07 217.89,40.81 219.13,40.81 220.55,39.39 220.55,36.34 221.11,35.78 222.29,35.78 222.65,36.14 223,36.14 QZ15.1 222.78,35.75 222.25,35.23 222.25,34.51 222.09,34.35 221.52,34.35 220.76,33.59 220.76,32.11 223.02,29.85 v1(223.02,28.65) ; UE1.D9 266.02,52.13 v1(266.02,53.67)
  IN2 w0.122: v1(266.02,53.67) 265.54,54.15 262.44,54.15 261.6,54.99 258.8,54.99 258.63,55.16 256.72,55.16 255.71,54.15 253.55,54.15 253.06,53.67 252.18,53.67 252.02,53.51 251.39,53.51 250.68,52.8 250.68,51.05 250.98,50.75 250.98,47.09 249.76,45.87 249.76,44.62 247.91,42.77 247.34,42.77 246.61,42.05 246.61,41.5 245.33,40.22 245.33,39.82 244.24,38.72 244.24,37.19 243.49,36.45 242.06,36.45 236.04,30.42 232.87,30.42 232.41,29.96 227.58,29.96 226.45,28.83 223.19,28.83 v1(223.02,28.65)
  BOTTOM w0.076: 133.65,46.48 133.65,46.84 130.96,49.53 130.96,50.92 UC1.BB17
  BOTTOM w0.102: 133.65,46.48 133.65,45.3 138.77,40.18 143.95,40.18 148.38,35.75 160.92,35.75 166.75,41.58 v1(166.81,41.58)
SLEEVE:
  vias: v2(270.08,19.63)
SLEEVE_R: length 18.9
  TOP w0.127: v2(276.77,18.53) 276.77,19.11 276.61,19.27 v1(276.2,19.27)
  TOP w1.016: 292.41,13.13 292.31,13.23 285.78,13.23 284.75,12.2 284.28,12.2
  IN4 w1.016: 275.26,18.97 275.26,17.06 276.46,15.87 276.46,14.25 278.85,11.86 279.33,11.86
  vias: v1(276.2,18.69) v1(279.82,11.12) v1(280.41,11.13)
SLOT2_SATA_LED#: length 4.4
  TOP w0.102: v2(259.07,33.09) 259.52,33.09 RN101.1 260.35,33.93 v1(260.35,34.64)
  BOTTOM w0.102: v1(260.35,34.64) 260.35,34.77 261,35.41 JNGFF2.10
SLP_WLAN#_GATE: length 5.1
  TOP w0.102: v2(225.18,37.51) 225.4,37.28 RZ518.2 RE552.1 224.5,36.4 QZ15.2
SLP_WLAN#_M: length 5.5
  TOP w0.102: QZ15.3 220.52,34.12 DZ9.3 219.56,33.5 218.27,33.5 RZ71.1 217.83,33.08 v2(217.94,32.98)
SM_RCOMP0: length 2.9
  TOP w0.381: v1(130.17,55.03) v2(129.7,55.49) 129.7,56.65 129.44,56.92 RC5.1
  BOTTOM w0.254: v1(130.17,55.03) 130.17,55.03 130.6,55.37 130.6,55.42 UC1.AR18
SM_RCOMP1: length 11.5
  TOP w0.381: RC6.1 128.68,44.78 128.68,49.16 128.63,49.21 v2(128.63,53.01) 128.63,53.28 129.11,53.77 129.44,53.77 129.64,53.97 129.82,54.25 v1(130.17,54.44)
  BOTTOM w0.254: v1(130.17,54.44) 130.17,54.45 130.6,54.77 UC1.AT18
SM_RCOMP2: length 10.2
  TOP w0.381: RC7.1 129.98,45.11 129.7,45.39 129.7,49.58 129.65,49.63 v2(129.65,52.02) 129.65,52.97 129.93,53.25 v1(130.17,53.81)
  BOTTOM w0.254: v1(130.17,53.81) 130.17,53.81 130.6,54.12 UC1.AU18
SML0_SMBCLK: length 187.1
  TOP w0.102: UL1.28 254.31,74.32 254.56,74.07 v1(254.56,73.83)
  IN1 w0.089: v1(150.99,63.93) 151.05,63.98 152.1,63.98 152.63,63.45 154.3,63.45 155.11,64.26 155.11,65.02 156.15,66.06 157.38,66.06 157.6,66.28 158.44,66.28 161.29,63.42 161.5,63.42 163.58,61.34 165.74,61.34 167.87,59.2 168.51,59.2 169.49,58.23 171.77,58.23 172.08,58.53 173.65,58.53 174.4,57.78 174.4,56.66 174.95,56.12 175.76,56.12 176.27,55.61 176.27,55.43 178.21,53.49 178.21,52.19 179.55,50.85 180.47,50.85 182.35,48.97 182.35,48.35 184.9,45.8 185.54,45.8 190.72,40.62 192.88,40.62 194.37,39.14 195.5,39.14 196.52,38.11 198.13,38.11 198.89,37.35 199.48,37.35 200.95,35.87 202.53,35.87 203.15,35.25 206.02,35.25 207.95,33.32 210.46,33.32 213.64,30.15 216.78,30.15 217.92,31.29 218.44,31.29 218.77,31.62 221.27,31.62 221.76,32.11 223.18,32.11 223.63,31.67 225.12,31.67 225.37,31.91 v1(225.37,32.08)
  BOTTOM w0.076: UC1.R9 136.14,65.67 136.43,65.38 136.7,65.38 136.77,65.45 137.03,65.45 137.1,65.38 137.38,65.38 137.57,65.19 137.57,64.49 138.05,64 138.67,64 138.96,63.71 138.96,63.43 139.21,63.18 139.69,63.18 139.73,63.15 140.27,63.15 140.55,63.08 142.42,63.08 142.63,63.29 143.38,63.29 143.69,63.6 144.73,63.6 144.92,63.41
  BOTTOM w0.102: v1(225.37,32.08) 225.51,32.22 226.39,32.22 227.13,32.96 227.13,36.67 225.91,37.89 222.94,37.89 221.77,39.06 221.77,41.3 224.44,43.96 227.52,43.96 228.68,45.13 229.52,45.13 230.18,45.79 232.04,45.79 234.65,48.41 235.31,48.41 236.94,50.03 239.27,50.03 241.46,52.22 244.33,52.22 247.19,55.08 249.02,55.08 249.56,55.62 250.02,55.62 252.66,58.26 252.66,72.74 253.68,73.76 254.49,73.76 v1(254.56,73.83) ; 144.92,63.41 144.93,63.41 146.95,63.41 147.15,63.2 148.24,63.2 148.54,63.51 150.47,63.51 150.88,63.91 150.98,63.91 v1(150.99,63.93) 151.01,63.91 152.02,63.91 RC347.1 152.65,63.29 154.02,63.29 CC318.1 RC19.1
SML0_SMBDATA: length 180.5
  TOP w0.102: v1(254.59,73.12) UL1.31
  IN1 w0.089: v1(150.99,64.52) 151.07,64.45 152.29,64.45 152.83,63.92 154.1,63.92 154.64,64.46 154.64,65.22 155.96,66.53 157.19,66.53 157.41,66.75 158.63,66.75 161.49,63.89 161.69,63.89 163.77,61.81 165.93,61.81 168.07,59.67 168.7,59.67 169.68,58.7 171.58,58.7 171.88,59 173.85,59 174.87,57.98 174.87,56.86 175.14,56.59 175.95,56.59 176.74,55.8 176.74,55.63 178.68,53.68 178.68,52.38 179.75,51.32 180.67,51.32 182.82,49.16 182.82,48.55 185.1,46.27 185.74,46.27 190.92,41.09 193.07,41.09 194.56,39.61 195.69,39.61 196.72,38.58 198.33,38.58 199.09,37.82 199.67,37.82 201.15,36.34 202.72,36.34 203.34,35.72 206.21,35.72 208.14,33.79 210.66,33.79 213.83,30.62 216.59,30.62 217.73,31.76 218.25,31.76 218.58,32.09 221.07,32.09 221.57,32.58 223.38,32.58 223.82,32.14 v1(224.76,32.14)
  BOTTOM w0.076: 145,63.89 144.99,63.89 144.9,63.8 143.65,63.8 143.31,63.46 142.56,63.46 142.35,63.25 140.57,63.25 140.29,63.31 140.15,63.31 UC1.W2
  BOTTOM w0.102: 145,63.89 147.15,63.89 147.35,63.69 148.04,63.69 148.34,63.99 150.27,63.99 150.8,64.52 v1(150.99,64.52) 151.12,64.4 151.82,64.4 RC348.1 152.98,65.55 RC20.1 ; v1(224.76,32.14) 224.87,32.03 224.87,31.77 225.07,31.57 225.6,31.57 225.78,31.74 226.59,31.74 227.61,32.76 227.61,36.87 226.11,38.38 223.14,38.38 222.25,39.26 222.25,41.1 224.64,43.48 227.72,43.48 228.88,44.65 229.72,44.65 230.38,45.31 232.24,45.31 234.85,47.93 235.51,47.93 237.14,49.55 239.47,49.55 v2(239.58,49.65) 241.66,51.74 244.53,51.74 247.39,54.59 249.22,54.59 249.76,55.14 250.22,55.14 253.14,58.06 253.14,72.54 253.88,73.28 254.44,73.28 v1(254.59,73.12)
SML1_SMBCLK: length 200
  TOP w0.102: v1(265.24,52.13) 264.85,51.73 UE1.D8
  IN1 w0.089: v1(280.81,40.16) 280.75,40.1 280.75,39.71 277.76,36.72 276.1,36.72 275.81,36.43 270.02,36.43 267.98,34.39 266.6,34.39 266.18,34.81 263.17,34.81 262.09,33.73 260.87,33.73 260.68,33.54 259.2,33.54 258.52,32.86 257.43,32.86 257.1,33.19 252.07,33.19 250.56,34.71 245.94,34.71 245.71,34.93 240.71,34.93 237.56,31.78 234.66,31.78 234.21,31.33 232.1,31.33 231.65,31.78 227.37,31.78 226.05,33.11 218.91,33.11 218.11,32.3 217.48,32.3 216.95,31.77 214.94,31.77 214.7,31.53 213.6,31.53 210.87,34.26 208.36,34.26 206.43,36.19 203.56,36.19 202.84,36.92 201.49,36.92 199.34,39.06 197.06,39.06 194.92,41.19 193.73,41.19 193.35,41.58 191.14,41.58 189.83,42.88 189.83,43.34 185.61,47.56 184.49,47.56 183.33,48.72 183.33,49.77 182.8,50.29 177.26,55.84 177.26,56.65 173.12,60.79 173.12,64.07 171.33,65.86 164.75,65.86 163.99,66.62 160.72,66.62 158.47,68.87 155.96,68.87 153.25,66.16 152.21,66.16 152,65.95 145.21,65.95 145.11,65.86 145.11,65.74 v1(145.19,65.66)
  IN4 w0.089: v1(280.81,40.16) 280.75,40.21 280.75,41.17 279.15,42.77 275.29,42.77 274.81,43.25 274.81,48 274.29,48.52 271.52,48.52 268.35,51.7 266.65,51.7 266.45,51.89 265.47,51.89 v1(265.24,52.13)
  BOTTOM w0.076: UC1.W3 139.5,63.71 139.66,63.71 139.87,63.79 140.01,63.79 140.01,63.78 140.16,63.74 140.42,63.74 140.5,63.78 141.12,63.78 142.14,63.78 142.4,64.03 143.13,64.03 143.87,64.77 144.19,64.77
  BOTTOM w0.102: 144.19,64.77 144.41,64.77 145.19,65.55 v1(145.19,65.66) v2(146.41,65.66) 147.87,65.66 148.15,65.95 148.87,65.95 149.33,65.49 CC319.1 RC15.1
SML1_SMBDATA: length 197.8
  TOP w0.076: UE1.E11 266.84,51.32 v1(266.02,51.32)
  IN1 w0.089: v1(280.22,40.16) 280.28,40.1 280.28,39.9 277.56,37.19 275.9,37.19 275.62,36.9 269.83,36.9 267.78,34.86 266.8,34.86 266.38,35.28 262.97,35.28 261.89,34.2 260.67,34.2 260.48,34.01 259,34.01 258.33,33.33 257.63,33.33 257.3,33.66 252.26,33.66 250.75,35.18 246.13,35.18 245.9,35.4 240.52,35.4 237.37,32.25 234.47,32.25 234.01,31.8 232.3,31.8 231.84,32.25 227.56,32.25 226.24,33.57 218.72,33.57 217.92,32.77 217.28,32.77 216.75,32.24 214.75,32.24 214.5,32 213.8,32 211.07,34.73 208.55,34.73 206.62,36.66 203.75,36.66 203.03,37.38 201.68,37.38 199.53,39.53 197.25,39.53 195.12,41.66 193.92,41.66 193.54,42.05 191.33,42.05 190.3,43.08 190.3,43.54 185.81,48.03 184.69,48.03 183.8,48.92 183.8,49.96 177.73,56.03 177.73,56.84 173.59,60.98 173.59,64.26 171.52,66.33 164.94,66.33 164.18,67.09 160.91,67.09 158.67,69.34 155.76,69.34 153.06,66.63 152.02,66.63 151.81,66.42 145.02,66.42 144.64,66.05 144.64,65.71 v1(144.61,65.67)
  IN4 w0.089: v1(280.22,40.16) 280.28,40.21 280.28,40.97 278.96,42.3 275.1,42.3 274.34,43.06 274.34,47.8 274.09,48.05 271.33,48.05 268.15,51.23 266.45,51.23 266.26,51.42 266.13,51.42 v1(266.02,51.32)
  BOTTOM w0.076: 144.63,65.97 144.63,65.95 144.61,65.93 v1(144.61,65.67) 144.61,65.35 144.2,64.95 143.82,64.95 143.06,64.19 142.33,64.19 142.08,63.94 141.05,63.94 140.47,63.94 140.38,63.91 140.19,63.91 140.06,63.94 140.03,63.95 139.85,63.95 139.72,63.91 139.24,63.91 UC1.V3
  BOTTOM w0.102: RC17.1 147.95,66.43 147.67,66.15 144.8,66.15 144.63,65.97
SNB_+1VALWP: length 1.5
  TOP w0.102: PC302.1 v3(158.68,104.59)
SNUB_1.8VALW: length 2.2
  TOP w0.102: PC506.1 v2(172.17,109.6)
  TOP w0.508: PC506.1 171.45,108.37 PR502.2
SNUB_1V_PRIM: length 2.6
  TOP w0.102: v3(169.4,97.25) PR409.2
  TOP w0.508: PR409.2 169.4,99.54 PC419.1
SNUB_1VS_VCCIO: length 2.1
  BOTTOM w0.102: v2(168.11,49.2) 169.63,49.2 169.96,48.88 PC401.1
SNUB_CHG1: length 2.9
  TOP w0.102: v2(35.97,33.9) PR923.2
  TOP w0.508: PR923.2 34.84,35.59 PC940.1
SNUB_CHG2: length 2.6
  TOP w0.102: PC941.1 34.47,30.45 v2(34.22,30.7)
  TOP w0.508: PC941.1 PR924.2
SPK_DET#: length 172.8
  TOP w0.102: v3(136.49,62.51) 136.95,62.51 v1(137.52,63.08)
  IN1 w0.089: v1(237.88,35.91) 237.71,35.75 236.48,35.75 236.06,35.33 233.91,35.33 232.57,33.98 228.27,33.98 226.69,35.57 217.37,35.57 216.46,34.66 213.73,34.66 211.09,37.29 209.22,37.29 208.8,37.72 207.73,37.72 207.4,38.05 205.39,38.05 204.42,39.01 202.03,39.01 199.99,41.04 197.74,41.04 195.25,43.53 193.53,43.53 192.21,44.85 190.99,44.85 179.3,56.54 179.3,57.23 178.29,58.24 178.29,59.36 177.22,60.42 177.22,61.77 176.99,62 176.99,62.45 175.52,63.93 175.52,64.72 171.33,68.91 165.62,68.91 164.56,69.96 160.36,69.96 158.25,72.07 156.13,72.07 154.66,70.6 152.39,70.6 151.5,69.71 147.82,69.71 147.41,69.3 144.87,69.3 144.48,68.91 141.11,68.91 138.02,65.81 137.61,65.81 137.52,65.72 v1(137.52,63.08)
  BOTTOM w0.076: UC1.W7 v1(137.52,63.08)
  BOTTOM w0.102: v1(237.88,35.91) 239.7,34.08 239.7,27.87 242.15,25.42 243.95,25.42 244.63,24.74 244.63,23.01 244.28,22.65 244.28,21.51 245.04,20.75 245.63,20.75 247.47,18.91 247.47,17.53 247.84,17.16 249.98,17.16 251.08,16.06 251.08,13.33 251.31,13.1 252.7,13.1 253.36,13.76 254.23,13.76 RA58.2 255.1,13.28 256.26,14.45 259.44,14.45 259.9,14.91 259.9,16.05 258.95,17 JSPK1.5
SPKR: length 202
  TOP w0.102: v1(138.51,53.75) 138.84,54.08 v2(139.4,54.08) 139.61,53.87 147.96,53.87 148.21,54.11 148.85,54.11 148.91,54.17 151.43,54.17 151.9,53.7 RC183.1 ; RA12.2 273.83,23.52 v1(273.83,23.87)
  IN1 w0.089: v1(138.51,53.75) 139.76,52.51 139.76,47.48 139.83,47.41 139.83,47.11 140.54,46.4 140.71,46.4 146.56,40.55 151.85,40.55 159.69,32.71 182.88,32.71 188.24,27.35 190.43,27.35 192.61,25.17 198.43,25.17 199.14,24.46 199.65,24.46 201.53,22.58 202.33,22.58 204.54,20.37 204.54,20.01 207.29,17.26 207.29,16.46 207.8,15.95 209.46,15.95 210.16,15.24 213.17,15.24 214.25,16.32 216.31,16.32 218.17,18.18 218.17,19.87 218.46,20.16 219.9,20.16 220.2,20.46 225.29,20.46 225.35,20.53 231.52,20.53 231.6,20.61 233.93,20.61 234.42,20.11 237.88,20.11 238.19,19.8 243.56,19.8 243.93,20.17 245.69,20.17 246.39,20.88 247.33,20.88 247.68,21.23 249.42,21.23 250.27,22.08 252.36,22.08 253.24,22.96 253.24,25.95 254.06,26.77 255.12,26.77 256.11,27.76 258.22,27.76 258.65,27.33 261.16,27.33 261.53,27.7 261.53,28.09 262.01,28.57 263.49,28.57 264.59,29.67 266.34,29.67 266.62,29.94 271.25,29.94 271.53,30.22 271.53,30.63 272.29,31.39 v1(273,31.39)
  IN3 w0.122: v1(273,31.39) 273.05,31.44 277.53,31.44 278.34,30.63 281,30.63 281.41,30.22 281.41,29.99 280.9,29.48 280.9,28.67 275.52,23.29 274.41,23.29 v1(273.83,23.87)
  BOTTOM w0.076: v1(138.51,53.75) 138.42,53.75 138.09,53.43 UC1.AW5
SPKR_R: length 2.6
  TOP w0.254: RA12.1 CA27.1 274.5,22.31 CA72.1 RA51.1
SRTCRST#: length 40.8
  TOP w0.102: CC24.1 154.75,41.83 155.65,42.73 RC56.1 156.29,43.22 156.29,44.47 155.78,44.98 153.88,44.98 153.55,45.31 v2(153.55,46.07) 153.37,46.25 153.37,46.94 v1(153.55,47.11)
  IN4 w0.076: 138.49,52.75 137.72,52.75 137.52,52.96 136.72,52.96 136,52.23 134.62,52.23 134.05,52.8 133.61,52.8 133.19,53.22 132.49,53.22 131.94,53.77 131.94,54.21 131.18,54.97 130.99,54.97 130.65,55.32 130.65,56.14 130.38,56.41 v1(130.25,56.41)
  IN4 w0.089: 138.49,52.75 140.77,52.75 141.99,51.53 143.5,51.53 143.83,51.86 146.42,51.86 147.58,53.02 151.17,53.02 152.84,51.35 152.84,47.82 v1(153.55,47.11)
  BOTTOM w0.076: v1(130.25,56.41) 130.58,56.74 UC1.AN18
SS_1V_PRIM: length 5.1
  TOP w0.102: PR428.1 171.43,104.05 v2(169.9,104.05)
  TOP w0.254: PR428.1 171.9,102.69 PC420.1 172.13,102.62 172.76,101.99 v1(172.79,101.99)
  BOTTOM w0.254: PU402.7 172.95,101.83 v1(172.79,101.99)
SS_1VS_VCCIO: length 4.1
  TOP w0.102: v2(173.96,54.69) PC410.1
  TOP w0.254: PC410.1 175.08,54.69 PR427.1 175.08,53.75 175.63,53.2 v1(175.63,52.88)
  BOTTOM w0.254: v1(175.63,52.88) 175.47,52.72 PU401.7
SUSACK#: length 178
  TOP w0.076: UE1.K12 268.18,46.93 268.5,47.25 269,47.25 269.42,46.83 269.83,46.83
  TOP w0.102: RC443.1 142.09,38.02 v1(142.93,37.18) ; 269.83,46.83 269.93,46.94 271.94,46.94 272.41,46.47 273.55,46.47 273.87,46.15 273.87,45.43 273.28,44.84 273.28,42.45 273,42.17 273,37.78 272.7,37.48 272.7,34.74 273.36,34.08 273.36,32.81 273.51,32.66 273.51,31.32 v2(272.88,30.69) 272.88,30.12 v1(272.93,30.07)
  IN1 w0.089: v1(142.93,37.18) 144.26,35.85 151.91,35.85 159.76,28.01 182.78,28.01 188.38,22.41 194.4,22.41 195.45,21.36 196.65,21.36 197.31,20.69 197.97,20.69 199.11,19.55 200.44,19.55 202.06,17.94 202.06,17.59 202.69,16.97 202.69,15.53 205.21,13 214.1,13 214.82,13.72 217.86,13.72 218.25,14.12 218.25,14.62 220.05,16.42 220.33,16.42 221.4,17.49 227.62,17.49 227.65,17.52 232.72,17.52 233.12,17.92 239.5,17.92 240.33,17.1 240.66,17.1 241.03,17.47 247.58,17.47 249,18.89 249.97,18.89 250.69,18.17 251.25,18.17 251.41,18.33 251.41,19.22 251.5,19.31 252.45,19.31 254.55,21.41 255.68,21.41 256.07,21.8 256.07,22.48 255.7,22.84 255.7,23.97 257.73,26 264.17,26 265.4,27.22 266.37,27.22 266.65,27.5 266.65,27.99 267.26,28.61 272.2,28.61 272.93,29.33 v1(272.93,30.07)
SUSACK#_R: length 32.7
  TOP w0.102: v1(133.86,55.73) 134.3,55.73 134.61,55.42 135.06,55.42 135.18,55.55 135.18,57.48 RC551.1 ; RC443.2 141.22,38.48 142.22,38.48 v1(143.51,37.18) 143.51,37.16 v2(142.77,36.41)
  IN1 w0.089: v1(133.86,55.73) 134.29,55.29 134.29,52.31 136.45,50.15 136.45,45.39 137.47,44.37 137.47,41.45 140.87,38.05 142.65,38.05 v1(143.51,37.18)
  BOTTOM w0.076: UC1.AP11 134.22,56.09 v1(133.86,55.73)
SUSCLK: length 159.7
  TOP w0.102: RZ56.2 220.3,26.42 219.87,25.99 219.87,25.52 218.62,24.28 218.62,22.88 218.05,22.31 217.71,22.31 217.52,22.12 v2(216.58,22.12) 215.83,22.12 213.92,20.21 213.92,19.02 v1(213.69,18.79) ; RC48.1 143.44,40.75 v1(143.44,41.46)
  IN1 w0.089: v1(166.17,41.58) 166.67,41.08 176.65,41.08 181.33,36.41 184.01,36.41 188.62,31.8 194.87,31.8 195.6,31.07 196.16,31.07 198.68,28.55 200.31,28.55 201.22,27.63 201.22,27.63 201.25,27.61 202.09,27.61 202.92,26.77 202.92,26.69 204.74,24.88 206.54,24.88 209.62,21.8 209.62,21.7 209.63,21.69 209.63,20.47 211.11,18.98 213.5,18.98 v1(213.69,18.79)
  IN4 w0.089: v1(213.69,18.79) 214.41,18.08 216.08,18.08 217.23,16.94 217.23,16.43 217.86,15.79 220.04,15.79 220.61,16.37 229.28,16.37 229.89,15.76 232.76,15.76 233.77,14.75 238.55,14.75 238.82,15.02 240.34,15.02 241.29,14.06 243.6,14.06 244.09,13.57 246.18,13.57 247.04,12.71 247.04,11.16 247.87,10.33 250.33,10.33 250.57,10.09 v1(250.58,10.09)
  BOTTOM w0.076: UC1.BA17 130.86,51.47 131.13,51.2 131.13,49.64 134.13,46.64
  BOTTOM w0.102: v1(250.58,10.09) 250.58,9.75 250.8,9.52 RN99.2 ; v1(166.17,41.58) 165.98,41.58 160.74,36.33 148.43,36.33 144,40.76 144,40.92 143.46,41.46 v1(143.44,41.46) 142.92,40.94 141.6,40.94 140.77,41.77 137.8,41.77 134.13,45.44 134.13,46.64
SUSCLK_R: length 18.4
  BOTTOM w0.102: RN99.1 252.1,8.76 252.5,8.36 254.29,8.36 254.45,8.21 257.13,8.21 257.28,8.35 257.66,8.35 257.95,8.06 257.95,7.1 258.73,6.32 258.73,4.06 v2(259.21,3.58) 259.52,3.88 261.04,3.88 261.29,3.63 264.06,3.63 264.35,3.34 JNGFF3.68
SW2_DP1_AUXN: length 206.8
  TOP w0.094: v1(28.5,81.83) CT116.1 ; v1(22.1,68.29) 22.08,68.27 CT81.1 ; v1(176.94,83.33) 176.74,83.13 175.34,83.13 RV70.1 174.86,83.31 174.68,83.13 174.53,83.13 174,83.66 171.71,83.66 171.6,83.77 UV7.27
  IN1 w0.089: v1(176.94,83.33) 176.81,83.21 173.89,83.21 171.2,85.9 165.05,85.9 161.24,89.71 160.28,89.71 159.26,90.72 152.58,90.72 151.46,91.84 144.1,91.84 142.98,90.72 138.97,90.72 136.58,88.34 117.1,88.34 116.64,88.79 108.16,88.79 107.37,89.58 107.37,90.78 106.43,91.72 106.43,92.58 103.97,95.05 103.3,95.05 102.77,95.58 102.77,96.24 102.34,96.67 90.68,96.67 89.79,95.78 86.01,95.78 85.75,95.53 84.13,95.53 83.75,95.91 82.1,95.91 79.53,93.34 78.08,93.34 77.02,92.27 74.76,92.27 73.41,90.93 71,90.93 67.24,87.17 64.44,87.17 60.25,82.98 59.62,82.98 58.24,81.6 58.24,80.59 52.89,75.23 51.23,75.23 50.86,74.85 49.4,74.85 48.97,75.28 46.97,75.28 46.21,74.52 44.05,74.52 43.46,75.1 39.17,75.1 38.79,74.72 36.68,74.72 36.02,74.07 32.87,74.07 31.04,72.24 28.05,72.24 26.9,71.09 24.87,71.09 23.35,69.57 22.71,69.57 22.1,68.96 v1(22.1,68.29)
  IN4 w0.089: v1(22.1,68.29) 22.3,68.49 22.3,72.59 21.72,73.18 21.72,79.18 23.06,80.52 26.68,80.52 27.28,81.12 28.73,81.12 28.88,81.28 28.88,81.46 v1(28.5,81.83)
SW2_DP1_AUXN_C: length 2.9
  TOP w0.094: CT116.2 28.13,80.31 27.98,80.46 RT131.1 27.6,80.45 UT9.25
SW2_DP1_AUXP: length 206.8
  TOP w0.094: UV7.26 171.59,83.37 171.7,83.48 173.93,83.48 174.46,82.95 174.68,82.95 174.86,82.77 RV76.1 175.34,82.95 176.74,82.95 v1(176.94,82.75) ; v1(22.69,68.29) 22.71,68.27 CT80.1 ; v1(29.39,81.83) CT115.1
  IN1 w0.089: v1(22.69,68.29) 22.69,68.47 22.51,68.65 22.39,68.65 22.28,68.75 22.28,68.88 22.79,69.39 23.42,69.39 24.95,70.91 26.98,70.91 28.12,72.06 31.12,72.06 32.95,73.88 36.1,73.88 36.76,74.54 38.87,74.54 39.25,74.92 43.39,74.92 43.97,74.34 46.28,74.34 47.05,75.1 48.9,75.1 49.33,74.67 50.93,74.67 51.31,75.05 52.96,75.05 58.42,80.51 58.42,81.53 59.69,82.8 60.33,82.8 64.52,86.99 67.31,86.99 71.07,90.75 73.49,90.75 74.83,92.09 77.09,92.09 78.16,93.16 79.61,93.16 82.17,95.73 83.67,95.73 84.05,95.35 85.83,95.35 86.08,95.6 89.87,95.6 90.76,96.49 102.26,96.49 102.59,96.16 102.59,95.5 103.23,94.87 103.89,94.87 106.25,92.51 106.25,91.64 107.19,90.7 107.19,89.51 108.08,88.61 116.57,88.61 117.02,88.16 136.66,88.16 139.04,90.54 143.06,90.54 144.17,91.66 151.39,91.66 152.51,90.54 159.19,90.54 160.2,89.53 161.17,89.53 164.98,85.72 171.13,85.72 173.82,83.03 176.66,83.03 v1(176.94,82.75)
  IN4 w0.089: v1(29.39,81.83) 29.06,81.5 29.06,81.2 28.8,80.94 27.36,80.94 26.75,80.34 23.13,80.34 21.9,79.1 21.9,73.25 22.48,72.67 22.48,68.49 v1(22.69,68.29)
SW2_DP1_AUXP_C: length 3.9
  TOP w0.094: UT9.24 28,79.58 28.28,79.86 29.25,79.86 29.39,80.01 CT115.2 30.13,80.31 RT130.1
SW2_DP1_CADET: length 1.8
  TOP w0.102: RV73.1 165.59,87.42 UV7.43
SW2_DP1_HPD: length 200.3
  TOP w0.102: RT73.2 30.31,55.74 30.92,55.74 31.78,56.6 31.78,58.8 v1(31.68,58.9) ; UV7.48 v1(163.59,86.53)
  IN1 w0.089: v1(24.67,77.68) 24.67,78.2 25.51,79.04 26.57,79.04 28.48,80.95 29.9,80.95 31.04,82.09 37.63,82.09 43.85,88.31 48.19,88.31 51.87,91.99 57.97,91.99 59.49,93.52 v1(59.49,94.33)
  IN2 w0.122: v1(59.49,94.33) 60.3,94.33 61.78,95.8 63.43,95.8 65.14,97.52 65.14,101.71 65.97,102.54 65.97,106.09 67.2,107.32 68.99,107.32 69.31,107 79.01,107 80.01,106.01 81.53,106.01 84.14,108.62 92.41,108.62 93.82,110.02 97.55,110.02 100.58,106.99 103.91,106.99 104.54,107.62 105.6,107.62 106.18,108.2 108.28,108.2 109.73,106.75 118.01,106.75 126.01,98.75 128.4,98.75 128.42,98.74 128.42,98.74 128.67,98.49 128.67,98.49 128.88,98.27 128.89,98.27 128.9,98.26 130.63,98.26 131.07,97.81 140.92,97.81 142.8,95.93 152.51,95.93 157.33,91.12 159.01,91.12 v1(163.59,86.53)
  BOTTOM w0.102: v1(24.67,77.68) 24.85,77.5 24.85,77.18 25.6,76.42 25.88,76.42 26.49,75.82 26.57,75.82 26.86,75.52 RT380.1 26.86,75.46 27.31,75.02 v2(27.31,74.42) 27.31,70.48 25.71,68.88 25.71,67.03 26.46,66.28 27.37,66.28 27.74,65.91 27.74,65.45 29.67,63.52 29.67,62.94 29.98,62.63 30.43,62.63 30.87,63.06 31.12,63.06 31.42,62.76 31.42,61.64 31.3,61.51 31.3,60.32 31.68,59.94 v1(31.68,58.9)
SW2_DP1_HPD_R: length 8.4
  TOP w0.076: UT5.C10 28.79,59.81 29.04,60.06 29.98,60.06 30.1,60.18 30.62,60.18
  TOP w0.102: RT73.1 29.94,57.08 30.34,56.68 30.34,56.3 30.48,56.16 v2(30.8,56.16) 30.98,56.16 31.47,56.65 31.47,58.52 31.27,58.72 31.27,59.53 30.62,60.18
SW2_DP1_N0: length 155.4
  TOP w0.094: v1(33.89,74.6) 34.13,74.35 34.13,74.16 34.01,74.04 33.59,74.04 33.43,73.87 33.23,73.87 CT104.1 ; v1(161.54,91.39) 161.54,89.87 163.08,88.33 163.08,86.3 163.19,86.19 UV7.49
  IN1 w0.089: v1(33.89,74.6) 34.14,74.85 34.14,75.64 34.55,76.04 44.96,76.04 45.65,75.36 46.15,75.36 46.72,75.92 49.15,75.92 49.64,75.44 50.55,75.44 50.98,75.87 52.61,75.87 57.66,80.92 57.66,82.04 59.72,84.1 60.23,84.1 63.99,87.86 67.11,87.86 71.96,92.71 74.33,92.71 74.48,92.86 76.79,92.86 78.39,94.46 78.8,94.46 80.07,95.73 80.88,95.73 82.12,96.97 83.34,96.97 83.77,96.54 87.33,96.54 88.04,97.26 102.59,97.26 103.41,96.44 103.41,95.85 103.64,95.63 104.22,95.63 107.01,92.83 107.01,91.99 108.48,90.53 118.98,90.53 119.69,91.23 121.7,91.23 124.74,94.28 138.61,94.28 139.58,93.32 141.13,93.32 142.09,94.28 155.25,94.28 156.44,93.09 160.48,93.09 161.51,92.06 161.51,91.43 v1(161.54,91.39)
SW2_DP1_N0_C: length 2.5
  TOP w0.094: CT104.2 31.69,73.79 31.5,73.79 31.29,73.58 v4(31.04,73.58) 30.55,73.58 30.45,73.68 UT9.10
SW2_DP1_N1: length 155.4
  TOP w0.094: UV7.46 164.39,86.21 164.28,86.32 164.28,88.71 162.84,90.15 v1(162.84,91.39) ; v1(34.27,77.01) 34.44,76.84 34.44,76.59 33.64,75.79 33.41,75.79 CT106.1
  IN1 w0.089: v1(34.27,77.01) 34.47,77.21 34.47,77.47 34.78,77.77 43.21,77.77 44.05,76.94 50.71,76.94 51.11,76.53 52.28,76.53 56.82,81.07 56.82,83.08 58.42,84.68 59.41,84.68 63.86,89.13 67.57,89.13 72.93,94.49 73.95,94.49 74.43,94.97 76.33,94.97 76.85,95.49 78.3,95.49 79.13,96.32 80.63,96.32 81.87,97.56 83.57,97.56 83.69,97.43 84.38,97.43 84.79,97.84 102.85,97.84 104.42,96.26 104.42,96.24 106.33,94.33 107.09,94.33 107.75,93.67 107.75,92.63 109.28,91.1 118.67,91.1 119.61,92.05 121.65,92.05 124.51,94.92 155.76,94.92 156.97,93.7 161.47,93.7 162.79,92.38 162.79,91.44 v1(162.84,91.39)
SW2_DP1_N1_C: length 3.1
  TOP w0.094: UT9.13 30.41,74.89 30.5,74.8 30.94,74.8 v4(31.18,75.03) 31.42,75.28 31.42,75.62 31.57,75.77 31.76,75.77 CT106.2
SW2_DP1_N2: length 155.7
  TOP w0.094: UV7.44 165.19,86.17 165.08,86.28 165.08,89.66 165.21,89.79 v1(165.21,91.11) ; v1(35.06,78.3) 35.16,78.2 35.16,77.96 34.98,77.78 33.99,77.78 33.73,77.52 33.53,77.52 CT108.1
  IN1 w0.089: v1(35.06,78.3) 35.31,78.56 35.31,78.89 35.51,79.09 37.55,79.09 37.75,79.29 40.64,79.29 41.33,78.61 49.79,78.61 50.4,79.22 52.18,79.22 53.85,80.89 53.85,82.67 59.54,88.36 62.02,88.36 63.42,89.76 67.39,89.76 72.7,95.07 73.71,95.07 74.25,95.6 75.67,95.6 76.18,96.11 78.09,96.11 80.45,98.47 83.82,98.47 83.87,98.42 103.08,98.42 103.65,97.85 104.38,97.85 105.01,97.23 105.01,96.47 105.46,96.01 106.76,96.01 111.1,91.67 118.1,91.67 119.11,92.68 121.34,92.68 124.21,95.55 156.39,95.55 157.54,94.41 162.59,94.41 165.21,91.79 v1(165.21,91.11)
SW2_DP1_N2_C: length 3.7
  TOP w0.094: CT108.2 31.89,77.55 31.6,77.55 31.3,77.24 v4(31.3,76.79) 31.3,76.4 30.87,75.97 30.61,75.97 30.49,76.08 UT9.16
SW2_DP1_N3: length 155.8
  TOP w0.094: CT110.1 33.5,79.32 33.84,79.32 34.1,79.07 34.57,79.07 34.68,79.17 34.68,79.37 v1(34.47,79.57) ; UV7.41 166.39,86.17 166.28,86.27 166.28,89.97 166.42,90.11 v1(166.42,91.17)
  IN1 w0.089: v1(34.47,79.57) 34.7,79.8 34.7,80.06 34.95,80.31 46.46,80.31 46.61,80.16 49.05,80.16 53,84.11 54.02,84.11 58.98,89.07 61.9,89.07 65.26,92.43 67.09,92.43 69.12,94.46 71.28,94.46 72.47,95.66 73.49,95.66 74.81,96.97 76.91,96.97 79,99.06 84.2,99.06 84.25,99.01 103.41,99.01 103.97,98.45 104.62,98.45 105.34,97.74 106.84,97.74 107.57,97 107.57,96.01 108.18,95.4 108.94,95.4 112.09,92.25 117.53,92.25 118.6,93.32 121.04,93.32 124.03,96.31 156.65,96.31 157.92,95.04 163.17,95.04 166.38,91.83 166.38,91.2 v1(166.42,91.17)
