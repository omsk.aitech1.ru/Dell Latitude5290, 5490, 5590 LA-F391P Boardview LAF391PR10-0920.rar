# Allegro board LAF391PR10-0920.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_RUN on IN3: outline of 342 points within 197.53,4.88 249.74,40.38
+5V_RUN_AUDIO on TOP (solid shape): 252.53,37.66 252.53,34.22 253.09,33.65 253.09,32.96 253.34,32.71 257.3,32.71 257.32,32.71 258.09,32.71 259.07,31.73 260.6,31.73 260.72,31.61 261.48,31.61 261.61,31.73 262.12,31.73 262.44,31.42 262.44,30.59 262.31,30.47 262.07,30.47 261.35,31.18 258.31,31.18 257.88,30.75 257.88,29.85 257.63,29.6 256.43,29.6 255.6,30.43 254.25,30.43 253.89,30.69 253.53,30.43 251.48,30.43 250.91,31.01 250.91,32.74 250.55,33.09 250.55,33.45 251.13,33.45 251.13,33.96 250.6,33.96 250.58,33.98 250.58,35.99 250.63,36.04 250.91,36.04 250.91,36.06 251.11,36.06 251.11,37.77 251.26,37.92 252.28,37.92
+5V_RUN_AUDIO_UZ5 on TOP (solid shape): 248.82,35.48 250.02,35.48 250.4,35.1 250.4,33.19 250.38,33.17 250.17,33.19 249.99,33.09 249.65,33.09 247.75,34.98 246.42,34.98 246.24,35.16 246.24,36.05 246.31,36.11 248.19,36.11
+5V_RUN_PVDD_L on TOP (solid shape): 266.34,25.33 266.34,25.03 265.68,24.37 265.68,22.7 265.63,22.65 265.53,22.65 265.47,22.71 265.47,24.95 265.99,25.47 266.19,25.47
+5V_RUN_PVDD_L on IN3 (solid shape): 266.58,25.45 266.58,24.97 265.55,23.94 262.3,23.94 262.17,23.96 262.04,23.94 261.36,23.94 261.14,24.17 261.14,25.4 261.36,25.62 266.41,25.62
+5V_RUN_PVDD_L on TOP: 263.47,22.71 263.47,23.53 263.01,23.99 262.67,23.99 262.48,23.8 261.93,23.8 261.8,23.67 260.79,23.67 259.9,24.56 259.08,24.56 258.7,24.94 258.5,24.94 257.87,25.57 257.87,27.23 257.5,27.6 256.4,27.6 256.12,27.87 256.12,28.88 256.15,28.92 258.87,28.92 258.92,28.87 258.92,26.55 259.4,26.08 259.4,25.85 259.86,25.38 260.54,25.38 261.23,24.69 261.77,24.69 261.85,24.61 262.2,24.61 262.56,24.24 263.13,24.24 263.68,23.69 263.68,22.71 263.63,22.65 263.53,22.65
+5V_RUN_UZ4 on TOP (solid shape): 213.29,32.8 213.29,32.09 213.4,31.98 214.37,31.98 214.86,31.5 214.86,28.99 214.8,28.93 214.32,28.93 214.32,28.38 214.07,28.38 214.07,28.93 213.52,28.93 213.52,28.38 213.27,28.38 213.27,28.93 212.77,28.93 210.59,31.11 210.59,31.62 211.15,31.62 211.16,31.56 211.17,31.51 211.19,31.46 211.22,31.41 211.25,31.36 211.29,31.33 211.34,31.29 211.39,31.27 211.44,31.25 211.49,31.24 211.55,31.24 211.6,31.24 211.66,31.26 211.71,31.28 211.76,31.31 211.8,31.34 211.84,31.39 211.87,31.43 211.89,31.48 211.91,31.54 211.92,31.59 211.92,31.65 211.91,31.7 211.89,31.76 211.87,31.81 211.84,31.85 211.8,31.89 211.76,31.93 211.71,31.96 211.66,31.98 211.6,32 211.55,32 211.49,32 211.44,31.99 211.39,31.97 211.34,31.95 211.29,31.91 211.25,31.87 211.22,31.83 211.19,31.78 211.17,31.73 211.16,31.67 211.15,31.62 210.59,31.62 210.59,32.15 210.68,32.24 211.82,32.24 212.49,32.91 213.18,32.91
+5V_TBT_VBUS on TOP: 15.69,57.77 15.69,59.37 15.93,59.61 17.07,59.61 17.39,59.29 17.39,58.09 18.09,57.39 18.91,57.39 19.11,57.2 19.11,55.29 18.85,55.04 18.34,55.04 18.15,55.23 18.15,55.74 17.84,56.05 16.82,56.05 16.76,55.99 16.76,55.23 16.69,55.16 15.93,55.16 15.87,55.23 15.87,56.24 15.93,56.31 16.57,56.31 16.76,56.5 16.76,57.45 16.63,57.58 15.88,57.58
+5V_TBTA_VBUS_D on TOP (solid shape): 15.39,60 15.39,57.67 15.68,57.39 16.44,57.39 16.57,57.26 16.57,56.56 16.44,56.43 13.07,56.43 12.95,56.56 12.95,56.96 13.75,57.77 13.75,58.32 14.06,58.62 14.06,60.02 14.3,60.26 15.13,60.26
+5V_USB_CHG_PWR on TOP (solid shape): 280.19,28.84 280.19,27.38 279.78,26.97 277.4,26.97 277.19,27.18 277.19,27.66 277.26,27.73 277.26,28.6 277.32,28.66 279.03,28.66 279.27,28.9 280.13,28.9
+5V_USB_CHG_PWR on TOP (solid shape): 282.22,22.96 282.22,21.71 282.55,21.38 285.42,21.38 285.81,21 285.81,19.17 285.48,18.84 280.2,18.84 279.99,19.05 279.99,22.99 280.16,23.16 282.02,23.16
+5V_USB_CHG_PWR on BOTTOM (solid shape): 283.14,20.57 285.35,20.57 285.88,20.04 285.88,19.38 285.37,18.87 281.89,18.87 281.18,19.15 280.44,19.3 280.41,19.33 279.59,19.33 279.4,19.51 279.4,20.43 279.5,20.51 279.57,20.61 279.65,20.69 279.65,20.93 279.78,21.06 282.65,21.06
+5V_USB_CHG_PWR on IN2 (solid shape): outline of 384 points within 277.06,19.72 283.55,28.12
+GND_CHASSIS on TOP (solid shape): 267.55,95.34 267.55,83.94 267.31,83.7 265.83,83.7 265.63,83.91 265.63,85.28 266.26,85.91 266.26,95.3 266.44,95.48 267.41,95.48
+GND_CHASSIS on BOTTOM (solid shape): 266.9,84.76 266.9,81.02 266.78,80.91 265.63,80.91 265.58,80.96 265.58,84.83 265.75,85.01 266.64,85.01
+VBUS_DC_SS on TOP (solid shape): 51.77,65.58 51.77,60.19 51.64,60.07 49.33,60.07 49.23,60.17 49.23,62.58 48.66,63.16 44.34,63.16 43.01,64.48 43.01,65.16 43.47,65.62 44.43,65.62 45.03,65.02 48.92,65.02 49.08,65.17 49.08,65.66 49.15,65.73 51.62,65.73
+VBUS_DC_SS on IN3 (solid shape): 44.45,64.89 44.45,64.7 43.36,63.61 42.75,63.61 42.63,63.74 42.63,64.02 43.78,65.17 44.17,65.17
+VCC1V8A_TBTA_LDO on TOP (solid shape): 22.17,66.23 22.61,66.23 22.96,65.87 23.68,65.87 24.39,65.16 24.39,64.92 24.31,64.84 24.14,64.84 23.87,65.11 23.77,65.33 23.55,65.43 23.53,65.45 22.79,65.45 22.53,65.71 22.03,65.71 21.9,65.83 21.9,66.21 22,66.31 22.08,66.31
+VCC_CORE on TOP (solid shape): 122.55,63.61 122.55,61.45 122.48,61.39 121.98,61.39 121.85,61.51 121.85,63.55 121.98,63.67 122.48,63.67
+VCC_CORE on BOTTOM (solid shape): outline of 547 points within 115.75,56.69 122.55,59.78
+VCC_CORE on BOTTOM (solid shape): outline of 761 points within 114.61,67.25 123.42,70.21
+VCC_CORE on IN4 (solid shape): 82.5,79.1 82.5,77.43 82.46,77.39 80.6,77.39 80.57,77.41 80.57,79.11 80.75,79.29 82.31,79.29
+VCC_CORE on IN4 (solid shape): 85.1,74.38 85.1,73.59 84.98,73.47 80.55,73.47 80.45,73.58 80.45,74.41 80.53,74.5 84.98,74.5
+VCC_CORE on IN4 (solid shape): 85.99,71.73 85.99,69.76 87.31,68.43 87.31,67.1 87.16,66.94 86.28,66.94 85.07,68.15 82.78,68.15 82.63,68.3 82.63,69.66 83.22,70.25 83.41,70.44 84.58,70.44 84.7,70.56 84.7,72.53 84.77,72.6 85.12,72.6
+VCC_CORE on IN4 (solid shape): 80.78,72.44 80.78,71.53 81.99,70.31 81.99,68.98 81.79,68.78 81.54,68.67 81.42,68.41 81.1,68.09 80.58,68.09 79.98,67.49 79.09,67.49 78.82,67.76 78.82,72.19 79.22,72.6 80.62,72.6
+VCC_CORE on TOP: 84.08,60.5 83.96,60.61 83.96,64.52 83.49,65 81.47,65 81.06,65.42 81.06,65.5 80.47,66.09 78.29,66.09 78.16,66.21 78.16,75.36 79.86,77.06 79.86,79.05 80.62,79.8 85.59,79.8 85.65,79.74 85.65,76.95 85.91,76.69 85.91,75.74 85.2,75.03 85.2,73.89 85.2,73.89 85.2,73.08 86.51,71.78 86.51,70.86 86.98,70.38 86.98,68.82 87.58,68.22 87.58,64.54 86.64,63.6 86.64,60.69 86.45,60.5
+VCC_CORE on TOP: outline of 183 points within 113.09,56.77 124.01,74.72
+VCC_CORE on BOTTOM: 78.29,66.09 78.16,66.21 78.16,74.6 78.29,74.72 78.92,74.72 78.99,74.66 78.99,74 79.18,73.8 80.19,73.8 80.45,74.06 80.45,75.99 80.64,76.18 80.64,78.98 80.89,79.23 82.16,79.23 82.51,78.88 82.51,76.33 83.3,76.33 83.33,76.36 83.33,78.51 83.47,78.66 86.16,78.66 86.29,78.53 86.29,75.87 85.08,74.66 85.08,73.2 86.49,71.79 86.49,70.65 87.43,69.71 87.43,66.2 87.39,66.16 86.85,66.16 85.02,67.99 82.65,67.99 82.44,68.2 82.16,67.93 80.45,67.93 79.68,67.17 79.68,66.59 79.18,66.09
+VCC_CORE on IN1: 115.5,66.21 122.1,66.21 122.36,65.96 122.36,63.8 122.48,63.67 122.99,63.67 123.12,63.55 123.12,58.34 122.74,57.96 107.37,57.96 104.7,60.63 91.29,60.63 90.88,61.04 90.88,63.71 91.16,63.99 91.16,65.88 90.72,66.33 80.33,66.33 79.05,67.61 79.05,77.52 79.94,78.41 79.94,80.06 81.34,81.45 94.16,81.45 99.37,76.25 99.37,66.09 99.88,65.58 105.85,65.58 105.97,65.45 109.78,65.45 110.55,66.21 110.55,66.85 110.8,67.1 113.34,67.1 114.1,67.86 114.1,68.12 114.23,68.25 114.48,68.25 114.74,67.99 114.74,66.98
+VCC_CORE on IN2: 122.12,56.75 118.93,56.75 117.72,57.96 113.59,57.96 113.09,58.47 113.09,67.74 111.56,67.74 110.42,68.88 105.97,68.88 104.83,67.74 100.51,67.74 99.12,66.34 90.23,66.34 87.94,64.05 78.8,64.05 78.16,64.69 78.16,76.56 80.83,79.23 82.54,79.23 85.91,82.6 93.02,82.6 94.92,80.69 95.43,80.69 97.08,79.04 99.75,79.04 100.13,79.42 100.94,79.42 101.32,79.07 101.71,79.42 102.42,79.42 104.32,81.33 111.52,81.33 111.62,81.31 111.72,81.33 117.34,81.33 118.73,79.94 118.74,79.94 119,79.68 121.34,79.68 123.5,77.52 123.5,71.55 123.5,71.55 123.5,69.31 122.8,68.6 122.8,67.7 123.16,67.33 123.16,57.79
+VCC_CORE on IN3: 113.47,63.8 113.47,59.1 113.85,58.72 116.9,58.72 118.6,57.02 121.98,57.02 122.1,57.15 122.1,59.23 123.37,60.5 123.37,79.42 117.4,85.39 101.15,85.39 100.3,84.54 100.3,82.38 98.79,80.88 92.98,80.88 92.61,81.24 92.61,83.27 92.15,83.74 87.3,83.74 86.54,82.98 84.64,82.98 84.38,82.72 80.45,82.72 79.94,82.22 79.94,77.26 78.92,76.25 78.92,67.61 79.18,67.36 79.56,67.36 81.62,65.29 89.18,65.29 90.23,66.34 99.12,66.34 100.51,67.74 104.83,67.74 105.97,68.88 110.42,68.88 111.56,67.74 113.3,67.74 113.38,67.65 113.38,66.83 113.15,66.59 113.15,64.12
+VCC_CORE on VCC: 114.28,57.76 113.83,58.21 113.52,58.21 113.09,58.64 113.09,65.47 114.3,66.69 114.3,66.72 114.36,66.77 114.36,67.31 113.93,67.74 111.54,67.74 110.4,68.88 105.99,68.88 104.85,67.74 100.53,67.74 99.14,66.34 90.3,66.34 90.2,66.34 88.22,64.37 82.52,64.37 80.81,66.09 78.19,66.09 78.16,74.85 78.16,79.19 78.8,79.82 78.8,87.44 83.6,92.25 86.65,92.25 87.79,93.39 96.32,93.39 96.32,86.17 97.1,85.39 117.42,85.39 123.5,79.32 123.5,69.3 122.8,68.61 122.8,67.7 123.16,67.33 123.16,58.02 122.93,57.78 122.42,57.78 122.4,57.76
+VCC_CORE on IN4: 122.86,64.94 114.94,64.94 114.84,65.05 113.47,63.67 113.47,59.1 113.85,58.72 116.9,58.72 118.8,56.82 121.98,56.82 122.1,56.94 122.1,59.23 123.37,60.5 123.37,64.44
+VCC_GT on BOTTOM (solid shape): outline of 1945 points within 74.22,46.86 110.67,69.58
+VCC_GT on IN4 (solid shape): 76.02,50.73 76.02,50.02 76.29,49.75 78.29,49.75 78.29,49.75 79.74,49.75 79.92,49.58 79.92,48.11 79.59,47.78 77.17,47.78 76.68,47.28 74.34,47.28 74.14,47.48 74.14,50.96 74.38,51.2 75.55,51.2
+VCC_GT on TOP: outline of 221 points within 74.25,46.86 111.46,75.1
+VCC_GT on IN1: 106.86,68.37 110.16,68.37 110.7,67.84 110.7,67.48 110.29,67.08 110.29,66.21 109.78,65.71 106.1,65.71 105.85,65.96 100.13,65.96 99.88,66.21 99.88,74.21 100.77,75.1 104.96,75.1 105.59,74.47 105.59,72.31 105.47,72.18 105.47,70.66 105.97,70.15 105.97,69.26
+VCC_GT on IN2: outline of 134 points within 73.99,39.17 112.65,68.37
+VCC_GT on IN3: 112.2,59.61 111.05,58.47 110.29,58.47 110.16,58.59 110.16,59.36 109.91,59.61 108.01,59.61 107.37,60.24 106.1,60.24 105.08,61.26 101.66,61.26 99.5,59.1 98.73,59.1 94.04,54.4 88.57,54.4 85.91,51.74 85.91,47.16 84.51,45.77 74.24,45.77 74.05,45.96 74.05,53.96 74.36,54.28 76,54.28 76.95,55.23 78.99,55.23 81.64,57.88 81.64,58.77 82.05,59.18 83.7,59.18 83.9,59.38 83.9,60.36 82.85,61.41 82.85,63.41 83.37,63.93 88.57,63.93 90.48,65.83 99.37,65.83 100.77,67.23 105.08,67.23 106.23,68.37 110.16,68.37 112.2,66.34
+VCC_GT on VCC: 72.17,47.42 71.68,47.9 71.68,58.74 73.59,60.65 73.59,65.22 73.95,65.58 80.59,65.58 82.31,63.86 88.42,63.86 90.41,65.83 99.35,65.83 100.74,67.23 105.06,67.23 106.21,68.37 110.19,68.37 111.33,67.23 113.72,67.23 113.85,67.1 113.85,66.95 112.58,65.68 112.58,58.59 112.19,58.21 106.21,58.21 105.72,58.7 105.72,59.97 104.3,61.39 94.69,61.39 94.56,61.26 88.34,61.26 80.19,53.11 80.19,48.92 78.69,47.42
+VCC_GT_+VCC_CORE on BOTTOM (solid shape): outline of 491 points within 110.8,67.36 115.53,69.64
+VCC_GT_+VCC_CORE on BOTTOM (solid shape): outline of 568 points within 111.31,57.07 117.09,59.74
+VCC_GT_+VCC_CORE on TOP: 112.2,72.31 112.2,69.77 111.38,68.96 111.38,68.02 111.08,67.71 111.08,67.48 111.21,67.36 111.46,67.36 111.69,67.13 111.69,65.73 112.07,65.35 112.07,62.15 111.66,61.74 111.03,61.74 110.93,61.64 110.93,59.48 111.82,58.59 111.82,57.78 111.94,57.65 112.3,57.65 112.42,57.78 112.42,58.49 112.45,58.52 113.67,58.52 113.69,58.49 113.69,57.48 113.77,57.4 114.86,57.4 114.94,57.48 114.94,58.21 115.02,58.29 115.37,58.29 115.6,58.52 115.6,58.82 115.47,58.95 113.69,58.95 113.09,59.56 113.09,61.49 112.86,61.72 112.86,63.29 113.03,63.47 113.92,63.47 114,63.55 114,64.11 113.9,64.21 113.54,64.21 113.47,64.28 113.47,65.32 113.34,65.45 112.96,65.45 112.83,65.58 112.83,67.23 112.93,67.33 113.19,67.33 115.27,69.41 115.27,72.79 112.96,75.1 110.93,75.1 110.29,74.47 110.29,74.21
+VCC_GTX on BOTTOM (solid shape): outline of 620 points within 106.29,56.82 111.43,59.74
+VCC_GTX on IN4 (solid shape): 108.08,58.75 110.08,58.75 111.23,57.6 111.23,57.06 110.98,56.82 110.72,56.82 110.01,57.53 108.94,57.53 108.64,57.22 108.64,56.92 108.44,56.71 108.08,56.71 107.7,57.1 107.11,57.1 106.08,58.13 106.08,59.39 106.23,59.54 107.29,59.54
+VCC_SA on TOP (solid shape): 100.26,89.33 100.26,88.44 100.39,88.31 102.67,88.31 102.8,88.18 102.8,85.77 102.16,85.14 97.72,85.14 96.83,86.03 96.83,88.76 97.53,89.45 100.13,89.45
+VCC_SA on BOTTOM (solid shape): 100.26,89.2 100.26,88.57 100.51,88.31 102.67,88.31 102.93,88.06 102.93,84.63 101.27,82.98 97.59,82.98 97.46,83.1 97.46,85.26 98.35,85.26 98.35,86.15 96.96,86.15 96.83,86.28 96.83,88.57 97.72,89.45 100,89.45
+VCC_SA on BOTTOM (solid shape): 127.18,59.61 127.18,58.8 127.14,58.73 127.11,58.66 127.06,58.6 127,58.58 126.79,58.51 126.71,58.32 126.68,58.24 126.61,58.21 126.41,58.21 126.34,58.24 126.31,58.32 126.05,58.58 125.8,58.32 125.77,58.24 125.7,58.21 125.53,58.21 125.42,58.32 125.41,58.38 125.4,58.42 125.4,59.04 125.47,59.24 125.4,59.44 125.4,59.61 125.53,59.74 127.06,59.74
+VCC_SA on TOP: 125.02,67.98 124.61,67.57 124.61,66.32 124.62,66.31 124.62,66.16 124.69,66.09 124.87,66.09 124.95,66.01 124.95,65.55 125.07,65.43 125.4,65.43 125.45,65.38 125.45,65 125.41,64.96 125.03,64.96 124.95,64.88 124.95,64.33 125.08,64.2 125.46,64.2 125.53,64.12 125.53,63.85 125.45,63.78 125.15,63.78 124.97,63.6 124.97,63.22 125.15,63.04 125.43,63.04 125.53,62.94 125.53,62.72 125.39,62.58 124.36,62.58 124.24,62.71 124.24,63.72 124.11,63.85 122.81,63.85 122.71,63.95 122.71,64.21 122.84,64.33 123.17,64.33 123.32,64.49 123.32,64.94 123.17,65.1 122.86,65.1 122.74,65.22 122.74,65.48 122.84,65.58 123.17,65.58 123.27,65.68 123.27,66.04 123.32,66.09 124.01,66.09 124.13,66.21 124.13,67.38 123.96,67.56 123.24,67.56 123.05,67.74 123.05,68.69 124.52,70.15 126.1,70.15 127.04,69.22 127.04,67.47 127.04,67.47 127.04,66.84 127.12,66.76 127.52,66.76 127.64,66.64 127.64,66.04 127.55,65.96 126.71,65.96 126.39,66.28 126.04,66.28 125.94,66.37 125.94,67.46 126.1,67.62 126.1,68.24 125.9,68.44 125.16,68.44 125.02,68.3
+VCC_SA on BOTTOM: 123.37,67.36 123.16,67.57 123.16,68.78 123.22,68.85 123.86,68.85 124.05,69.04 124.05,69.73 124.11,69.81 124.14,69.91 124.17,69.97 124.24,70 124.31,70.01 124.39,70.05 124.98,70.05 125.21,70.01 125.39,70.15 125.8,70.15 126.05,70 126.3,70.15 126.72,70.15 126.8,70.06 126.91,70 126.92,70 127.08,69.84 127.08,69.83 127.2,69.67 127.38,69.61 127.4,69.61 127.42,69.58 127.45,69.48 127.37,69.41 127.17,69.12 127.45,68.91 127.53,68.88 127.56,68.81 127.56,67.61 127.31,67.36
+VCC_SA on IN1: 122.74,66.21 125.28,66.21 125.79,65.71 125.79,62.66 125.53,62.4 124.64,62.4 123.12,63.93 122.74,63.93 122.61,64.05 122.61,66.09
+VCC_SA on VCC: 123.93,57.76 123.67,58.02 123.67,67.54 123.31,67.91 123.31,68.39 124.01,69.09 124.01,79.53 117.64,85.9 97.32,85.9 96.83,86.39 96.83,93.39 117.68,93.39 123.52,87.55 134.7,87.55 135.06,87.19 135.06,82.7 134.57,82.22 132.54,82.22 131.6,81.28 131.6,69.26 130.61,68.27 130.61,65.57 130.37,65.33 128.9,65.33 126.85,63.27 126.85,57.99 126.61,57.76
+VCC_SFR_OC on TOP (solid shape): outline of 592 points within 126.06,37.15 128.06,59.78
GND on TOP (solid shape): 45.65,27.61 45.65,26.72 45.14,26.21 43.62,26.21 43.49,26.34 43.49,27.73 43.62,27.86 45.39,27.86
GND on TOP (solid shape): 68.36,79.9 68.36,76.65 67.44,75.74 64.24,75.74 62.89,77.09 62.89,79.93 63.58,80.62 67.64,80.62
GND on TOP (solid shape): 84.44,33.62 84.44,30.5 84.22,30.28 80.18,30.28 79.97,30.49 79.97,33.33 80.59,33.96 84.11,33.96
GND on TOP (solid shape): 128.77,109.39 128.77,104.38 128.71,104.31 127.37,104.31 127.31,104.38 127.31,109.39 127.37,109.46 128.71,109.46
GND on TOP (solid shape): 167.37,101.43 167.37,98.19 167.18,98 166.16,98 165.92,98.24 165.92,101.36 166.15,101.58 167.21,101.58
GND on TOP (solid shape): 169.22,107.83 169.22,106.85 169.09,106.73 167.7,106.73 167.51,106.91 167.51,107.74 167.72,107.95 169.1,107.95
GND on TOP (solid shape): 172.8,54.43 172.8,52.4 172.52,52.12 171.63,52.12 171.45,52.29 171.45,54.43 171.63,54.61 172.62,54.61
GND on TOP (solid shape): 195.67,27.81 195.67,26.66 195.42,26.41 190.91,26.41 190.68,26.64 190.68,27.9 190.99,28.2 195.27,28.2
GND on TOP (solid shape): 219.23,17.34 219.23,16.5 218.12,15.39 217.48,15.39 217.38,15.49 217.38,16.46 218.42,17.5 219.08,17.5
GND on TOP (solid shape): 246.26,30.65 246.26,28.22 244.96,26.92 241.91,26.92 240.87,27.96 240.87,30.76 241.69,31.57 245.34,31.57
GND on TOP (solid shape): 279.48,22.94 279.48,20.52 279.25,20.29 277.54,20.29 277.47,20.37 277.47,22.98 277.61,23.12 279.29,23.12
GND on TOP (solid shape): 283.41,28.62 283.41,27.16 283.2,26.94 280.6,26.94 280.33,27.21 280.33,28.85 280.37,28.89 283.14,28.89
GND on TOP (solid shape): 175.57,109.9 175.57,108.89 174.27,107.59 173.02,107.59 172.75,107.86 172.75,109.57 173.21,110.03 175.44,110.03
GND on TOP (solid shape): 178.62,50.87 178.62,49.45 178.49,49.32 175.19,49.32 174.43,50.08 174.43,50.97 174.62,51.16 178.33,51.16
GND on TOP (solid shape): 181.59,48.33 181.59,47.13 181.33,46.86 179.04,46.86 178.87,47.04 178.87,48.56 179,48.69 181.23,48.69
GND on TOP (solid shape): 64.52,110.58 64.52,104.59 64.25,104.32 63.35,104.32 63.22,104.45 63.22,110.6 63.41,110.79 64.31,110.79
GND on TOP (solid shape): 65.27,100.96 65.27,98.6 65.18,98.51 63.98,98.51 63.77,98.71 63.77,99.78 63.78,99.78 63.78,101.02 63.89,101.12 65.11,101.12
GND on TOP (solid shape): 80.26,75.16 80.26,74.05 80.17,73.96 79.3,73.96 79.18,74.08 79.18,75.1 79.29,75.22 80.2,75.22
GND on TOP (solid shape): 162.12,54 162.72,54 162.81,53.91 162.81,52.84 162.63,52.66 162.13,52.66 161.2,53.6 161.2,54.13 161.33,54.26 161.85,54.26
GND on TOP (solid shape): 249.86,7.02 249.86,4.83 249.73,4.69 247.59,4.69 247.16,5.13 247.16,6.83 247.62,7.29 249.6,7.29
GND on TOP (solid shape): 269.85,7.19 269.85,5.27 269.61,5.04 265.04,5.04 264.85,5.23 264.85,7.13 265.01,7.29 269.75,7.29
GND on TOP (solid shape): 276.99,7.14 276.99,5.84 276.65,5.51 276.65,5.19 276.6,5.13 274.85,5.13 274.75,5.24 274.75,7.17 274.92,7.34 276.78,7.34
GND on TOP (solid shape): 279.2,20.01 279.2,18.54 278.85,18.18 277.8,18.18 277.78,18.21 277.78,19.96 277.98,20.16 279.05,20.16
GND on TOP (solid shape): 54.28,48.69 54.28,47.8 53.9,47.42 52.76,47.42 52.59,47.58 52.59,48.67 52.73,48.81 54.16,48.81
GND on TOP (solid shape): 177.12,98.19 177.21,98.19 177.35,98.05 177.35,97.1 177.09,96.85 175.7,96.85 175.47,97.07 175.47,98.12 175.54,98.19 177.12,98.19
GND on TOP (solid shape): 62.07,79.77 62.07,78.02 61.88,77.82 61.15,77.82 61.06,77.91 61.06,79.23 60.91,79.38 58.61,79.38 58.55,79.45 58.55,79.95 58.87,80.26 61.58,80.26
GND on TOP (solid shape): 89.91,53.13 92.51,53.13 94.48,51.16 94.48,48.31 92.64,46.47 89.72,46.47 86.16,50.02 86.16,54.4 86.22,54.47 88.57,54.47
GND on TOP (solid shape): 237.52,23.42 237.52,20.77 237.43,20.68 235.15,20.68 235.02,20.56 235.02,19.66 234.94,19.58 234.82,19.58 234.75,19.65 234.75,23.42 234.8,23.47 237.47,23.47
GND on TOP (solid shape): 267.58,68.25 267.58,66.61 267.11,66.14 264.18,66.14 264.12,66.2 264.12,67.56 264.21,67.65 265.13,67.65 265.38,67.9 266,67.9 266.43,68.33 267.51,68.33
GND on TOP (solid shape): 109.15,67.48 109.15,66.19 109.1,66.14 109.1,65.76 108.99,65.64 108.25,65.64 108.11,65.78 108.11,67.46 108.49,67.84 108.79,67.84
GND on TOP (solid shape): 201.93,25.49 201.93,24.87 201.34,24.28 200.19,24.28 200.09,24.37 200.09,24.55 200.09,24.55 200.09,25.3 200.17,25.39 200.5,25.39 200.75,25.63 201.79,25.63
GND on TOP (solid shape): 244.18,15.12 244.18,14.25 244.14,14.21 242.95,14.21 242.78,14.05 242.78,13.28 242.69,13.2 242.54,13.2 242.41,13.32 242.41,14.98 242.6,15.17 244.13,15.17
GND on TOP (solid shape): 29.21,56.47 29.21,55.7 29.25,55.66 29.25,54.96 29.28,54.93 29.28,53.19 29.2,53.11 28.67,53.11 28.06,53.72 28.06,54.67 28.53,55.15 28.53,56.43 28.65,56.55 29.13,56.55
GND on TOP (solid shape): 33.1,46.43 33.1,42.04 32.97,41.91 29.72,41.91 29.6,42.03 29.6,42.45 28.89,43.15 28.89,45.14 29.62,45.87 29.62,46.02 29.7,46.1 32.03,46.1 32.44,46.5 33.02,46.5
GND on TOP (solid shape): 35.21,21.66 35.08,21.53 34.14,21.53 32.64,20.04 29.04,20.04 28.02,21.05 28,21.05 27.79,21.25 27.79,22.25 27.97,22.42 35.21,22.42
GND on TOP (solid shape): 130.55,64.56 130.55,64.28 130.55,64.25 130.8,63.99 130.8,63.29 130.74,63.23 130.23,63.23 130.17,63.29 130.17,64.12 130.04,64.25 130.04,64.63 130.1,64.69 130.42,64.69
GND on TOP (solid shape): 163.83,109.01 163.83,108.23 163.63,108.02 163.63,107.59 163.43,107.39 160.84,107.39 160,108.22 160,109.7 160.1,109.79 163.06,109.79
GND on TOP (solid shape): 222.23,12.93 222.23,12.24 222.04,11.95 221.87,11.65 221.6,11.38 221.43,11.38 220.76,12.06 220.76,13.12 220.96,13.32 221.84,13.32
GND on TOP (solid shape): 91.75,83.61 91.75,82.52 92.16,82.11 92.16,81.91 91.9,81.66 89.41,81.66 88.75,82.32 88.75,83.51 88.98,83.74 91.62,83.74
GND on TOP (solid shape): 153.06,30.09 153.85,29.29 154.49,29.29 154.71,29.07 154.71,25.99 154.49,25.77 148.81,25.77 148.5,26.08 148.5,28.85 148.86,29.21 148.86,30.39 148.97,30.5 152.64,30.5
GND on TOP (solid shape): 210.84,15.96 211.55,15.96 211.59,15.92 211.59,15.29 211.85,15.03 211.85,10.59 211.62,10.36 209.51,10.36 209.34,10.53 209.34,13.15 208.12,14.37 208.12,15.54 208.55,15.97 210.83,15.97
GND on TOP (solid shape): 8.87,69.41 10.88,69.41 11.08,69.21 11.08,68.8 11.03,68.75 10.19,68.75 10.03,68.59 8.25,68.59 7.65,69.19 7.65,69.48 7.74,69.57 8.72,69.57
GND on TOP (solid shape): 27.11,26.97 27.11,25.13 26.96,24.98 20.95,24.98 20.86,25.07 20.86,25.67 20.94,25.75 22.35,25.75 22.66,26.06 23.39,26.06 23.65,26.32 23.65,27.23 23.73,27.3 26.78,27.3
GND on TOP (solid shape): 38,53.9 38,49.15 37.84,48.99 35.76,48.99 35.71,49.02 35.21,49.52 35.21,53.85 35.37,54.01 37.89,54.01
GND on TOP (solid shape): 71.33,105.2 71.33,105.17 71.33,105.16 71.3,105.01 71.33,104.86 71.33,104.85 71.33,104.09 71.02,103.77 70.1,103.77 69.81,104.07 69.81,105.25 70.06,105.51 71.03,105.51
GND on TOP (solid shape): 106.77,67.23 106.77,66.79 106.85,66.71 107.24,66.71 107.39,66.56 107.39,65.77 107.28,65.65 106.67,65.65 106.62,65.7 106.62,66.07 106.47,66.22 106.2,66.22 106.05,66.38 106.05,67.04 105.83,67.26 105.83,67.69 105.97,67.84 106.17,67.84
GND on TOP (solid shape): 282.5,35.28 283.01,35.28 283.17,35.11 283.17,34.17 283.02,34.01 282.53,34.01 282.11,33.59 282.11,31.82 281.94,31.65 280.84,31.65 280.78,31.65 280.71,31.72 280.71,35.33 280.86,35.48 282.3,35.48
GND on TOP (solid shape): 92.64,88.95 92.64,88.41 92.56,88.17 92.64,87.94 92.64,86.79 92.38,86.53 91.5,86.53 90.61,87.42 90.61,88.95 90.86,89.2 92.38,89.2
GND on TOP (solid shape): 174.07,101.03 174.07,98.01 173.97,97.91 172.54,97.91 172.42,97.79 172.42,97.1 171.43,96.11 171.43,94.68 171.05,94.31 169.89,94.31 169.78,94.42 169.78,97.53 170.73,98.48 170.73,99.55 169.98,100.29 169.39,100.29 169.26,100.43 169.26,101.39 169.38,101.51 173.59,101.51
GND on TOP (solid shape): 234.97,37.15 236.88,37.15 236.92,37.12 236.92,36.22 236.9,36.21 235.71,36.21 235.55,36.04 235.55,36.03 235.54,36.02 235.54,35.22 235.47,35.16 235.22,35.16 235.13,35.24 235.13,35.59 235.01,35.7 233.93,35.7 233.69,35.94 233.69,37.28 233.91,37.49 234.63,37.49
GND on TOP (solid shape): 218.7,36.93 218.7,36.44 218.39,36.13 217.44,36.13 217.31,36 217.31,35.44 217.17,35.31 216.78,35.31 216.37,35.72 214.24,35.72 214.02,35.5 214.02,35.13 214.33,34.81 214.33,32.31 214.32,32.3 213.45,32.3 213.45,32.3 213.45,36.81 213.72,37.08 218.55,37.08
GND on TOP (solid shape): 58.93,59.61 60.35,59.61 61.65,58.31 61.65,55.67 61.52,55.55 60.16,55.55 59.9,55.81 59.9,56.28 59.75,56.43 59.75,57.96 59.62,58.09 58.75,58.09 58.53,57.86 58.02,57.86 57.76,58.11 57.76,59.31 58.3,59.84 58.7,59.84
GND on TOP (solid shape): 68.47,98.95 68.47,96.14 68.4,96.06 67.78,96.06 67.35,96.49 67.15,96.49 66.46,97.18 66.46,98.07 66.96,98.56 66.96,98.76 67.16,98.96 67.22,98.96 67.23,98.95 67.43,98.93 67.61,99.02 68.41,99.02
GND on TOP (solid shape): 261.26,10.31 261.26,9.25 261.53,8.98 263.23,8.98 263.47,8.74 263.47,7.88 263.32,7.73 258.62,7.73 258.48,7.88 258.48,8.84 258.95,9.31 258.95,10.31 259.04,10.4 259.17,10.4 259.26,10.31 259.26,9.45 259.41,9.29 260.31,9.29 260.43,9.41 260.43,10.3 260.56,10.42 261.15,10.42
GND on TOP (solid shape): 246.24,10.41 246.24,9.3 246.39,9.14 246.96,9.14 247.08,9.27 248.29,9.27 248.47,9.09 248.47,8.43 248.35,8.31 246.49,8.31 246.39,8.4 245.52,8.4 245.47,8.46 245.47,9.09 245.53,9.15 245.57,9.22 245.62,9.26 245.62,10.36 245.72,10.46 246.19,10.46
GND on TOP (solid shape): 13.46,64.66 14.19,64.66 14.28,64.56 14.28,63.99 15.12,63.15 15.12,61.02 14.53,60.43 14.07,60.43 13.84,60.21 13.84,59.19 13.45,58.79 13.45,57.7 13.29,57.54 12.53,57.54 12.4,57.67 12.4,60.1 12.1,60.39 12.1,63.56 12.26,63.72 12.26,64.64 12.34,64.72 13.4,64.72
GND on TOP (solid shape): 154.11,55.8 154.11,55.39 154.39,55.11 155.81,55.11 155.96,55.27 156.29,55.27 156.44,55.11 156.44,54.33 156.29,54.17 156.09,54.17 155.96,54.3 155.85,54.3 155.84,54.31 154.45,54.31 154.16,54.6 154.16,54.67 153.68,55.15 153.24,55.15 153.08,55.32 153.08,55.9 153.15,55.98 153.93,55.98
GND on TOP (solid shape): 155.98,107.89 155.98,102.99 153.07,100.08 148.97,100.08 146.32,102.72 146.32,105.24 145.09,106.47 144.07,106.47 143.69,106.09 142.3,106.09 141.91,106.47 141.53,106.47 141.41,106.35 141.41,105.58 141.28,105.46 140.14,105.46 140.01,105.58 140.01,106.47 140.26,106.73 141.91,106.73 142.04,106.85 142.04,107.23 142.3,107.49 143.69,107.49 143.95,107.23 144.39,107.23 145.15,108 145.15,109.46 145.53,109.84 154.04,109.84
GND on TOP (solid shape): 217.64,21.52 217.64,18.12 217.53,18 216.27,18 216.04,18.23 216.04,18.38 216.5,19.25 216.04,20.12 216.04,21.16 216.41,21.54 217.63,21.54
GND on TOP (solid shape): 253.71,35.94 253.71,35.6 254.25,35.06 254.29,34.58 254.78,34.53 255.02,34.29 255.76,34.29 256.59,33.45 257.1,33.45 257.2,33.35 257.2,32.95 257.12,32.86 253.39,32.86 253.36,32.9 253.36,34.96 252.71,35.61 252.71,36.22 252.89,36.39 253.25,36.39
GND on TOP (solid shape): 265.94,35.26 265.94,33.55 265.84,33.45 265.51,33.45 265.41,33.55 265.41,33.57 265.22,33.93 264.81,33.92 264.8,33.91 264.67,33.91 264.66,33.92 264.44,33.98 264.22,33.91 264.21,33.91 264.02,34.1 264.02,35.27 264.14,35.4 265.8,35.4
GND on TOP (solid shape): 43.36,48.59 43.36,47.7 42.98,47.32 42.98,46.11 43.21,45.88 43.21,43.61 43.18,43.6 43.1,43.57 43.03,43.53 42.88,43.26 42.97,42.98 42.98,42.97 42.99,42.93 42.98,42.9 42.97,42.89 42.91,42.79 42.88,42.67 42.95,42.42 43.17,42.27 43.21,42.26 43.21,40.82 43.11,40.72 43.11,39.67 43.04,39.6 41.66,39.6 40.95,40.31 40.95,48.56 41.08,48.69 43.26,48.69
GND on TOP (solid shape): 148.18,59.53 148.18,58.52 148.02,58.36 147.68,58.52 147.37,58.31 146.05,58.31 145.65,57.91 145.2,57.91 144.93,58.05 144.65,57.95 144.61,57.94 144.32,58.05 144.06,57.95 144.03,57.92 143.88,58.07 143.88,58.57 144.32,59.01 145.68,59.01 145.94,59.28 146.86,59.28 147.11,59.53 147.11,60.03 147.14,60.06 147.65,60.06
GND on TOP (solid shape): 287.58,16.65 288.18,15.95 288.96,16.45 290.06,16.45 300.1,16.45 300.66,16.21 300.9,15.65 300.9,14.27 282.63,14.27 281.49,13.13 278.95,13.13 277.6,14.47 277.6,16.33 279.91,18.63 287.58,18.63
GND on TOP (solid shape): 41.85,102.44 41.85,102.44 41.85,100.6 40.88,98.27 38.55,97.3 36.63,97.3 36.2,97.3 36.2,102.3 36.32,102.71 36.63,103.01 36.81,103.07 37,103.1 41.85,103.1
GND on TOP (solid shape): 186.87,80.36 187.91,74.75 187.99,74.3 185.55,73.85 181.7,76.53 184.41,80.36 186.8,80.75
GND on TOP (solid shape): 91.65,77.49 92.26,77.49 94.39,75.36 94.39,72.21 90.96,68.78 90.96,66.67 90.96,66.66 90.94,66.53 90.96,66.4 90.96,66.39 90.96,66.09 90.9,66.09 90.89,66.09 90.52,65.93 90.58,65.53 90.61,65.46 90.59,65.39 90.52,65.26 90.51,65.11 90.53,64.91 90.67,64.76 90.67,64.56 91.4,63.82 92.87,63.82 93.04,63.65 93.04,60.85 92.84,60.64 89.34,60.64 88.92,61.06 88.92,63.86 87.84,64.95 87.84,68.73 87.35,69.22 87.35,70.37 86.8,70.92 86.8,76 88.32,77.52 91.62,77.52
GND on TOP (solid shape): 197.75,15.83 197.75,14.07 197.56,13.88 195.78,13.88 195.52,13.62 194.92,13.62 194.75,13.8 194.75,14.64 195.01,14.64 195.02,14.59 195.03,14.54 195.05,14.48 195.08,14.44 195.12,14.39 195.16,14.36 195.2,14.33 195.25,14.3 195.31,14.29 195.36,14.28 195.42,14.28 195.47,14.29 195.53,14.3 195.58,14.33 195.62,14.36 195.67,14.39 195.7,14.44 195.73,14.48 195.75,14.54 195.77,14.59 195.77,14.64 195.77,14.7 195.76,14.76 195.74,14.81 195.72,14.86 195.68,14.9 195.65,14.94 195.6,14.98 195.55,15 195.5,15.02 195.45,15.04 195.39,15.04 195.34,15.04 195.28,15.02 195.23,15 195.18,14.98 195.14,14.94 195.1,14.9 195.06,14.86 195.04,14.81 195.02,14.76 195.01,14.7 195.01,14.64 194.75,14.64 194.76,14.68 194.76,14.73 194.76,14.78 194.76,14.84 194.74,14.89 194.72,14.94 194.69,14.98 194.66,15.02 194.62,15.06 194.57,15.09 194.53,15.11 194.48,15.13 194.42,15.14 194.37,15.14 194.32,15.14 194.27,15.13 194.24,15.13 194.22,15.14 194.19,15.16 194.17,15.18 194.16,15.21 194.16,15.23 194.16,15.77 194.37,15.97 195.56,15.97 197.61,15.97
GND on TOP (solid shape): 247.75,62.9 251.05,59.6 247.75,56.3 246.66,56.3 245.23,56.3 245.25,56.43 245.25,56.57 245.25,56.75 245.25,56.82 245.26,56.88 245.26,56.9 246.66,62.55 246.69,62.73 246.76,62.9
GND on TOP (solid shape): outline of 85 points within 52.76,52.93 58.09,57.35
GND on TOP (solid shape): 132.48,59.36 132.63,59.15 132.89,59.11 132.97,59.03 132.98,58.8 133.15,58.65 133.15,58.59 132.64,58.09 132.64,57.83 132.52,57.7 132.26,57.7 132.14,57.83 132.14,58.13 132.15,58.17 132.18,58.18 132.41,58.71 131.84,58.63 131.83,58.59 130.61,58.59 130.61,58.85 130.74,58.97 130.99,58.97 131.12,59.1 131.12,59.16 131.16,59.22 131.18,59.29 131.2,59.31 131.83,59.31 132.15,59.09 132.46,59.32 132.47,59.36
GND on TOP (solid shape): 288.75,68.66 289.2,68.11 289.82,68.45 300.1,68.45 300.66,68.22 300.9,67.66 300.9,64.3 300.66,63.74 300.1,63.5 297.2,63.5 297.2,63.2 297.11,62.99 296.9,62.9 296.2,62.9 296.2,61.7 295.96,61.14 295.4,60.9 294.75,60.9 294.62,60.89 294.48,60.85 294.13,60.54 294.06,60.07 293.6,60.07 291.49,62.18 287.13,62.18 286.7,62.6 286.7,64.18 285.68,65.2 285.06,65.2 284.94,65.22 284.82,65.2 281.98,65.2 281.41,65.77 281.41,67.69 282.63,68.91 288.75,68.91
GND on TOP (solid shape): 17.86,39.95 17.86,37.11 17.28,36.52 17.28,31.72 16.51,30.96 13.52,30.96 13.52,32.5 12.94,33.19 12.15,32.74 12.14,32.7 1,32.7 0.44,32.94 0.2,33.5 0.2,34.6 0.44,35.16 1,35.4 1.5,35.4 2,35.6 2.2,36.1 2.2,37.1 2,37.6 1.5,37.8 1,37.8 0.44,38.04 0.2,38.6 0.2,39.45 0.44,40.01 1,40.25 9.5,40.25 10.19,40.83 9.74,41.61 9.7,41.62 9.7,41.98 15.83,41.98
GND on TOP (solid shape): 294.55,45.23 294.55,44.87 294.05,44.1 294.75,43.5 295.4,43.5 295.96,43.26 296.2,42.7 296.2,41.5 296.9,41.5 297.02,41.47 297.12,41.4 297.18,41.31 297.2,41.2 297.2,40.9 300.1,40.9 300.66,40.66 300.9,40.1 300.9,33.55 300.66,32.99 300.1,32.75 299.8,32.75 299.3,32.55 299.1,32.05 299.1,30.75 299.01,30.54 298.8,30.45 294.71,30.45 288.96,30.45 288.95,30.49 288.16,30.94 287.58,30.25 287.58,28.57 284.33,28.57 283.54,29.36 283.54,31.21 284.38,32.05 284.38,36.17 284.38,36.17 284.38,38.45 286.8,40.87 290.98,40.87 291.91,41.8 291.91,45.8 293.01,46.9 294.55,46.9
GND on TOP (solid shape): 123.47,45.19 123.47,44.94 123.46,44.91 123.45,44.88 123.39,44.84 123.36,44.86 122.93,44.95 122.69,44.58 122.71,44.43 122.79,44.3 122.81,44.27 122.82,44.24 122.72,44.1 122.69,43.93 122.89,43.57 123.31,43.6 123.37,43.62 123.44,43.59 123.46,43.56 123.47,43.52 123.47,43.09 123.46,43.04 123.42,43.01 123.36,42.99 123.31,43.01 122.91,43.03 122.71,42.68 122.94,42.32 123.36,42.4 123.4,42.4 123.43,42.38 123.46,42.34 123.47,42.3 123.47,41.77 123.45,41.71 123.35,41.67 123.31,41.69 122.71,41.38 123.31,41.06 123.35,41.08 123.45,41.04 123.47,40.98 123.47,38.1 123.19,37.82 122.13,37.82 121.87,38.08 121.87,44.58 122.05,44.75 122.73,45.44 123.21,45.44
GND on TOP (solid shape): outline of 140 points within 104.27,59 111.92,65.48
GND on TOP (solid shape): 7.7,67.74 9.48,67.74 10.05,67.17 10.05,66.59 10.05,66.53 10.04,66.52 10.03,66.14 10.35,65.93 10.37,65.93 11.84,64.46 11.84,60.83 11.64,60.63 10.24,60.63 9.78,60.17 9.78,57.73 10.37,57.15 12.2,57.15 12.53,56.82 12.53,54.86 12.06,54.4 9.7,54.4 9.7,54.68 9.74,54.69 10.19,55.47 9.5,56.05 1,56.05 0.44,56.29 0.2,56.85 0.2,57.78 0.21,57.91 0.25,58.03 0.23,58.03 0.48,58.42 0.89,58.6 1.5,59.24 1,59.97 1,62.93 1.5,63.66 0.89,64.3 0.4,64.56 0.2,65.09 0.2,65.78 0.44,66.34 1,66.58 4.13,66.58 4.9,66.08 5.5,66.78 5.5,68.22 7.21,68.22
GND on TOP (solid shape): outline of 203 points within 120.02,58.97 129.11,68.31
GND on TOP (solid shape): outline of 124 points within 25.43,60.06 29.97,63.59
GND on TOP (solid shape): outline of 102 points within 115.51,59.05 118.42,67.89
GND on TOP (solid shape): outline of 432 points within 0.2,0.2 277.68,20.24
GND on TOP (solid shape): outline of 1611 points within 121.21,10.16 153.55,23.85
GND on TOP (solid shape): outline of 1767 points within 49.62,12.04 72.98,20.01
GND on TOP (solid shape): outline of 1804 points within 91.69,10.16 114.11,19.8
GND on TOP (solid shape): outline of 1959 points within 170.98,10.16 193.97,20.02
GND on TOP (solid shape): outline of 2742 points within 0.2,45.14 300.9,112.9
GND on BOTTOM (solid shape): 45.65,27.54 45.65,26.72 45.14,26.21 43.71,26.21 43.61,26.31 43.61,27.73 43.74,27.86 45.33,27.86
GND on BOTTOM (solid shape): 169.24,107.79 169.24,106.59 169.17,106.52 167.73,106.52 167.5,106.74 167.5,107.74 167.68,107.92 169.12,107.92
GND on BOTTOM (solid shape): 171.37,104.21 171.37,103.27 171.25,103.15 170.07,103.15 169.96,103.27 169.96,104.17 170.08,104.29 171.29,104.29
GND on BOTTOM (solid shape): 205.95,11.65 205.95,10.48 205.83,10.35 203.45,10.35 203.35,10.46 203.35,12.14 203.68,12.47 205.14,12.47
GND on BOTTOM (solid shape): 218.07,12.52 218.07,10.67 217.84,10.44 215.71,10.44 215.41,10.73 215.41,12.46 215.59,12.64 217.95,12.64
GND on BOTTOM (solid shape): 161.03,56.01 161.03,55.59 160.84,55.4 159.3,55.4 159.07,55.63 159.07,56.97 159.23,57.13 159.9,57.13
GND on BOTTOM (solid shape): 178.24,97.84 178.24,97.07 178.01,96.85 175.52,96.85 175.39,96.97 175.39,98.09 175.49,98.19 177.88,98.19
GND on BOTTOM (solid shape): 128.77,110.35 128.77,104.38 128.71,104.31 127.44,104.31 127.31,104.44 127.31,110.28 127.56,110.54 128.58,110.54
GND on BOTTOM (solid shape): 136.64,27.09 136.64,24.93 136.46,24.74 130.34,24.74 129.35,25.73 129.35,30 129.73,30.38 133.35,30.38
GND on BOTTOM (solid shape): 166.21,104.19 166.21,102.1 166.03,101.92 164.95,101.92 164.8,102.07 164.8,104.27 164.89,104.36 166.04,104.36
GND on BOTTOM (solid shape): 172.87,54.29 172.87,52.3 172.74,52.18 171.48,52.18 171.35,52.32 171.35,54.37 171.49,54.51 172.64,54.51
GND on BOTTOM (solid shape): 54.34,48.71 54.34,47.85 53.9,47.42 52.86,47.42 52.57,47.7 52.57,48.76 52.66,48.85 54.2,48.85
GND on BOTTOM (solid shape): 168.92,71.95 168.92,70.85 167.7,69.63 166.73,69.63 165.03,71.33 165.03,72.44 165.28,72.69 167.35,72.69 167.47,72.82 168.05,72.82
GND on BOTTOM (solid shape): 80.26,75.17 80.26,74.06 80.16,73.96 79.26,73.96 79.18,74.05 79.18,75.04 79.34,75.2 80.23,75.2
GND on BOTTOM (solid shape): 91.05,54.59 94.48,51.16 94.48,48.37 92.51,46.4 89.4,46.4 86.22,49.58 86.22,54.4 86.29,54.47 89.4,54.47 90.16,55.23 90.16,56.43 91.05,56.43
GND on BOTTOM (solid shape): 125.92,96.67 125.92,92.37 125.59,92.04 121.18,92.04 120.85,92.37 120.85,94.2 121.03,94.37 123.01,94.37 123.57,94.94 123.57,96.77 123.81,97.02 125.57,97.02
GND on BOTTOM (solid shape): 183.32,93.39 183.32,90.6 183.19,90.47 180.65,90.47 180.27,90.85 180.27,91.74 181.54,93.01 181.54,93.39 181.67,93.52 183.19,93.52
GND on BOTTOM (solid shape): 175.54,110.03 175.54,109.19 175.26,108.91 173.77,108.91 173.03,109.65 172.78,109.65 172.65,109.77 172.65,110.03 172.78,110.16 175.42,110.16
GND on BOTTOM (solid shape): 282.38,23.16 282.38,22.09 281.92,21.64 279.81,21.64 279.33,21.15 279.33,20.58 279.24,20.49 279.24,20.14 278.91,19.81 277.91,19.81 277.55,20.16 277.55,22.99 278.08,23.52 282.02,23.52
GND on BOTTOM (solid shape): 167.27,101.47 167.27,98.14 167.12,97.99 166.11,97.99 165.9,98.19 165.9,100.89 166.05,101.03 166.3,101.03 166.88,101.61 167.14,101.61
GND on BOTTOM (solid shape): 258.5,79.29 258.5,78.6 258.37,78.47 256.21,78.47 255.96,78.22 254.56,78.22 253.61,77.26 251.9,77.26 251.71,77.45 251.71,78.66 252.47,79.42 258.37,79.42
GND on BOTTOM (solid shape): 132.48,87.66 132.48,86.43 132.11,86.05 131.11,86.05 130.74,85.68 130.74,84.86 130.64,84.75 130.2,84.75 130.13,84.82 130.13,85.91 129.85,86.19 129.85,87.18 130.49,87.83 132.31,87.83
GND on BOTTOM (solid shape): 65.72,88.54 65.72,85.41 66.28,84.86 67.87,84.86 68.13,84.6 68.13,82.85 67.75,82.47 66.92,82.47 66.71,82.27 66.71,81.08 68.18,79.61 68.18,76.89 67.05,75.77 63.68,75.77 62.48,76.97 62.48,88.41 62.73,88.66 65.6,88.66
GND on BOTTOM (solid shape): 93.91,79.17 93.91,76.81 94.39,76.32 94.39,70.13 92.5,68.23 92.5,66.76 92.04,66.3 88.55,66.3 88.26,66.59 88.26,69.37 86.8,70.83 86.8,75.43 90.66,79.29 93.79,79.29
GND on BOTTOM (solid shape): 246.03,7.85 246.03,6.56 246.72,5.86 246.72,2.04 246.46,1.79 245.59,1.79 245.57,1.78 244.11,1.78 243.96,1.92 243.96,3.88 244.18,4.09 245.17,4.09 245.45,4.38 245.45,6.23 245.27,6.41 244.24,6.41 244.13,6.52 244.13,7.86 244.18,7.9 245.97,7.9
GND on BOTTOM (solid shape): 70.67,69.39 71.58,69.39 71.63,69.34 71.63,68.78 71.54,68.69 70.91,68.69 70.79,68.57 70.79,65.2 70.67,65.07 69.4,65.07 69.3,65.17 68.71,65.17 68.59,65.05 65.06,65.05 64.95,65.16 64.95,66.32 65.08,66.46 65.08,66.48 65.84,67.24 65.84,69.13 66.1,69.39 70.67,69.39
GND on BOTTOM (solid shape): 163.58,109.27 163.58,107.57 163.43,107.41 161.19,107.41 160.91,107.14 160.91,106.14 161.28,105.77 161.28,104.64 160.91,104.28 160.91,103.28 161.22,102.97 161.22,102.74 161.06,102.58 160.93,102.58 160.63,102.88 160.63,104.24 160.18,104.69 160.18,107.21 159.94,107.44 159.94,109.86 160.03,109.95 162.9,109.95
GND on BOTTOM (solid shape): 51.63,30.05 51.63,27.57 51.62,27.48 51.63,27.38 51.73,27.21 51.9,27.11 52.41,26.6 52.41,25.33 52.12,25.03 48.44,25.03 47.94,25.53 47.94,30.16 48.01,30.23 51.45,30.23
GND on BOTTOM (solid shape): 109.33,111.33 111.86,111.33 112.02,111.17 112.4,110.8 112.87,110.57 113.42,110.01 113.42,109.59 113.21,109.38 112.13,109.38 111.52,109.99 110.2,109.99 109.71,109.51 106.9,109.51 106.7,109.71 106.7,111.17 106.87,111.34 109.32,111.34
GND on BOTTOM (solid shape): 210.49,40.31 210.77,40.18 211.06,40.31 212.27,40.31 212.32,40.26 212.32,38.98 211.68,38.33 208.68,38.33 208.66,38.35 208.12,38.35 207.72,38.74 207.13,38.74 206.84,39.04 206.84,39.9 207.25,40.31
GND on BOTTOM (solid shape): 115.21,13.96 115.27,13.86 115.27,12.9 115.09,12.72 115.09,11.01 114.98,10.9 114.85,10.9 114.76,10.99 114.76,12.66 114.58,12.84 114.58,13.79 114.66,13.88 114.69,13.86 114.91,13.83 115.09,13.93
GND on BOTTOM (solid shape): 257.1,7.9 257.11,7.87 257.11,7.82 257.11,6.53 258.17,5.47 258.17,2.53 257.54,1.9 253.75,1.9 253.47,2.18 253.47,4.29 254.17,4.99 254.17,6.06 254.18,6.14 254.17,6.27 254.26,6.35 254.65,6.35 254.75,6.26 254.75,5.8 254.88,5.67 255.56,5.67 255.75,5.86 255.75,7.88 255.79,7.92 257.08,7.92
GND on BOTTOM (solid shape): 176.1,51.3 176.1,49.65 176.05,49.6 175.44,49.6 175.1,49.26 175.1,48.52 175.02,48.44 174.61,48.44 174.38,48.21 174.38,47.82 174.6,47.6 176.64,47.6 177.05,48.01 177.05,48.55 177.17,48.68 180.3,48.68 180.31,48.68 180.4,48.68 180.55,48.52 180.55,47.3 179.77,46.53 173.51,46.53 173.18,46.86 173.18,48.23 173.74,48.79 173.74,49.27 173.82,49.35 174.07,49.35 174.34,49.62 174.33,49.63 174.33,51.27 174.38,51.32 176.08,51.32
GND on BOTTOM (solid shape): 155.29,108.59 155.29,106.84 155.6,106.53 155.6,102.79 152.89,100.08 148.97,100.08 146.36,102.69 146.36,103.17 145.6,103.93 145.6,105.96 145.09,106.47 144.01,106.47 143.63,106.09 142.36,106.09 141.98,106.47 140.77,106.47 140.52,106.22 140.52,105.58 140.39,105.46 140.14,105.46 140.01,105.58 140.01,106.47 140.26,106.73 141.85,106.73 141.98,106.85 141.98,107.3 142.22,107.54 143.64,107.54 144.01,107.17 145.03,107.17 145.15,107.3 145.15,109.46 145.53,109.84 147.12,109.84 147.25,109.97 153.91,109.97
GND on BOTTOM (solid shape): 112.7,14.1 112.67,14.07 112.67,13.62 113.11,13.58 113.22,13.59 113.27,13.49 113.27,12.9 113.09,12.71 113.09,11.02 112.97,10.9 112.89,10.9 112.76,11.03 112.76,12.65 112.32,13.1 112.32,13.98 112.51,14.17 112.64,14.17
GND on BOTTOM (solid shape): 63.9,63.6 63.9,63.06 63.83,62.85 63.9,62.64 63.9,62.52 64.06,62.35 64.88,62.35 65.09,62.14 65.09,60.63 64.6,60.13 62.42,60.13 62.2,59.9 62.2,58.28 61.76,57.84 60.92,57.84 60.6,57.52 60.6,56.1 60.31,55.81 59.91,55.81 59.02,56.7 59.02,57.28 58.48,57.83 58.22,57.83 57.83,58.23 57.83,58.45 57.33,58.95 55.78,58.95 55.73,59 55.73,59.89 55.76,59.91 58.73,59.91 59.02,59.63 60.51,59.63 60.99,60.11 60.99,63.56 61.1,63.67 63.82,63.67
GND on BOTTOM (solid shape): 252,10.79 252.02,10.64 252.09,10.51 252.09,10.17 251.97,10.05 250.98,10.05 250.96,10.08 250.96,10.11 250.6,10.47 250.2,10.15 250.2,10.13 249.51,9.44 248.91,9.44 248.27,8.8 247.39,8.8 246.74,9.44 246.74,10.68 246.84,10.78 247,10.78 247.24,10.54 249.2,10.54 249.6,10.94 251.85,10.94
GND on BOTTOM (solid shape): 36.54,90.54 38.2,88.88 48.11,88.88 48.41,88.58 48.41,85.86 48.06,85.51 46.56,85.51 46.28,86.15 46,85.51 38.08,85.51 38.03,85.46 36.48,85.46 36.34,85.6 36.34,90.76 36.54,90.96
GND on BOTTOM (solid shape): 42.04,47.4 42.04,45.77 42.19,45.61 42.78,45.61 42.83,45.56 42.83,45.46 42.83,43.87 42.73,43.76 42.53,43.76 42.45,43.69 42.45,42.16 42.55,42.06 42.94,42.06 43.13,41.86 43.13,37.74 43.62,37.26 43.62,35.8 43.43,35.61 41.74,35.61 41.27,36.08 41.27,39.99 40.9,40.36 40.9,42.06 40.9,42.16 41,42.26 41.46,42.26 41.74,42.54 41.74,43.71 41.5,43.95 41.09,43.95 40.9,44.14 40.9,45.06 41.12,45.28 41.53,45.28 41.74,45.49 41.74,45.91 41.74,45.92 41.74,46.74 41.41,47.08 41.07,47.08 40.92,47.22 40.92,47.45 41.03,47.56 41.88,47.56
GND on BOTTOM (solid shape): 32.59,77.14 32.59,75.78 32.4,75.58 30.9,75.58 30.66,75.67 30.42,75.58 30.27,75.58 29.83,75.14 29.83,73.19 29.67,73.03 28.69,73.03 28.55,73.17 28.55,76.34 28.73,76.52 29.89,76.52 30.2,76.2 30.41,76.2 30.92,76.2 30.97,76.71 30.97,77.11 31.11,77.25 32.49,77.25
GND on BOTTOM (solid shape): 173.56,100.48 173.56,98.78 173.54,98.75 172.82,98.75 172.59,98.52 172.59,97.24 172.14,96.79 172.14,95.07 172.1,95.03 171.57,95.02 171.56,94.49 171,93.93 169.93,93.93 169.78,94.08 169.78,96.14 170.2,96.55 170.2,97.23 170.2,97.23 170.2,98.25 170.26,98.31 170.28,98.31 170.5,98.35 170.65,98.51 171.62,98.51 171.84,98.73 171.84,100.45 171.89,100.5 173.54,100.5
GND on BOTTOM (solid shape): 287.58,16.65 288.16,15.96 288.95,16.41 288.96,16.45 300.1,16.45 300.66,16.21 300.9,15.65 300.9,14.27 282.63,14.27 281.49,13.13 278.95,13.13 277.6,14.47 277.6,16.33 279.91,18.63 287.13,18.63 287.13,18.64 287.58,18.64
GND on BOTTOM (solid shape): 41.85,102.44 41.85,102.44 41.85,100.6 40.88,98.27 38.55,97.3 36.63,97.3 36.2,97.3 36.2,102.3 36.32,102.71 36.63,103.01 36.81,103.07 37,103.1 41.85,103.1
GND on BOTTOM (solid shape): 167.49,18.97 167.57,18.94 167.58,18.93 167.76,18.75 167.76,18.73 167.21,18.18 167.21,17.65 167.24,17.62 167.26,17.51 167.15,17.45 166.88,17.39 166.69,17.18 166.62,17.11 166.53,17.14 166.47,17.19 166.47,17.29 166.93,17.75 166.93,18.46 166.61,18.78 166.61,18.82 166.71,18.92 166.72,18.92 166.83,18.96 166.92,19.02 167.17,18.92 167.42,19.02
GND on BOTTOM (solid shape): 210.97,20.17 211.06,20.12 211.06,20.02 211.19,19.55 211.68,19.59 211.71,19.6 211.75,19.59 211.88,19.5 212.02,19.48 212.11,19.49 212.19,19.52 212.29,19.52 212.34,19.43 212.34,18.05 212.02,17.73 210.04,17.73 209.88,17.88 209.88,18 209.4,18.49 209.4,19.32 209.44,19.49 209.4,19.66 209.4,20.12 209.45,20.17
GND on BOTTOM (solid shape): 186.87,80.36 187.91,74.75 187.99,74.3 185.55,73.85 181.7,76.53 184.41,80.36 186.8,80.75
GND on BOTTOM (solid shape): 32.77,37.46 32.77,37.03 32.47,36.72 32.47,33.32 31.45,33.32 31.36,33.23 31.36,31.98 31.66,31.68 32.35,31.68 32.47,31.56 32.47,27.77 31.61,27.77 31.51,27.66 31.51,26.86 31.52,26.85 31.52,25.44 31.65,25.3 32.6,25.3 32.82,25.09 32.82,20.49 32.31,19.99 28.25,19.99 27.87,20.37 27.87,22.13 27.32,22.68 27.32,24.38 22.81,24.38 22.66,24.53 22.42,24.53 21.87,25.08 19.71,25.08 19,25.79 19,26.51 18.27,27.25 18.27,32.11 18.71,32.56 21.9,32.56 22.03,32.43 22.03,31.92 22.33,31.62 25.86,31.62 26.05,31.81 26.67,31.81 26.73,31.75 26.73,30.82 26.05,30.13 22.84,30.13 22.69,29.98 20.69,29.98 20.1,29.38 20.1,25.98 20.38,25.7 22.41,25.7 22.8,26.09 23.55,26.09 23.65,26.2 23.65,27.26 23.72,27.33 26.8,27.33 26.92,27.21 26.92,26.19 27.44,25.68 29.02,25.68 29.8,26.45 29.8,37.28 30.1,37.59 32.64,37.59
GND on BOTTOM (solid shape): 184.43,14.25 184.4,14.22 184.38,13.75 184.84,13.72 184.87,13.76 184.94,13.69 184.77,13.51 184.77,12.76 184.68,12.66 184.65,12.52 184.65,11.08 184.65,11.02 184.63,10.94 184.55,10.9 184.3,10.9 184.22,10.94 184.2,11.02 184.21,11.08 184.21,12.52 184.15,12.7 183.99,12.8 183.98,12.8 183.88,12.9 183.88,14.05 184.16,14.33 184.36,14.33
GND on BOTTOM (solid shape): 263.77,10.95 263.77,9.25 263.51,8.99 263.51,7.93 263.21,7.63 260.51,7.63 260.23,7.91 260.23,10.53 260.51,10.81 260.59,10.84 260.67,10.79 260.94,10.62 261.25,10.71 261.28,10.73 261.58,10.61 261.84,10.72 261.88,10.74 261.91,10.72 262.28,10.63 262.55,10.89 262.63,10.96 262.73,10.92 263.14,10.79 263.41,11.14 263.41,11.18 263.54,11.18
GND on BOTTOM (solid shape): outline of 98 points within 174.17,60.58 179.93,64.96
GND on BOTTOM (solid shape): 117.11,70.44 117.11,70.25 116.56,69.7 116.56,69.47 116.55,69.47 116.55,69.28 116.6,69.19 116.54,69.04 116.38,69.03 116.32,69.08 116.3,69.16 116.3,69.2 116.26,69.4 116.08,69.49 116.06,69.49 116,69.47 115.87,69.5 115.85,69.52 115.47,69.52 115.47,69.53 115.21,69.53 115.16,69.5 115.14,69.49 115.08,69.47 115.02,69.49 114.94,69.56 114.91,69.62 114.91,69.72 114.93,69.77 114.95,69.81 115.18,70.04 115.24,70.08 115.29,70.13 115.75,70.13 115.82,70.05 115.84,70.04 116.06,70 116.23,70.13 116.24,70.14 116.31,70.21 116.31,70.46 116.41,70.56 116.99,70.56
GND on BOTTOM (solid shape): outline of 111 points within 196.88,25.67 202.15,31.41
GND on BOTTOM (solid shape): 288.75,68.66 289.2,68.11 289.82,68.45 300.1,68.45 300.66,68.22 300.9,67.66 300.9,65.3 300.9,64.3 300.66,63.74 300.1,63.5 297.2,63.5 297.2,63.2 297.11,62.99 296.9,62.9 296.2,62.9 296.2,61.7 295.96,61.14 295.4,60.9 294.97,60.9 294.75,60.9 294.25,60.69 294.02,60.1 293.95,60.07 293.6,60.07 293.34,59.81 282.15,59.81 281.41,60.55 281.41,60.56 281.23,60.74 281.23,62.1 281.41,62.28 281.41,62.9 281.42,62.98 281.41,63.05 281.41,63.57 281.42,63.67 281.41,63.77 281.41,67.69 282.63,68.91 288.75,68.91
GND on BOTTOM (solid shape): 17.86,39.95 17.86,37.11 17.36,36.61 17.36,31.38 16.94,30.96 13.52,30.96 13.52,32.5 12.94,33.19 12.15,32.74 12.14,32.7 1,32.7 0.44,32.94 0.2,33.5 0.2,34.6 0.44,35.16 1,35.4 1.5,35.4 2,35.6 2.2,36.1 2.2,37.1 2,37.6 1.5,37.8 1,37.8 0.44,38.04 0.2,38.6 0.2,39.45 0.44,40.01 1,40.25 9.5,40.25 10.19,40.83 9.74,41.61 9.7,41.62 9.7,41.98 15.83,41.98
GND on BOTTOM (solid shape): 294.55,44.87 294.51,44.86 294.22,44.66 294.06,44.34 294.06,44.34 294.2,43.76 294.75,43.5 295.4,43.5 295.96,43.26 296.2,42.7 296.2,41.5 296.9,41.5 297.11,41.41 297.2,41.2 297.2,40.9 300.1,40.9 300.66,40.66 300.9,40.1 300.9,33.55 300.66,32.99 300.1,32.75 299.8,32.75 299.3,32.55 299.1,32.05 299.1,30.75 299.01,30.54 298.8,30.45 293.95,30.45 288.96,30.45 288.95,30.49 288.16,30.94 287.58,30.25 287.58,28.57 284.33,28.57 283.54,29.36 283.54,31.21 284.38,32.05 284.38,36.17 284.38,36.17 284.38,38.45 286.8,40.87 290.98,40.87 291.91,41.8 291.91,45.8 293.01,46.9 294.55,46.9
GND on BOTTOM (solid shape): outline of 188 points within 19.52,77.5 25.36,82.37
GND on BOTTOM (solid shape): outline of 231 points within 276.88,6.63 283.99,11.01
GND on BOTTOM (solid shape): outline of 349 points within 33.56,71.73 48.96,80.56
GND on BOTTOM (solid shape): outline of 365 points within 0.2,54.4 12.53,69.01
GND on BOTTOM (solid shape): outline of 430 points within 0.2,0.2 277.68,20.24
GND on BOTTOM (solid shape): outline of 2563 points within 0.2,45.14 300.9,112.9
GND on BOTTOM (solid shape): outline of 15695 points within 27.15,10.15 197.17,30.14
GND on IN1 (solid shape): 32.79,37.26 32.79,31.11 32.55,30.87 32.55,30.47 32.51,30.42 32.51,28.25 31.47,27.22 31.47,27.22 31.41,27.15 31.41,26.93 31.22,26.74 30.03,26.74 29.9,26.87 29.9,37.22 30.25,37.58 32.48,37.58
GND on IN1 (solid shape): 288.75,68.66 289.2,68.11 289.82,68.45 300.1,68.45 300.66,68.22 300.9,67.66 300.9,64.3 300.66,63.74 300.1,63.5 297.2,63.5 297.2,63.2 297.11,62.99 296.9,62.9 296.2,62.9 296.2,61.7 295.96,61.14 295.4,60.9 294.75,60.9 294.62,60.89 294.48,60.85 294.13,60.54 294.06,60.07 293.6,60.07 291.49,62.18 287.13,62.18 286.06,63.24 282.05,63.24 281.41,63.88 281.41,67.69 282.63,68.91 288.75,68.91
GND on IN1 (solid shape): 294.55,44.87 294.51,44.86 294.05,44.1 294.71,43.5 294.75,43.5 295.4,43.5 295.96,43.26 296.2,42.7 296.2,41.5 296.9,41.5 297.11,41.41 297.2,41.2 297.2,40.9 300.1,40.9 300.66,40.66 300.9,40.1 300.9,33.55 300.66,32.99 300.1,32.75 299.8,32.75 299.3,32.55 299.1,32.05 299.1,30.75 299.01,30.54 298.8,30.45 295.68,30.45 288.96,30.45 288.95,30.49 288.16,30.94 287.58,30.25 287.58,28.62 284.61,28.62 283.62,29.61 283.62,30.45 286.01,32.84 290.02,32.84 291.93,34.74 291.93,45.92 292.82,46.81 294.55,46.81
GND on IN1 (solid shape): 17.86,39.95 17.86,37.11 16.82,36.06 16.82,33.14 17.28,32.69 17.28,31.72 16.51,30.96 13.52,30.96 13.52,32.5 12.94,33.19 12.15,32.74 12.14,32.7 1,32.7 0.44,32.94 0.2,33.5 0.2,34.6 0.44,35.16 1,35.4 1.5,35.4 2,35.6 2.2,36.1 2.2,37.1 2,37.6 1.5,37.8 1,37.8 0.44,38.04 0.2,38.6 0.2,39.45 0.44,40.01 1,40.25 9.5,40.25 10.19,40.83 9.74,41.61 9.7,41.62 9.7,41.98 15.83,41.98
GND on IN1 (solid shape): outline of 190 points within 277.82,13.28 300.9,22.59
