# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D29: length 97.3
  IN4 w0.076: v1(121.02,55.71) 120.49,55.18 120.49,54.27 120.32,54.11 120.32,53.31 120.87,52.77 120.87,52.05 121.83,51.1 121.83,50.42 122.52,49.73 122.52,48.48 123.49,47.5
  IN4 w0.089: 123.49,47.5 123.49,41.9 125.12,40.27 128.78,40.27 129.3,40.79 133.98,40.79 139,35.77 157.28,35.77 158.09,34.96 169.09,34.96 170.9,33.15 171.46,33.15 180.47,24.14 180.47,16.74 180.87,16.34 180.87,14.62 180.43,14.18 180.43,13.86 180.52,13.77 180.98,13.77 181.07,13.68 181.07,13.45 180.98,13.36 180.44,13.36 180.35,13.27 180.35,13.07 180.44,12.98 182.37,12.98 182.46,13.07 v1(182.46,13.31)
  BOTTOM w0.076: v1(121.02,55.71) 121.2,55.86 UC1.AP33
  BOTTOM w0.102: JDIMM2.194 182.43,13.28 v1(182.46,13.31)
DDR_B_D30: length 95.4
  IN4 w0.076: v1(122.85,55.71) 123.23,55.34 123.23,54.2 123.54,53.88 123.54,52.23 ; 128.64,45.72 128.64,45.83 128.52,45.96 128.52,47.04 128.06,47.49 127.71,47.49 126.88,48.32
  IN4 w0.084: 123.54,52.23 125.18,50.59 125.18,50.03 126.88,48.32
  IN4 w0.089: v1(186.15,13.08) 185.9,13.08 185.09,13.89 185.09,15.98 184.46,16.62 184.46,19.42 183.82,20.05 183.82,25.45 182.73,26.54 182.61,26.54 182.41,26.35 182.29,26.35 182.14,26.5 182.14,26.63 182.33,26.82 182.33,26.94 173.42,35.85 172.01,35.85 169.47,38.39 166.93,38.39 166.73,38.19 166.73,37.75 166.64,37.66 166.43,37.66 166.34,37.75 166.34,38.48 166.25,38.57 166.03,38.57 165.94,38.48 165.94,37.75 165.85,37.66 165.64,37.66 165.55,37.75 165.55,38.53 165.46,38.62 150.41,38.62 150.14,38.88 142.45,38.88 141.34,39.99 139.95,39.99 136.14,43.8 130.18,43.8 128.64,45.34 128.64,45.72
  BOTTOM w0.076: UC1.AR30 v1(122.85,55.71)
  BOTTOM w0.102: JDIMM2.208 185.92,11.8 185.92,12.86 v1(186.15,13.08)
DDR_B_D31: length 96.6
  IN4 w0.076: v1(122.85,56.35) 123.4,55.8 123.4,54.26 123.73,53.93 123.73,52.29 125.35,50.67 125.35,50.14 127.75,47.74 128.13,47.74 128.71,47.16 128.71,46.15 129.13,45.72
  IN4 w0.089: v1(186.15,14.63) 185.78,14.27 185.6,14.27 185.48,14.4 185.48,16.03 184.76,16.75 184.76,19.55 184.39,19.92 184.39,20.64 184.76,21.01 184.76,21.77 184.13,22.4 184.13,25.57 173.55,36.15 172.14,36.15 171.99,36.31 171.99,36.45 172.33,36.79 172.33,36.94 172.22,37.04 172.08,37.04 171.74,36.7 171.59,36.7 171.48,36.81 171.48,36.96 171.81,37.28 171.81,37.43 171.71,37.53 171.56,37.53 171.23,37.21 171.09,37.21 169.37,38.92 150.61,38.92 150.35,39.19 142.65,39.19 141.53,40.31 140.09,40.31 136.28,44.12 130.33,44.12 129.21,45.23 129.21,45.64 129.13,45.72
  BOTTOM w0.076: UC1.AP30 v1(122.85,56.35)
  BOTTOM w0.102: v1(186.15,14.63) 185.97,14.81 185.59,14.81 185.21,14.43 185.21,13.73 184.92,13.45 184.92,11.8 JDIMM2.204
DDR_B_D32: length 55.7
  IN1 w0.089: v1(124.81,42.54) 124.84,42.52 124.84,41.43 126.23,40.04 126.23,37.68 131.01,32.9 131.01,32.78 130.69,32.46 130.69,32.31 130.79,32.21 130.94,32.21 131.26,32.53 131.38,32.53 131.51,32.4 131.51,32.28 131.19,31.95 131.19,31.81 131.29,31.7 131.44,31.7 131.76,32.02 131.89,32.02 132.01,31.9 132.01,31.77 131.69,31.45 131.69,31.3 131.8,31.2 131.94,31.2 132.26,31.52 132.39,31.52 132.52,31.4 132.52,31.27 132.19,30.95 132.19,30.8 132.3,30.7 132.45,30.7 132.77,31.02 132.89,31.02 133.02,30.89 133.02,30.77 132.7,30.45 132.7,30.3 134.63,28.37 135.21,28.37 144.2,19.37 144.2,16.65 144.29,16.57 144.29,14.59 144.6,14.28 v1(145.38,14.28)
  BOTTOM w0.076: 124.32,43.81 123.61,44.53 123.61,47.34 123.15,47.8 123.15,50.3 123.15,50.3 123.15,50.65 123,50.8 123,51.16 123.02,51.19 123.17,51.57 123.17,51.85 123.43,52.12 UC1.AY31
  BOTTOM w0.102: v1(124.81,42.54) 124.32,43.04 124.32,43.81 ; v1(145.38,14.28) 145.38,14.15 144.81,13.58 144.81,13.26 144.42,12.88 JDIMM2.50
DDR_B_D33: length 55.8
  IN1 w0.089: v1(143.4,15.95) 143.4,16.32 143.24,16.47 142.87,16.47 142.74,16.61 142.74,17.39 142.73,17.4 142.73,19.55 136.94,25.35 134.74,25.35 134.26,25.83 134.26,26.89 134.39,27.02 134.62,27.02 134.75,27.15 134.75,27.33 134.62,27.45 133.88,27.45 133.67,27.66 133.67,28.03 125.44,36.26 125.44,36.64 125.57,36.77 125.57,37.05 125.28,37.34 125.28,39.98 124.06,41.2 124.06,48.52 124.16,48.62 125.45,48.62 125.56,48.72 125.56,48.87 125.45,48.98 124.16,48.98 124.06,49.08 124.06,49.35 v1(124.23,49.53)
  BOTTOM w0.076: UC1.AW31 124.09,52.97 124.34,52.72 124.34,52.14 124.37,52.1 124.37,51.91 124.31,51.76 124.31,51.61 124.37,51.39 124.37,51.28 124.34,51.2 124.33,51.17 124.33,50.64 124.62,50.34 124.62,50.29 124.62,49.92 v1(124.23,49.53)
  BOTTOM w0.102: JDIMM2.45 143.17,19.01 142.97,18.8 142.97,16.38 v1(143.4,15.95)
DDR_B_D34: length 55.1
  IN1 w0.084: v1(124.83,47.73) 125.59,46.96 125.59,41.71 126.92,40.37
  IN1 w0.089: v1(146.99,14.84) 146.99,14.32 146.74,14.07 146.31,14.07 145.55,14.83 145.01,14.83 144.76,15.08 144.76,15.42 145.09,15.75 146.06,15.75 146.23,15.92 146.23,16.15 145.85,16.53 145.85,18.05 145.4,18.51 145.4,19.84 141.6,23.63 141.1,24.14 141.1,24.28 141.65,24.84 141.65,24.97 139.82,26.8 138.77,26.8 127.42,38.15 127.42,39.87 126.92,40.37
  BOTTOM w0.076: UC1.AY29 124.56,52.22 124.56,51.97 124.48,51.75 124.48,51.62 124.55,51.39 124.55,51.25 124.49,51.13 124.49,50.71 124.79,50.41 124.79,50.22 124.79,48.85 124.83,48.81 v1(124.83,47.73)
  BOTTOM w0.102: JDIMM2.58 146.42,14.27 v1(146.99,14.84)
DDR_B_D35: length 55.9
  IN1 w0.089: v1(126.11,44.22) 126.51,43.82 126.51,43.65 127.17,42.99 127.17,41.97 127.44,41.7 127.44,40.8 128.45,39.78 128.45,38.41 139.15,27.71 140.2,27.71 144.63,23.28 144.63,23.16 144.07,22.6 144.07,22.46 144.18,22.35 144.32,22.35 144.88,22.91 145.01,22.91 145.13,22.78 145.13,22.66 144.58,22.1 144.58,21.95 144.68,21.85 144.83,21.85 145.38,22.41 145.51,22.41 145.64,22.28 145.64,22.15 145.08,21.6 145.08,21.45 148.05,18.47 148.05,13.58 147.82,13.35 v1(147.51,13.35)
  BOTTOM w0.076: v1(126.11,44.22) 126.08,44.22 125.58,44.72 125.58,48.77 125.28,49.07 125.28,49.32 125.28,50.64 125.19,50.73 125.19,51.68 124.97,51.9 124.97,52.44 124.66,52.75 UC1.AW29
  BOTTOM w0.102: JDIMM2.62 147.42,13.26 v1(147.51,13.35)
DDR_B_D36: length 54.4
  IN1 w0.089: v1(143.37,17.25) 143.28,17.25 143.03,17.49 143.03,18.52 143.14,18.62 143.45,18.62 143.55,18.73 143.55,18.87 143.45,18.98 143.14,18.98 143.03,19.08 143.03,19.68 136.48,26.23 134.67,26.23 134.57,26.34 134.57,26.49 134.67,26.59 135.64,26.59 135.77,26.72 135.77,26.9 135.64,27.02 135.35,27.02 135.14,27.22 135.14,27.57 134.95,27.76 134.37,27.76 127.76,34.38 127.76,34.5 128.09,34.83 128.09,34.96 127.96,35.09 127.84,35.09 127.51,34.75 127.38,34.75 127.25,34.88 127.25,35 127.59,35.34 127.59,35.46 127.46,35.59 127.33,35.59 127,35.26 126.88,35.26 126.75,35.38 126.75,35.51 127.08,35.84 127.08,35.97 126.96,36.09 126.83,36.09 126.5,35.76 126.37,35.76 126.25,35.89 126.25,36.01 126.58,36.34 126.58,36.47 126.45,36.59 126.33,36.59 126,36.26 125.87,36.26 125.75,36.39 125.75,36.51 126.08,36.85 126.08,36.97 125.59,37.45 125.59,39.99 124.26,41.33 124.26,43.91 v1(124.83,44.48)
  BOTTOM w0.076: UC1.BB31 123.43,50.84 123.48,50.8 123.48,50.05 123.48,50.05 123.48,47.93 123.94,47.47 123.94,45.37 v1(124.83,44.48)
  BOTTOM w0.102: v1(143.37,17.25) 143.65,17.25 144.17,17.77 JDIMM2.49
DDR_B_D37: length 54.6
  IN1 w0.089: v1(143.32,14.3) 143.67,14.3 143.98,14.61 143.98,15.98 143.86,16.1 143.86,19.29 135.08,28.06 134.5,28.06 130.22,32.34 130.22,32.49 130.54,32.81 130.54,32.94 130.42,33.06 130.29,33.06 129.97,32.74 129.82,32.74 129.72,32.84 129.72,32.99 130.04,33.31 130.04,33.44 129.92,33.56 129.79,33.56 129.47,33.24 129.32,33.24 129.22,33.35 129.22,33.49 129.54,33.82 129.54,33.94 129.41,34.07 129.29,34.07 128.97,33.75 128.82,33.75 128.71,33.85 128.71,34 129.04,34.32 129.04,34.44 128.91,34.57 128.78,34.57 128.46,34.25 128.32,34.25 128.21,34.35 128.21,34.5 128.53,34.82 128.53,34.95 125.91,37.57 125.91,40.01 124.44,41.49 124.44,43.44 v1(124.83,43.83)
  BOTTOM w0.076: UC1.BA31 123.43,51.52 123.28,51.37 123.17,51.13 123.17,50.87 123.31,50.72 123.31,50.16 123.31,50.16 123.31,47.87 123.77,47.41 123.77,44.88 v1(124.83,43.83)
  BOTTOM w0.102: JDIMM2.46 143.42,12.88 143.73,13.18 143.73,13.9 v1(143.32,14.3)
DDR_B_D38: length 54.6
  IN1 w0.089: v1(126.12,42.98) 126.37,43.23 126.58,43.23 126.95,42.85 126.95,42.11 126.8,41.96 126.8,41.75 127.18,41.37 127.18,40.8 128.05,39.94 128.05,38.39 139.03,27.41 140.08,27.41 143.15,24.33 143.15,24.21 142.6,23.65 142.6,23.5 142.7,23.4 142.85,23.4 143.4,23.95 143.53,23.95 143.66,23.83 143.66,23.7 143.1,23.15 143.1,23 143.2,22.9 143.35,22.9 143.91,23.45 144.03,23.45 144.16,23.33 144.16,23.2 143.6,22.64 143.6,22.5 147.12,18.97 147.12,18.71 147.25,18.59 147.51,18.59 147.7,18.4 147.7,17.23 147.5,17.04 147.5,16.78 147.65,16.63 147.65,16.42 147.51,16.28 v1(147.38,16.28)
  BOTTOM w0.076: 125.7,43.81 125.7,44.34 125.44,44.6 125.44,44.63 125.42,44.66 125.42,48.7 125.12,49 125.12,49.25 125.12,49.25 125.12,50.08 125.12,50.08 125.12,50.55 125.03,50.64 125.03,51.18 124.76,51.44 UC1.BA29
  BOTTOM w0.102: v1(126.12,42.98) 125.7,43.41 125.7,43.81 ; v1(147.38,16.28) 147.82,16.71 147.82,18.85 147.68,18.99 JDIMM2.63
DDR_B_D39: length 53.8
  IN1 w0.089: v1(125.98,42.34) 125.84,42.2 125.84,41.78 125.99,41.63 126.14,41.63 126.3,41.79 126.46,41.79 126.57,41.68 126.57,41.52 126.42,41.37 126.42,41.22 127.73,39.91 127.73,38.27 138.9,27.1 139.95,27.1 142.16,24.89 142.16,24.76 141.61,24.21 141.61,24.06 141.71,23.96 141.86,23.96 142.41,24.51 142.54,24.51 142.67,24.39 142.67,24.26 142.11,23.7 142.11,23.56 145.85,19.82 145.85,19.5 145.7,19.35 145.7,19.17 145.83,19.05 146.05,19.05 146.23,19.22 146.44,19.22 146.74,18.93 146.74,18.77 146.62,18.65 146.13,18.65 146.03,18.55 146.03,18.4 146.13,18.3 146.7,18.3 146.78,18.21 146.78,18.03 146.7,17.94 146.26,17.94 146.16,17.84 146.16,16.89 146.33,16.71 146.97,16.71 147.13,16.87 v1(147.13,17.27)
  BOTTOM w0.076: 125.25,43.81 125.25,48.64 124.95,48.93 124.95,49.18 124.95,49.18 124.95,50.15 124.95,50.15 124.95,50.48 124.76,50.67 UC1.BB29
  BOTTOM w0.102: v1(125.98,42.34) 125.85,42.34 125.25,42.94 125.25,43.81 ; v1(147.13,17.27) 146.68,17.72 JDIMM2.59
DDR_B_D40: length 61.1
  IN1 w0.089: v1(149.06,14.89) 149.31,15.13 149.31,17.32 149.02,17.6 149.02,20.17 144.52,24.67 144.52,24.8 144.94,25.22 144.94,25.34 144.81,25.47 144.69,25.47 144.27,25.05 144.14,25.05 144.01,25.18 144.01,25.3 144.43,25.72 144.43,25.85 144.31,25.97 144.18,25.97 143.76,25.55 143.64,25.55 143.51,25.68 143.51,25.8 143.93,26.22 143.93,26.35 143.81,26.48 143.68,26.48 143.26,26.06 143.13,26.06 143.01,26.18 143.01,26.31 143.43,26.73 143.43,26.85 143.3,26.98 143.18,26.98 142.76,26.56 142.63,26.56 142.51,26.69 142.51,26.81 142.93,27.23 142.93,27.36 142.8,27.48 142.67,27.48 142.25,27.06 142.13,27.06 142,27.19 142,27.31 142.42,27.73 142.42,27.86 142.3,27.99 142.17,27.99 141.75,27.57 141.63,27.57 141.5,27.69 141.5,27.82 141.92,28.24 141.92,28.36 141.79,28.49 141.67,28.49 141.25,28.07 141.12,28.07 140.58,28.61 139.53,28.61 129.47,38.67 129.47,39.62 129,40.09 129,40.84 127.56,42.28 127.56,43.48 127.44,43.61 127.44,44.78 v1(126.12,46.1)
  BOTTOM w0.076: v1(126.12,46.1) 126.68,46.66 126.68,48.87 125.97,49.58 125.97,50.78 126.06,50.87 126.06,51.12 126.02,51.21 126.02,51.48 126.06,51.57 126.06,51.77 126.03,51.86 126.02,51.86 125.99,51.96 125.99,52.22 UC1.AY27
  BOTTOM w0.102: JDIMM2.66 148.42,14.25 v1(149.06,14.89)
DDR_B_D41: length 61.7
  IN1 w0.084: v1(126.12,44.85) 126.96,44.85 127.18,44.62 127.18,44.47 127.08,44.37 126.7,44.37 126.6,44.27 126.6,44.13 126.7,44.03 127.08,44.03 127.18,43.94 127.18,43.48 127.37,43.29 127.37,42.15 127.94,41.58 127.94,41.3 127.82,41.17 127.82,40.97
  IN1 w0.089: 127.82,40.97 129.05,39.74 129.05,38.66 139.4,28.31 140.45,28.31 146.51,22.25 146.51,22.1 145.96,21.56 145.96,21.41 146.07,21.31 146.21,21.31 146.76,21.85 146.91,21.85 147.01,21.75 147.01,21.6 146.47,21.05 146.47,20.91 146.57,20.8 146.72,20.8 147.26,21.35 147.41,21.35 147.51,21.24 147.51,21.1 146.97,20.55 146.97,20.4 147.07,20.3 147.22,20.3 147.77,20.85 147.91,20.85 148.02,20.74 148.02,20.59 147.47,20.05 147.47,19.9 147.58,19.8 147.72,19.8 148.26,20.33 148.43,20.33 148.54,20.22 148.54,20.05 148.01,19.52 148.01,19.36 148.14,19.24 148.48,19.24 148.66,19.06 148.66,17.53 149,17.19 149,16.94 148.66,16.6 148.66,16.41 149,16.07 149,15.75 148.65,15.4 148.65,13.53 148.81,13.36 v1(149.06,13.36)
  BOTTOM w0.076: UC1.AW27 125.89,52.78 125.57,52.46 125.57,51.91 125.36,51.7 125.36,50.8 125.45,50.71 125.45,49.95 125.45,49.39 125.75,49.09 125.75,45.22 v1(126.12,44.85)
  BOTTOM w0.102: v1(149.06,13.36) 149.42,13 JDIMM2.70
DDR_B_D42: length 61.2
  IN1 w0.089: v1(149.9,16.56) 150.12,16.56 150.35,16.79 150.35,19.27 150.24,19.38 149.73,19.38 149.65,19.47 149.65,19.65 149.73,19.74 150.24,19.74 150.33,19.83 150.33,20.01 150.24,20.09 149.73,20.09 149.65,20.18 149.65,20.36 149.73,20.45 150.24,20.45 150.33,20.54 150.33,20.78 149.77,21.34 149.77,21.38 149.62,21.52 149.62,21.67 149.81,21.86 149.81,22 149.71,22.11 149.56,22.11 149.37,21.92 149.22,21.92 144.39,26.75 144.39,26.88 144.85,27.34 144.85,27.46 144.73,27.59 144.6,27.59 144.14,27.13 144.02,27.13 143.89,27.26 143.89,27.38 144.35,27.84 144.35,27.97 144.22,28.09 144.1,28.09 143.64,27.63 143.51,27.63 143.39,27.76 143.39,27.88 143.85,28.34 143.85,28.47 143.72,28.59 143.59,28.59 143.13,28.14 143.01,28.14 142.88,28.26 142.88,28.39 143.34,28.85 143.34,28.97 143.22,29.1 143.09,29.1 142.63,28.64 142.51,28.64 142.4,28.75 142.4,29.16 142.33,29.22 139.78,29.22 130.08,38.92 130.08,39.21 130.17,39.3 130.28,39.3 130.37,39.39 130.37,39.62 130.29,39.7 130.13,39.7 130.05,39.77 130.05,41.44 129.44,42.05 129.12,42.05 128.99,42.18 128.99,42.5 128.93,42.56 128.59,42.56 128.45,42.69 128.45,42.92 128.5,42.97 v1(128.83,42.97)
  BOTTOM w0.076: 128.52,45.4 128.52,47.38 127.81,48.08 127.81,49.36 127.56,49.62 127.56,51.14 127.44,51.4 127.39,51.5 127.39,51.85 127.11,52.12 UC1.AY25
  BOTTOM w0.102: v1(149.9,16.56) 148.68,17.79 JDIMM2.67 ; 128.52,45.4 128.52,45.27 128.77,45.02 128.77,43.04 v1(128.83,42.97)
DDR_B_D43: length 62
  IN1 w0.089: v1(149.9,18.16) 149.7,17.96 149.45,17.96 149.33,18.09 149.33,18.63 149.42,18.72 149.94,18.72 150.03,18.81 150.03,18.99 149.94,19.08 149.42,19.08 149.33,19.17 149.33,20.54 149.64,20.85 149.64,21.04 149.51,21.17 149.32,21.17 148.98,20.83 148.79,20.83 148.65,20.98 148.65,21.13 149.04,21.52 149.04,21.67 148.87,21.84 148.75,21.84 148.33,21.42 148.2,21.42 148.08,21.55 148.08,21.67 148.5,22.09 148.5,22.22 148.37,22.34 148.25,22.34 147.83,21.92 147.7,21.92 147.57,22.05 147.57,22.17 147.99,22.59 147.99,22.72 147.87,22.85 147.74,22.85 147.32,22.43 147.2,22.43 147.07,22.55 147.07,22.68 147.49,23.1 147.49,23.22 147.36,23.35 147.24,23.35 146.82,22.93 146.69,22.93 146.57,23.05 146.57,23.18 146.99,23.6 146.99,23.73 146.86,23.85 146.74,23.85 146.32,23.43 146.19,23.43 146.07,23.56 146.07,23.68 146.49,24.1 146.49,24.23 146.36,24.35 146.23,24.35 145.81,23.93 145.69,23.93 145.56,24.06 145.56,24.19 145.98,24.61 145.98,24.73 145.86,24.86 145.73,24.86 145.31,24.44 145.19,24.44 145.06,24.56 145.06,24.69 145.48,25.11 145.48,25.23 141.79,28.92 139.65,28.92 129.77,38.8 129.77,41.23 129.3,41.7 129.11,41.7 128.99,41.58 128.83,41.58 128.2,42.21 128.2,42.81 v1(127.94,43.06)
  BOTTOM w0.076: UC1.AW25 126.46,52.97 126.26,52.77 126.19,52.67 126.19,51.9 126.22,51.8 126.22,51.53 126.19,51.45 126.19,51.25 126.22,51.16 126.22,50.8 126.13,50.71 126.13,49.65 126.85,48.93
  BOTTOM w0.102: 126.85,48.93 126.86,48.92 126.86,43.61 127.41,43.06 v1(127.94,43.06) ; JDIMM2.71 149.68,18.39 v1(149.9,18.16)
DDR_B_D44: length 59.3
  IN1 w0.089: v1(126.12,46.7) 127.01,47.59 128.16,47.59 129.21,46.53 129.21,45.36 130.74,43.83 130.74,43.1 133.29,40.54 133.29,38.23 140.52,31.01 144.86,31.01 150.11,25.76 150.11,25.63 149.73,25.25 149.73,25.11 149.83,25 149.98,25 150.36,25.38 150.48,25.38 150.61,25.25 150.61,25.13 150.23,24.75 150.23,24.6 150.34,24.5 150.48,24.5 150.86,24.88 150.99,24.88 151.11,24.75 151.11,24.63 150.74,24.25 150.74,24.1 150.84,24 150.99,24 151.36,24.37 151.49,24.37 151.62,24.25 151.62,24.12 151.24,23.75 151.24,23.6 151.34,23.49 151.49,23.49 151.87,23.87 151.99,23.87 152.14,23.72 152.14,18.21 152.2,18.14 152.6,18.14 152.71,18.03 152.71,17.9 152.6,17.79 152.2,17.79 152.14,17.73 152.14,17.27 v1(152.34,17.07)
  BOTTOM w0.076: UC1.BB27 125.78,51.01 125.78,49.53 126.52,48.8 126.52,47.09 v1(126.12,46.7)
  BOTTOM w0.102: v1(152.34,17.07) 151.68,17.73 JDIMM2.79
DDR_B_D45: length 59.7
  IN1 w0.089: v1(126.15,47.95) 126.32,48.13 128.04,48.13 129.56,46.6 129.56,45.61 132.17,43 132.17,42.3 133.6,40.87 133.6,38.36 140.65,31.31 144.98,31.31 152.44,23.85 152.44,22.92 152.58,22.78 152.94,22.78 153.04,22.67 153.04,22.45 152.95,22.36 152.53,22.36 152.44,22.27 152.44,22.09 152.53,22.01 152.95,22.01 153.04,21.92 153.04,21.74 152.95,21.65 152.53,21.65 152.44,21.56 152.44,21.38 152.53,21.29 152.95,21.29 153.04,21.21 153.04,21.03 152.95,20.94 152.53,20.94 152.44,20.85 152.44,20.67 152.53,20.58 152.95,20.58 153.04,20.49 153.04,20.32 152.95,20.23 152.53,20.23 152.44,20.14 152.44,19.96 152.53,19.87 152.95,19.87 153.04,19.78 153.04,19.61 152.95,19.52 152.53,19.52 152.44,19.43 152.44,19.25 152.53,19.16 152.95,19.16 153.04,19.07 153.04,18.89 152.95,18.81 152.53,18.81 152.44,18.72 152.44,18.54 152.53,18.45 152.93,18.45 153.02,18.36 153.02,17.99 v1(153.86,17.15)
  BOTTOM w0.076: UC1.BA27 125.79,51.45 125.52,51.18 125.52,50.87 125.61,50.78 125.61,49.88 125.61,49.47 126.1,48.98 126.1,48.01 v1(126.15,47.95)
  BOTTOM w0.102: JDIMM2.83 152.68,18.49 153.86,17.3 v1(153.86,17.15)
DDR_B_D46: length 59.9
  IN1 w0.089: v1(127.9,47.11) 128.12,47.11 128.9,46.34 128.9,45.17 130.36,43.71 130.36,43.05 132.99,40.42 132.99,38.1 140.39,30.7 144.73,30.7 147.14,28.29 147.14,28.17 146.76,27.79 146.76,27.64 146.87,27.54 147.01,27.54 147.39,27.91 147.52,27.91 147.64,27.79 147.64,27.66 147.27,27.29 147.27,27.14 147.37,27.03 147.52,27.03 147.89,27.41 148.02,27.41 148.15,27.29 148.15,27.16 147.77,26.78 147.77,26.64 147.87,26.53 148.02,26.53 148.4,26.91 148.52,26.91 148.65,26.78 148.65,26.66 148.27,26.28 148.27,26.13 148.38,26.03 148.52,26.03 148.9,26.41 149.03,26.41 149.15,26.28 149.15,26.15 148.78,25.78 148.78,25.63 148.88,25.53 149.03,25.53 149.4,25.9 149.53,25.9 149.66,25.78 149.66,25.65 149.28,25.27 149.28,25.13 151.83,22.57 151.83,16.25 v1(152.77,15.32)
  BOTTOM w0.076: UC1.BA25 127.11,51.52 127.27,51.37 127.39,51.11 127.39,49.69 127.39,49.55 127.65,49.3 127.65,47.35 127.89,47.11 v1(127.9,47.11)
  BOTTOM w0.102: v1(152.77,15.32) 152.19,14.73 152.19,13.78 151.93,13.52 JDIMM2.80
DDR_B_D47: length 59
  IN1 w0.089: v1(127.63,45.83) 127.82,46.02 128.39,46.02 128.58,45.83 128.58,45 130,43.58 130,42.76 131.79,40.97 131.79,40.15 131.56,39.92 131.56,39.1 140.27,30.4 143.58,30.4 143.88,30.1 144,30.1 144.31,30.4 144.45,30.4 144.56,30.29 144.56,30.15 144.26,29.84 144.26,29.72 144.38,29.59 144.51,29.59 144.88,29.97 145.03,29.97 145.14,29.87 145.14,29.72 144.76,29.34 144.76,29.22 144.88,29.09 145.01,29.09 145.39,29.47 145.53,29.47 145.64,29.36 145.64,29.22 145.26,28.84 145.26,28.71 145.39,28.59 145.51,28.59 145.89,28.96 146.04,28.96 146.14,28.86 146.14,28.71 145.76,28.34 145.76,28.21 145.89,28.08 146.02,28.08 146.39,28.46 146.54,28.46 146.64,28.36 146.64,28.21 146.27,27.83 146.27,27.71 151.53,22.44 151.53,16.23 151.53,15.98 151.95,15.56 151.95,14.65 152.53,14.07 v1(152.77,14.07)
  BOTTOM w0.076: v1(127.63,45.83) 127.63,46.26 127.48,46.41 127.48,48.08 127.48,49.23 127.23,49.48 127.23,50.69 127.11,50.8 UC1.BB25
  BOTTOM w0.102: v1(152.77,14.07) 153.2,13.64 153.2,12.93 152.93,12.66 JDIMM2.84
DDR_B_D48: length 91.5
  IN4 w0.076: 131.1,45.72 129.7,47.12 129.7,47.31 128.3,48.71 127.84,48.71 126.87,49.68 126.87,50.54 124.68,52.73
  IN4 w0.084: 124.68,52.73 v1(124.68,53.79)
  IN4 w0.089: 131.1,45.72 131.18,45.64 136.92,45.64 139.2,43.37 139.72,43.37 141.19,41.89 143.59,41.89 144.79,40.7 151.15,40.7 151.41,40.43 170.09,40.43 171.18,39.35 172.55,39.35 185.73,26.17 185.73,24.68 186.88,23.53 186.88,17.45 187.59,16.74 187.59,16.28 188.06,15.81 188.06,15.51 188.33,15.24 188.56,15.24 188.74,15.06 188.74,14.9 188.65,14.81 188.27,14.81 188.18,14.72 188.18,14.54 188.27,14.46 188.65,14.46 188.74,14.37 188.74,14.23 v1(187.67,13.16)
  BOTTOM w0.076: UC1.AU27 v1(124.68,53.79)
  BOTTOM w0.102: JDIMM2.216 187.93,11.92 187.92,11.92 187.92,12.9 v1(187.67,13.16)
DDR_B_D49: length 92.3
  IN4 w0.076: 130.65,45.72 129.34,47.04 129.34,47.35 128.23,48.46 127.78,48.46 125.95,50.3 125.95,50.86 124.29,52.52 124.29,53.93 124.68,54.32 v1(124.68,54.44)
  IN4 w0.089: v1(187.14,16.36) 187.14,15.94 187.05,15.85 186.94,15.85 186.36,16.43 186.36,16.58 186.47,16.69 186.87,16.69 186.96,16.78 186.96,16.95 186.81,17.1 186.66,17.1 186.57,17.19 186.57,17.33 186.57,23.03 186.27,23.33 185.5,23.33 185.34,23.49 185.34,23.76 185.42,23.85 185.59,23.85 185.68,23.94 185.68,24.15 185.59,24.24 185.42,24.24 185.34,24.33 185.34,26.13 172.42,39.04 171.05,39.04 169.97,40.13 151.21,40.13 150.95,40.39 143.2,40.39 142.05,41.54 141.1,41.54 139.59,43.05 139.08,43.05 136.8,45.34 131.04,45.34 130.65,45.72
  BOTTOM w0.076: UC1.AT27 v1(124.68,54.44)
  BOTTOM w0.102: JDIMM2.215 187.68,18.49 187.6,18.41 187.6,16.83 v1(187.14,16.36)
DDR_B_D50: length 90.9
  IN4 w0.076: 126.29,52.25 126.21,52.32 126.21,53.09 126.13,53.17 125.95,53.97 125.82,54.1 v1(125.6,54.44) ; 131.12,47.16 128.58,49.7 128.33,50.22 127.57,50.98 127.56,50.98
  IN4 w0.084: 127.56,50.98 126.29,52.25
  IN4 w0.089: 131.12,47.16 136.33,47.16 136.71,47.28 137.72,47.28 138.36,46.91 138.99,46.27 139.12,45.95 139.37,45.31 139.74,44.94 140.45,44.94 141.98,43.41 144.22,43.41 145.4,42.23 153.03,42.23 153.3,41.96 165.46,41.96 165.8,42.3 167.21,42.3 167.6,41.91 170.63,41.91 172.85,41.22 187.08,26.98 189.07,22.62 189.07,17.31 189.97,15.53 189.97,14.52 189.67,14.02 v1(189.45,13.79)
  BOTTOM w0.076: UC1.AT25 v1(125.6,54.44)
  BOTTOM w0.102: JDIMM2.224 189.92,11.8 189.92,13.32 v1(189.45,13.79)
DDR_B_D51: length 90.7
  IN4 w0.084: v1(125.6,53.81) 125.96,53.1 126.01,52.99 126.01,52.28 127.53,50.76 127.53,50.01 127.61,49.78 127.69,49.71 128.48,49.48 130.13,47.83
  IN4 w0.089: 130.13,47.83 131.12,46.85 136.57,46.85 137.14,46.95 137.47,46.95 137.7,46.91 138.21,46.63 138.71,46.12 139.11,45.13 139.67,44.57 140.25,44.57 141.74,43.09 144.09,43.09 145.25,41.93 152.91,41.93 153.17,41.66 165.59,41.66 165.91,41.98 167.1,41.98 167.47,41.61 170.58,41.61 171.58,40.6 173.01,40.6 186.77,26.85 186.87,26.72 188.69,22.65 188.69,18.38 188.69,18.38 188.69,17.19 v1(189.55,15.47)
  BOTTOM w0.076: UC1.AU25 v1(125.6,53.81)
  BOTTOM w0.102: v1(189.55,15.47) 190.44,14.58 190.44,13.52 190.92,13.03 190.92,11.8 JDIMM2.228
DDR_B_D52: length 92.5
  IN4 w0.076: 130.23,45.72 130.23,45.77 129.15,46.85 129.15,47.29 128.26,48.18 127.79,48.18 125.77,50.2 125.77,50.79 124.11,52.45 124.11,54 124.31,54.21 124.31,55.34 v1(124.68,55.71)
  IN4 w0.089: 130.23,45.72 130.23,45.64 130.85,45.02 136.67,45.02 138.97,42.72 139.44,42.72 140.92,41.23 141.93,41.23 143.07,40.09 150.73,40.09 150.99,39.82 169.84,39.82 170.93,38.74 172.3,38.74 185.03,26.01 185.03,22.77 185.32,22.49 185.44,22.49 185.98,23.02 186.15,23.02 186.26,22.91 186.26,22.75 185.72,22.21 185.72,22.08 185.88,21.93 186.18,21.93 186.27,21.84 186.27,21.62 186.18,21.53 185.86,21.53 185.74,21.42 185.74,21.26 185.86,21.14 186.15,21.14 186.27,21.03 186.27,20.86 186.15,20.75 185.86,20.75 185.74,20.63 185.74,20.47 185.86,20.35 186.18,20.35 186.27,20.26 186.27,20.05 186.18,19.96 185.86,19.96 185.74,19.84 185.74,19.68 185.86,19.57 186.18,19.57 186.27,19.48 186.27,19.26 186.18,19.17 185.86,19.17 185.77,19.08 185.77,18.29 v1(186.15,17.91)
  BOTTOM w0.076: UC1.AP27 v1(124.68,55.71)
  BOTTOM w0.102: v1(186.15,17.91) 186.35,17.91 186.68,18.24 JDIMM2.211
DDR_B_D53: length 93.1
  IN4 w0.076: v1(124.68,56.35) 124.15,55.81 124.15,54.29 123.93,54.07 123.93,52.38 125.59,50.72 125.59,50.14 127.81,47.93 128.26,47.93 128.96,47.23 128.96,46.78 129.85,45.89 129.85,45.72
  IN4 w0.089: 129.85,45.72 129.85,45.46 130.6,44.71 136.53,44.71 138.84,42.4 139.31,42.4 140.79,40.92 141.79,40.92 142.93,39.78 150.6,39.78 150.87,39.52 169.71,39.52 170.8,38.43 172.17,38.43 184.73,25.88 184.73,22.65 185.37,22 185.37,16.98 187.64,14.71 v1(187.67,14.71)
  BOTTOM w0.076: UC1.AN27 v1(124.68,56.35)
  BOTTOM w0.102: v1(187.67,14.71) 186.92,13.97 186.92,11.8 JDIMM2.212
DDR_B_D54: length 92.9
  IN4 w0.076: 131.28,47.74 133.69,47.74 ; 126.46,53.31 126.46,53.97 126.14,54.29 126.14,55.81 v1(125.6,56.35) ; 134.36,47.79 134.37,47.79 ; 129.29,49.73 129.82,49.2
  IN4 w0.084: 126.46,53.31 126.57,53.2 126.57,52.54 128.99,50.12 128.99,50.03 129.29,49.73 ; 129.82,49.2 131.28,47.74
  IN4 w0.089: v1(191.17,18.62) 191.17,18.49 190.92,18.24 190.6,18.24 190.51,18.33 190.51,19.07 190.43,19.15 190.17,19.15 190.08,19.07 190.08,17.82 189.99,17.73 189.76,17.73 189.68,17.82 189.68,24.22 188.7,25.19 188.7,26.4 172.58,42.52 167.85,42.52 167.43,42.94 165.54,42.94 165.19,42.59 153.78,42.59 153.53,42.84 145.79,42.84 144.26,44.37 142.3,44.37 141.09,45.58 141.09,45.83 139.83,47.09 139.83,47.41 139.25,47.99 136.16,47.99 135.96,47.79 134.37,47.79 ; 134.36,47.79 134.31,47.74 133.69,47.74
  BOTTOM w0.076: UC1.AN25 126.02,56.71 v1(125.6,56.35)
  BOTTOM w0.102: v1(191.17,18.62) 191.17,19.92 191.18,19.92 JDIMM2.229
DDR_B_D55: length 92.6
  IN4 w0.076: 126.46,52.4 126.38,52.48 126.38,53.15 126.3,53.24 126.3,53.86 125.96,54.19 125.96,55.34 v1(125.6,55.71) ; 131.22,47.53 129.4,49.35 129.26,49.35
  IN4 w0.084: 129.26,49.35 129.11,49.49 128.82,49.79 128.82,50.04 126.46,52.4
  IN4 w0.089: 131.22,47.53 131.27,47.48 136.16,47.48 136.29,47.61 138.09,47.61 139.76,45.94 139.76,45.64 140.14,45.26 140.71,45.26 142.23,43.73 144.37,43.73 145.57,42.53 153.19,42.53 153.46,42.27 165.33,42.27 165.7,42.63 167.3,42.63 167.72,42.22 172.45,42.22 188.4,26.27 188.4,25.07 189.37,24.09 189.37,17.39 189.92,16.84 190.92,16.84 v1(191.17,17.1)
  BOTTOM w0.076: UC1.AP25 v1(125.6,55.71)
  BOTTOM w0.102: v1(191.17,17.1) 190.97,17.1 190.17,17.89 190.17,19.86 190.18,19.86 JDIMM2.225
DDR_B_D56: length 98.5
  IN4 w0.076: 127.06,53.59 127.06,53.95 127.43,54.32 v1(127.43,54.44)
  IN4 w0.084: 127.06,53.59 127.38,53.26 127.38,52.51 131.2,48.69
  IN4 w0.089: v1(193.46,16.44) 193.09,16.06 192.83,16.06 192.43,16.46 192.43,19.04 190.93,20.54 190.93,27.24 190.16,28.01 189.37,28.01 188.51,28.87 188.36,28.87 188.22,28.73 188.07,28.73 187.97,28.84 187.97,28.99 188.11,29.13 188.11,29.27 188.01,29.38 187.86,29.38 187.72,29.24 187.57,29.24 187.47,29.34 187.47,29.49 187.61,29.63 187.61,29.78 187.5,29.88 187.36,29.88 187.22,29.74 187.07,29.74 186.96,29.84 186.96,29.99 187.1,30.13 187.1,30.28 187,30.38 186.85,30.38 186.71,30.24 186.57,30.24 186.46,30.35 186.46,30.49 186.6,30.64 186.6,30.78 186.5,30.89 186.35,30.89 186.21,30.75 186.06,30.75 185.96,30.85 185.96,31 186.1,31.14 186.1,31.29 185.99,31.39 185.85,31.39 185.71,31.25 185.56,31.25 185.46,31.35 185.46,31.5 185.6,31.64 185.6,31.89 173.76,43.73 168.35,43.73 167.86,44.22 158.98,44.22 158.91,44.29 154.55,44.29 154.3,44.05 146.59,44.05 144.48,46.16 144.33,46.16 144.22,46.05 144.07,46.05 143.97,46.15 143.97,46.3 144.08,46.41 144.08,46.56 143.98,46.66 143.41,46.66 143.18,46.89 143.18,46.9 142.9,47.18 142.73,47.18 141.57,48.33 140.76,48.33 139.87,49.22 134.97,49.22 134.68,49.51 134.29,49.51 133.47,48.69 131.2,48.69
  BOTTOM w0.076: UC1.AT22 v1(127.43,54.44)
  BOTTOM w0.102: v1(193.46,16.44) 192.17,17.72 192.17,19.86 192.18,19.86 JDIMM2.233
DDR_B_D57: length 97.9
  IN4 w0.076: 129.68,50.46 129.68,50.45 130.14,50 130.19,50
  IN4 w0.084: 129.68,50.46 128.24,51.89 128.24,52.83 127.43,53.65 v1(127.43,53.79)
  IN4 w0.089: v1(193.64,17.97) 193.1,18.52 193.1,18.81 191.49,20.41 191.49,20.63 191.59,20.73 191.99,20.73 192.09,20.84 192.09,20.99 191.99,21.09 191.34,21.09 191.23,21.19 191.23,21.34 191.34,21.45 191.99,21.45 192.09,21.55 192.09,21.7 191.99,21.8 191.34,21.8 191.23,21.9 191.23,22.05 191.34,22.16 191.99,22.16 192.09,22.26 192.09,22.41 191.99,22.51 191.34,22.51 191.23,22.62 191.23,22.76 191.34,22.87 191.99,22.87 192.09,22.97 192.09,23.12 191.99,23.22 191.34,23.22 191.23,23.33 191.23,23.47 191.34,23.58 191.99,23.58 192.09,23.68 192.09,23.83 191.99,23.93 191.34,23.93 191.23,24.04 191.23,24.19 191.34,24.29 191.99,24.29 192.09,24.39 192.09,24.54 191.99,24.65 191.34,24.65 191.23,24.75 191.23,27.37 190.29,28.32 189.6,28.32 173.89,44.03 168.48,44.03 167.97,44.54 159.17,44.54 159.11,44.6 154.43,44.6 154.18,44.35 146.86,44.35 143.1,48.12 142.23,48.12 141.71,48.63 140.89,48.63 139.98,49.54 135.22,49.54 134.99,49.77 134.28,49.77 133.46,48.94 131.24,48.94 130.19,50
  BOTTOM w0.076: UC1.AU22 v1(127.43,53.79)
  BOTTOM w0.102: JDIMM2.237 193.18,19.8 193.17,19.8 193.17,18.45 193.64,17.99 v1(193.64,17.97)
DDR_B_D58: length 97
  IN4 w0.084: 128.71,53.42 v1(128.34,53.79)
  IN4 w0.089: 128.71,53.42 128.71,53.3 130.16,51.84 130.45,51.84 131.26,51.04 132.71,51.04 132.99,50.76 136.91,50.76 137.19,51.04 140.16,51.04 141.39,49.81 142.27,49.81 142.74,49.34 143.55,49.34 147.36,45.52 153.69,45.52 153.94,45.77 158.11,45.77 158.38,46.04 161.96,46.04 162.29,45.71 164.82,45.71 165.15,46.04 168.52,46.04 169.31,45.25 174.33,45.25 189.55,30.03 190.8,30.03 191.4,29.42 191.4,29.28 191.27,29.14 191.27,29 191.37,28.89 191.52,28.89 191.65,29.03 191.8,29.03 191.91,28.92 191.91,28.77 191.77,28.64 191.77,28.49 191.88,28.39 192.02,28.39 192.16,28.52 192.3,28.52 192.41,28.42 192.41,28.27 192.27,28.14 192.27,27.99 192.38,27.89 192.53,27.89 192.66,28.02 192.81,28.02 193.26,27.56 193.26,26.95 193.16,26.85 192.51,26.85 192.41,26.74 192.41,26.6 192.51,26.49 193.16,26.49 193.26,26.39 193.26,26.24 193.16,26.14 192.51,26.14 192.41,26.03 192.41,25.88 192.51,25.78 193.16,25.78 193.26,25.68 193.26,23.66 193.37,23.56 193.96,23.56 194.07,23.45 194.07,23.31 193.96,23.2 193.37,23.2 193.26,23.1 193.26,22.95 193.37,22.85 193.96,22.85 194.07,22.74 194.07,22.59 193.96,22.49 193.37,22.49 193.26,22.39 193.26,22.24 193.37,22.13 193.96,22.13 194.07,22.03 194.07,21.88 193.96,21.78 193.37,21.78 193.26,21.68 193.26,21.03 195.17,19.12 v1(195.17,18.68)
  BOTTOM w0.076: UC1.AU21 v1(128.34,53.79)
  BOTTOM w0.102: v1(195.17,18.68) 195.17,19.8 195.18,19.8 JDIMM2.245
DDR_B_D59: length 98.2
  IN4 w0.076: v1(128.34,54.44) 129.34,53.44 129.34,52.93 130.15,52.12 130.74,52.12 131.5,51.35 132.9,51.35 133.32,50.93 136.83,50.93 137.24,51.34 137.57,51.34
  IN4 w0.089: 137.57,51.34 140.29,51.34 141.52,50.11 142.39,50.11 142.87,49.64 143.68,49.64 147.49,45.83 151.68,45.83 152.18,46.33 152.53,46.33 152.78,46.08 157.99,46.08 158.25,46.34 162.09,46.34 162.42,46.01 164.69,46.01 165.02,46.34 168.65,46.34 169.44,45.55 174.45,45.55 188.03,31.97 188.24,31.97 188.69,32.42 188.84,32.42 188.94,32.32 188.94,32.17 188.46,31.69 188.46,31.55 188.57,31.44 188.72,31.44 189.19,31.92 189.34,31.92 189.44,31.81 189.44,31.67 188.97,31.19 188.97,31.04 189.07,30.94 189.22,30.94 189.64,31.36 189.79,31.36 189.9,31.26 189.9,31.11 189.45,30.66 189.45,30.56 189.67,30.34 190.92,30.34 193.65,27.61 193.65,24.58 194.52,23.72 194.52,20.45 195.7,19.28 195.7,17.14 195.55,17 195.41,17 v1(195.25,17.15)
  BOTTOM w0.076: UC1.AT21 v1(128.34,54.44)
  BOTTOM w0.102: JDIMM2.249 196.18,17.86 195.47,17.15 v1(195.25,17.15)
DDR_B_D60: length 100.1
  IN4 w0.076: 131.23,48.12 134.66,48.12 ; v1(127.43,56.35) 126.9,55.82 126.88,55.8 126.88,54.28 126.64,54.04 126.64,53.38
  IN4 w0.084: 129.89,49.45 126.75,52.6 126.75,53.27 126.64,53.38
  IN4 w0.089: 134.66,48.12 134.93,48.38 135.71,48.38 135.91,48.59 139.6,48.59 141.41,46.78 141.58,46.78 141.88,46.49 141.88,45.68 142.55,45 144.64,45 146.21,43.44 153.96,43.44 154.21,43.19 159.53,43.19 159.9,43.56 167.66,43.56 168.1,43.12 173.4,43.12 178.78,37.74 178.78,37.6 178.64,37.46 178.64,37.31 178.74,37.2 178.89,37.2 179.03,37.35 179.18,37.35 179.28,37.24 179.28,37.09 179.14,36.95 179.14,36.81 179.24,36.7 179.39,36.7 179.53,36.84 179.68,36.84 179.78,36.74 179.78,36.59 179.64,36.45 179.64,36.3 179.75,36.2 179.89,36.2 180.03,36.34 180.18,36.34 180.29,36.24 180.29,36.09 180.14,35.95 180.14,35.8 180.25,35.7 180.4,35.7 180.54,35.84 180.68,35.84 180.79,35.73 180.79,35.59 180.65,35.44 180.65,35.3 180.75,35.19 180.9,35.19 181.04,35.33 181.19,35.33 181.95,34.57 181.95,33.99 188.59,27.35 189.96,27.35 190.32,26.99 190.32,26.1 190.12,25.9 190.12,25.26 190.32,25.07 190.32,20.29 191.77,18.84 191.77,16 191.32,15.54 191.32,14.21 v1(192.44,13.08) ; 129.89,49.45 131.23,48.12
  BOTTOM w0.076: v1(127.43,56.35) UC1.AN22
  BOTTOM w0.102: v1(192.44,13.08) 192.92,12.6 192.92,11.8 JDIMM2.236
DDR_B_D61: length 99.6
  IN4 w0.076: v1(127.43,55.71) 127.06,55.34 127.06,54.21 126.89,54.04 126.89,53.37 127.19,53.07 127.19,52.41
  IN4 w0.084: 127.19,52.41 127.2,52.41 129.79,49.81
  IN4 w0.089: 129.79,49.81 131.23,48.37 134.66,48.37 134.98,48.69 135.58,48.69 135.8,48.9 139.76,48.9 140.63,48.02 141.4,48.02 142.22,47.2 142.22,45.97 142.71,45.48 144.66,45.48 146.4,43.74 154.43,43.74 154.68,43.99 158.7,43.99 158.79,43.9 167.74,43.9 168.22,43.42 173.63,43.42 182.61,34.45 182.61,34.2 182.47,34.06 182.47,33.91 182.57,33.8 182.72,33.8 182.86,33.95 183.01,33.95 183.11,33.84 183.11,33.69 182.97,33.55 182.97,33.41 183.08,33.3 183.22,33.3 183.36,33.44 183.51,33.44 183.61,33.34 183.61,33.19 183.47,33.05 183.47,32.9 183.58,32.8 183.73,32.8 183.87,32.94 184.01,32.94 184.12,32.84 184.12,32.69 183.98,32.55 183.98,32.4 184.08,32.3 184.23,32.3 184.37,32.44 184.52,32.44 184.62,32.33 184.62,32.19 184.48,32.04 184.48,31.9 184.58,31.79 184.73,31.79 184.87,31.93 185.02,31.93 185.12,31.83 185.12,31.68 184.98,31.54 184.98,31.39 188.67,27.71 190.03,27.71 190.62,27.12 190.62,20.41 192.13,18.91 192.13,16.09 192.83,15.4 192.83,14.8 192.63,14.61 v1(192.37,14.61)
  BOTTOM w0.076: UC1.AP22 v1(127.43,55.71)
  BOTTOM w0.102: v1(192.37,14.61) 191.92,14.16 191.92,11.8 JDIMM2.232
DDR_B_D62: length 98.8
  IN4 w0.076: 129.69,53.44 129.69,55.22 129.18,55.73 v1(129.18,55.76)
  IN4 w0.089: 129.69,53.44 129.97,53.16 130.58,53.16 131.82,51.93 133.53,51.93 133.94,51.52 136.49,51.52 136.94,51.96 140.69,51.96 141.73,50.93 142.44,50.93 143.12,50.25 143.96,50.25 147.77,46.44 151.41,46.44 151.92,46.94 152.78,46.94 153.03,46.69 157.57,46.69 157.83,46.95 162.63,46.95 162.96,46.62 164.44,46.62 164.77,46.95 168.9,46.95 169.69,46.16 174.71,46.16 187.04,33.83 188.29,33.83 194.42,27.71 194.42,24.86 195.15,24.13 195.15,20.87 195.32,20.71 195.45,20.71 195.72,20.98 195.85,20.98 195.97,20.86 195.97,20.73 195.7,20.46 195.7,20.33 195.82,20.2 195.95,20.2 196.24,20.49 196.36,20.49 196.49,20.37 196.49,20.24 196.2,19.95 196.2,19.83 196.42,19.61 196.42,14.09 195.44,13.11 v1(195.43,13.11)
  BOTTOM w0.076: UC1.AP21 128.85,56.09 129.18,55.75 v1(129.18,55.76)
  BOTTOM w0.102: JDIMM2.246 v1(195.43,13.11)
DDR_B_D63: length 99.9
  IN4 w0.076: v1(128.34,56.35) 128.73,55.96 128.73,54.38 129.52,53.59 129.52,53.37 129.79,53.1 129.79,53.09 129.9,52.98 130.13,52.98
  IN4 w0.089: v1(195.39,14.66) 196,15.27 196,19.59 194.83,20.77 194.83,23.84 194.06,24.61 194.06,27.63 190.91,30.78 190.53,30.78 190.3,31.01 190.3,31.39 188.79,32.9 188.64,32.9 188.16,32.42 188.02,32.42 187.91,32.53 187.91,32.68 188.39,33.15 188.39,33.3 188.17,33.52 187.71,33.52 187.53,33.35 187.09,33.35 174.58,45.86 169.56,45.86 168.77,46.65 164.9,46.65 164.57,46.32 162.66,46.32 162.33,46.65 157.97,46.65 157.71,46.38 152.91,46.38 152.65,46.64 152.06,46.64 151.55,46.13 147.63,46.13 143.82,49.95 142.99,49.95 142.52,50.42 141.65,50.42 140.4,51.66 137.08,51.66 136.71,51.29 133.79,51.29 133.41,51.67 131.69,51.67 130.38,52.98 130.13,52.98
  BOTTOM w0.076: UC1.AN21 v1(128.34,56.35)
  BOTTOM w0.102: JDIMM2.250 196.43,13.95 195.72,14.66 v1(195.39,14.66)
DDR_B_DQS0: length 54.1
  IN1 w0.076: 119.4,39.74 119.4,39.75 119.4,39.76 119.4,42.34 119.69,42.63 119.69,47.12 119.65,47.17 119.51,47.17 v1(119.29,46.95)
  IN1 w0.091: v1(134.58,16.44) 134.25,16.77 134.04,16.77 133.82,16.99 133.82,18.36 133.07,19.11 132.12,19.11 125.14,26.1 120.35,26.1 120.11,26.34 120.11,26.68 120.35,26.92 121.13,26.92 121.26,27.05 121.26,27.24 121.13,27.38 120.31,27.38 120.11,27.57 120.11,30.29 120.02,30.38 119.58,30.38 119.38,30.58 119.38,30.92 119.74,31.28 119.74,31.51 119.4,31.85 119.4,39.74
  BOTTOM w0.076: UC1.AY38 119.02,52.47 118.97,52.42 118.87,52.42 118.82,52.37 118.77,52.32 118.66,52.09 118.66,51.92 118.73,51.76 118.73,51.58 118.67,51.46 118.67,51.26 118.72,51.12 118.72,50.89 118.7,50.85 118.6,50.7 118.6,47.34 118.85,47.09 119.15,47.09 119.29,46.95 v1(119.29,46.95)
  BOTTOM w0.099: JDIMM2.13 135.17,19.05 135.42,18.81 135.42,17.03 135,16.62 134.76,16.62 v1(134.58,16.44)
DDR_B_DQS1: length 55
  IN1 w0.076: 123.23,39.74 123.23,39.75 123.22,39.76 123.22,40.06 122.38,40.9 122.38,41.73 122.61,41.96 122.61,42.46 122.38,42.69 122.38,43.98 122.71,44.31 122.85,44.31 123.07,44.08 v1(123.07,43.95)
  IN1 w0.091: 123.23,39.74 123.23,34.57 132.18,25.62 132.18,24.58 133.42,23.34 135.78,23.34 137.33,21.79 137.33,21.45 136.96,21.08 136.96,20.89 137.1,20.76 137.29,20.76 137.66,21.13 137.99,21.13 138.23,20.89 138.23,20.55 138.13,20.44 138.13,20.25 138.26,20.12 138.45,20.12 138.56,20.23 138.9,20.23 139.14,19.99 139.14,19.65 139.03,19.54 139.03,19.35 139.12,19.26 139.16,19.22 139.35,19.22 139.46,19.32 139.8,19.32 139.98,19.14 139.98,15.64 139.76,15.42 139.76,15.16 140.18,14.73 140.18,14.55 140.43,14.3 v1(140.53,14.3)
  BOTTOM w0.076: UC1.BA34 121.47,52.21 121.52,52.26 121.65,52.26 121.68,52.22 121.76,52.05 121.76,51.96 121.7,51.79 121.7,51.54 121.75,51.42 121.75,51.28 121.7,51.14 121.7,50.01 121.77,49.94 121.85,49.86 121.85,49.86 121.9,49.81 121.9,46.24 121.99,46.14 121.99,45.57 121.98,45.56 121.98,45.54
  BOTTOM w0.099: JDIMM2.34 140.42,12.65 140.28,12.8 140.28,14.05 v1(140.53,14.3) ; 121.98,45.54 121.98,44.45 122.31,44.12 122.91,44.12 v1(123.07,43.95)
DDR_B_DQS2: length 93.1
  IN4 w0.076: 121.05,45.19 121.05,45.21 121.05,45.22 121.05,48.86 120.28,49.64 120.28,50.44 118.52,52.2 118.52,52.72 117.77,53.47 117.77,54.72 117.93,54.89 118.16,54.89 118.33,55.06 v1(118.33,55.06)
  IN4 w0.091: 121.05,45.19 121.05,40.6 123.57,38.07 133.57,38.07 138.32,33.32 144.74,33.32 145,33.58 156.37,33.58 157.18,32.77 168.18,32.77 169.99,30.96 170.51,30.96 177.45,24.02 177.45,18.21 177.22,17.98 177.22,16.61 177.47,16.36 177.98,16.36 v1(178.02,16.32)
  BOTTOM w0.076: UC1.AR38 118.74,55.21 118.59,55.06 v1(118.33,55.06)
  BOTTOM w0.099: v1(178.02,16.32) 178.25,16.54 178.6,16.54 178.86,16.8 178.86,18.81 178.68,18.99 JDIMM2.179
DDR_B_DQS3: length 95.6
  IN4 w0.076: 122.29,53.47 122.29,53.49 122.3,53.49 122.3,54.52 122.16,54.65 122.16,54.85 121.94,55.07 v1(121.94,55.08)
  IN4 w0.091: 122.29,53.47 122.29,53.26 122.22,53.18 122.22,52.32 123.57,50.96 123.57,49.36 124.62,48.32 124.81,48.32 125.29,47.83 125.29,42.19 125.73,41.76 127.05,41.76 127.49,42.2 135.89,42.2 139.9,38.19 141.05,38.19 141.65,37.6 149.39,37.6 149.8,37.18 157.87,37.18 158.68,36.37 169.67,36.37 171.48,34.56 172.05,34.56 175.06,31.54 175.91,31.54 180.72,26.73 180.72,25.95 182.17,24.5 182.17,19.13 182.59,18.72 182.59,16.65 182.82,16.42 182.82,15.53 183.95,14.4 184.19,14.4 v1(184.62,13.97)
  BOTTOM w0.076: v1(121.94,55.08) 122.08,55.08 122.4,55.39 UC1.AR32
  BOTTOM w0.099: v1(184.62,13.97) 184.62,14.28 184.42,14.48 184.1,14.48 183.73,14.11 183.73,12.83 183.92,12.64 183.92,12.47 183.93,12.47 JDIMM2.200
DDR_B_DQS4: length 55.4
  IN1 w0.076: v1(124.83,45.78) 124.83,45.83 125.02,46.02 125.17,46.02 125.25,45.94 125.25,41.43 126.74,39.93 126.74,39.76 126.74,39.75 126.74,39.74
  IN1 w0.091: 126.74,39.74 126.74,37.88 133.73,30.88 133.73,30.75 133.51,30.53 133.51,30.19 133.75,29.95 134.09,29.95 134.31,30.17 134.44,30.17 134.63,29.98 134.63,29.85 134.41,29.63 134.41,29.29 134.65,29.05 134.99,29.05 135.21,29.27 135.34,29.27 135.56,29.05 135.56,28.71 138.68,25.6 138.96,25.6 139.12,25.76 139.42,26.06 139.6,26.06 139.74,25.92 139.74,25.73 139.28,25.28 139.28,25 139.58,24.7 139.86,24.7 140.14,24.97 140.32,25.16 140.51,25.16 140.64,25.02 140.64,24.83 140.18,24.37 140.18,24.09 144.72,19.56 144.72,16.98 144.95,16.75 145.22,16.75 145.28,16.69 v1(145.28,16.46)
  BOTTOM w0.076: v1(124.83,45.78) 124.68,45.92 124.38,45.92 124.1,46.2 124.1,48.86 123.64,49.32 123.64,49.46 123.65,49.46 123.65,50.8 123.7,50.89 123.7,51.12 123.66,51.26 123.66,51.46 123.71,51.58 123.71,51.76 123.64,51.92 123.64,52.09 123.75,52.32 123.85,52.42 123.95,52.42 124,52.47 UC1.AY30
  BOTTOM w0.099: v1(145.28,16.46) 145.46,16.64 145.64,16.64 146.01,17.01 146.01,18.75 145.68,19.09 JDIMM2.55
DDR_B_DQS5: length 61.1
  IN1 w0.076: 130.87,39.74 130.87,39.75 130.87,39.75 130.87,39.81 130.88,39.81 130.88,41.11 129.47,42.53 129.47,43.25 128.62,44.11 128.05,44.11 v1(127.82,43.88)
  IN1 w0.091: v1(151.45,14.07) 151.26,14.26 150.75,14.26 150.36,14.65 150.36,15.48 150.85,15.97 150.85,21.67 149.71,22.81 149.13,22.81 148.89,23.05 148.89,23.39 149.19,23.69 149.19,23.82 149,24.02 148.87,24.02 148.56,23.71 148.22,23.71 147.98,23.95 147.98,24.29 148.29,24.6 148.29,24.73 148.1,24.92 147.97,24.92 147.66,24.61 147.32,24.61 147.08,24.85 147.08,25.19 147.39,25.5 147.39,25.63 147.19,25.82 147.06,25.82 146.76,25.52 146.42,25.52 146.18,25.76 146.18,26.09 146.49,26.4 146.49,26.53 146.29,26.72 146.16,26.72 145.86,26.42 145.52,26.42 145.28,26.66 145.28,27 145.58,27.3 145.58,27.43 143.3,29.72 139.98,29.72 130.87,38.84 130.87,39.74
  BOTTOM w0.076: UC1.BA26 126.45,52.21 126.5,52.26 126.63,52.26 126.66,52.22 126.74,52.05 126.74,51.96 126.68,51.79 126.68,51.54 126.73,51.42 126.73,51.28 126.68,51.14 126.68,50.78 126.68,50.78 126.78,50.63 126.87,50.54 126.87,49.24 126.88,49.23 127.06,49.05 127.06,44.39 ; 127.32,44.13 127.32,44.13 127.34,44.13 127.38,44.09 127.62,44.09 v1(127.82,43.88)
  BOTTOM w0.099: JDIMM2.76 150.93,12.7 150.61,13.01 150.61,14.07 150.84,14.29 151.23,14.29 v1(151.45,14.07) ; 127.06,44.39 127.32,44.13
DDR_B_DQS6: length 91.6
  IN4 w0.076: v1(124.68,55.08) 124.68,55.07 125.06,54.69 125.06,53.52 125.64,52.94 125.64,52.11 127.16,50.58 127.16,49.72 127.72,49.16 128.13,49.16 131.11,46.17 132.61,46.17 132.62,46.16 132.75,46.16
  IN4 w0.091: 132.75,46.16 137.11,46.16 137.49,45.79 139.4,43.87 139.93,43.87 141.4,42.4 143.81,42.4 145.01,41.19 151.38,41.19 151.45,41.13 151.64,40.93 170.3,40.93 171.3,39.92 172.71,39.92 173.06,39.57 186.23,26.41 186.23,25.02 187.39,23.85 187.39,22.82 187.59,22.63 187.81,22.63 187.93,22.51 187.93,22.25 187.81,22.13 187.59,22.13 187.39,21.93 187.39,21.47 187.59,21.27 187.76,21.27 187.88,21.15 187.88,20.89 187.76,20.77 187.59,20.77 187.39,20.58 187.39,20.11 187.59,19.91 187.89,19.91 188.01,19.79 188.01,19.54 187.89,19.42 187.59,19.42 187.39,19.22 187.39,17.65 187.7,17.34 187.98,17.34 v1(188.15,17.17)
  BOTTOM w0.076: UC1.AR27 v1(124.68,55.08)
  BOTTOM w0.099: v1(188.15,17.17) 188.15,17.22 188.33,17.4 188.73,17.4 189.17,17.84 189.17,20 JDIMM2.221
DDR_B_DQS7: length 98.1
  IN4 w0.076: 131.16,49.87 130.85,50.18 130.85,50.53 127.81,53.57 127.81,54.58 127.71,54.68 127.71,55.35 127.93,55.57 128.2,55.57 v1(128.34,55.71)
  IN4 w0.091: v1(194.38,13.85) 194.21,14.02 194.2,14.02 194.18,14.04 193.9,14.04 193.55,14.39 193.55,15.29 193.74,15.48 193.74,15.81 194.06,16.12 194.06,17.27 194.18,17.39 194.18,19.15 192.59,20.75 192.59,24.75 191.73,25.6 191.73,27.58 190.48,28.83 189.8,28.83 174.05,44.57 168.69,44.57 168.23,45.03 159.43,45.03 159.36,45.1 154.22,45.1 153.97,44.85 147.08,44.85 143.29,48.63 142.47,48.63 141.98,49.13 141.11,49.13 140.19,50.06 133,50.06 132.26,49.32 131.7,49.32 131.16,49.87
  BOTTOM w0.076: v1(128.34,55.71) 128.61,55.44 UC1.AR21
  BOTTOM w0.099: v1(194.38,13.85) 194.38,14.14 194.25,14.27 194,14.27 193.66,13.94 193.66,13.65 194.11,13.2 194.11,12.81 194.43,12.5 JDIMM2.242
DDR_B_DQS#0: length 54.1
  IN1 w0.076: 119.58,39.74 119.58,39.75 119.57,39.76 119.57,42.28 119.85,42.56 119.85,47.19 119.71,47.33 119.55,47.33 v1(119.29,47.6)
  IN1 w0.091: 119.58,39.74 119.58,31.92 119.92,31.58 119.92,31.2 119.56,30.85 119.56,30.65 119.65,30.56 120.09,30.56 120.29,30.36 120.29,27.65 120.38,27.56 121.2,27.56 121.44,27.32 121.44,26.98 121.2,26.74 120.43,26.74 120.29,26.6 120.29,26.41 120.43,26.28 125.21,26.28 132.2,19.29 133.15,19.29 134,18.44 134,17.07 134.12,16.95 134.29,16.95 v1(134.58,17.25)
  BOTTOM w0.076: v1(119.29,47.6) 119.29,47.41 119.22,47.34 119.13,47.34 119.04,47.26 118.91,47.26 118.77,47.4 118.77,49.87 118.77,50.65 118.84,50.76 118.85,50.78 118.89,50.84 118.89,51.14 118.84,51.28 118.84,51.42 118.89,51.54 118.89,51.79 118.83,51.96 118.83,52.05 118.9,52.22 118.94,52.26 119.06,52.26 119.12,52.21 UC1.BA38
  BOTTOM w0.099: v1(134.58,17.25) 134.58,16.92 134.68,16.82 134.7,16.8 134.92,16.8 135.23,17.11 135.23,18.71 135.09,18.85 134.8,18.85 134.68,18.98 JDIMM2.11
DDR_B_DQS#1: length 55
  IN1 w0.076: 123.05,39.74 123.05,39.75 123.06,39.76 123.06,39.99 122.22,40.83 122.22,41.8 122.45,42.03 122.45,42.4 122.22,42.63 122.22,44.05 122.64,44.48 122.95,44.48 v1(123.07,44.6)
  IN1 w0.091: 123.05,39.74 123.05,34.5 132,25.54 132,24.5 133.35,23.16 135.71,23.16 137.15,21.72 137.15,21.53 136.78,21.16 136.78,20.82 137.02,20.58 137.36,20.58 137.73,20.95 137.92,20.95 138.05,20.81 138.05,20.62 137.95,20.52 137.95,20.18 138.18,19.94 138.52,19.94 138.63,20.05 138.82,20.05 138.96,19.91 138.96,19.72 138.85,19.61 138.85,19.27 139.09,19.03 139.43,19.03 139.53,19.14 139.72,19.14 139.8,19.06 139.8,15.72 139.58,15.49 139.58,15.08 140,14.66 140,14.51 v1(139.79,14.3)
  BOTTOM w0.076: 122.17,45.54 122.17,45.56 122.16,45.57 122.16,46.21 122.06,46.3 122.06,49.88 121.99,49.95 121.87,50.08 121.87,51.12 121.91,51.26 121.91,51.46 121.86,51.58 121.86,51.76 121.93,51.92 121.93,52.09 121.82,52.32 121.71,52.42 121.62,52.42 121.57,52.47 UC1.AY34
  BOTTOM w0.099: 122.17,45.54 122.17,44.53 122.38,44.31 122.78,44.31 v1(123.07,44.6) ; JDIMM2.32 139.93,12.6 140.09,12.76 140.09,14.13 139.92,14.3 v1(139.79,14.3)
DDR_B_DQS#2: length 93.1
  IN4 w0.076: 121.23,45.19 121.23,45.21 121.22,45.22 121.22,48.93 120.45,49.7 120.45,50.51 118.68,52.27 118.68,52.78 117.93,53.54 117.93,54.66 118,54.72 118.15,54.72 118.33,54.54 v1(118.33,54.43)
  IN4 w0.091: 121.23,45.19 121.23,40.68 123.65,38.25 133.64,38.25 138.39,33.5 144.66,33.5 144.92,33.76 156.45,33.76 157.26,32.95 168.25,32.95 170.06,31.14 170.59,31.14 177.63,24.1 177.63,18.13 177.4,17.9 177.4,16.69 177.55,16.54 177.66,16.54 178.02,16.9 v1(178.02,17.22)
  BOTTOM w0.076: UC1.AT38 118.69,54.79 v1(118.33,54.43)
  BOTTOM w0.099: JDIMM2.177 178.18,19.22 178.67,18.73 178.67,16.87 178.52,16.73 178.19,16.73 178.02,16.9 v1(178.02,17.22)
DDR_B_DQS#3: length 95.8
  IN4 w0.076: v1(122.85,55.08) 122.51,55.08 122.33,54.89 122.33,54.72 122.46,54.58 122.46,53.49 122.47,53.49 122.47,53.47
  IN4 w0.091: v1(184.6,14.99) 184.6,14.79 184.39,14.58 184.02,14.58 183,15.6 183,16.49 182.77,16.72 182.77,18.79 182.35,19.21 182.35,24.58 180.9,26.03 180.9,26.8 175.98,31.72 175.14,31.72 172.12,34.74 171.56,34.74 169.75,36.55 158.75,36.55 157.94,37.36 149.88,37.36 149.46,37.78 141.73,37.78 141.13,38.37 139.97,38.37 135.97,42.38 127.42,42.38 126.97,41.94 125.81,41.94 125.48,42.27 125.48,47.9 124.88,48.5 124.7,48.5 123.75,49.44 123.75,51.04 122.4,52.4 122.4,53.11 122.47,53.18 122.47,53.47
  BOTTOM w0.076: v1(122.85,55.08) 122.68,55.08 UC1.AT32
  BOTTOM w0.099: JDIMM2.198 183.43,12.68 183.54,12.79 183.54,12.83 183.54,12.83 183.54,14.19 184.02,14.67 184.41,14.67 184.6,14.86 v1(184.6,14.99)
DDR_B_DQS#4: length 55.4
  IN1 w0.076: 126.92,39.74 126.92,39.75 126.91,39.76 126.91,40 125.42,41.49 125.42,46.01 125.23,46.19 125.06,46.19 v1(124.83,46.43)
  IN1 w0.091: v1(145.3,17.25) 145.3,17.01 145.22,16.93 145.02,16.93 144.9,17.05 144.9,19.63 140.36,24.17 140.36,24.3 140.82,24.76 140.82,25.1 140.58,25.34 140.24,25.34 140.01,25.1 139.78,24.88 139.65,24.88 139.46,25.07 139.46,25.2 139.92,25.66 139.92,26 139.68,26.24 139.34,26.24 138.88,25.78 138.75,25.78 135.74,28.79 135.74,29.12 135.42,29.45 135.14,29.45 134.92,29.23 134.73,29.23 134.59,29.36 134.59,29.55 134.82,29.77 134.82,30.05 134.52,30.35 134.24,30.35 134.01,30.13 133.82,30.13 133.69,30.26 133.69,30.45 133.91,30.68 133.91,30.96 126.92,37.95 126.92,39.74
  BOTTOM w0.076: v1(124.83,46.43) 124.83,46.29 124.62,46.09 124.45,46.09 124.27,46.27 124.27,48.93 123.81,49.39 123.81,50.75 123.87,50.84 123.87,51.14 123.82,51.28 123.82,51.42 123.87,51.54 123.87,51.79 123.81,51.96 123.81,52.05 123.89,52.22 123.92,52.26 124.04,52.26 124.1,52.21 UC1.BA30
  BOTTOM w0.099: v1(145.3,17.25) 145.23,17.17 145.23,16.97 145.35,16.84 145.37,16.84 145.38,16.83 145.57,16.83 145.83,17.09 145.83,18.65 145.55,18.93 145.35,18.93 145.17,19.1 JDIMM2.53
DDR_B_DQS#5: length 61.1
  IN1 w0.076: 131.05,39.74 131.05,41.18 129.63,42.6 129.63,43.32 128.68,44.27 128.03,44.27 v1(127.81,44.49)
  IN1 w0.091: 131.05,39.74 131.05,38.91 140.06,29.9 143.37,29.9 145.76,27.51 145.76,27.23 145.46,26.92 145.46,26.73 145.59,26.6 145.78,26.6 146.09,26.91 146.37,26.91 146.67,26.61 146.67,26.33 146.36,26.02 146.36,25.83 146.49,25.7 146.68,25.7 146.99,26 147.27,26 147.57,25.7 147.57,25.42 147.26,25.12 147.26,24.93 147.4,24.79 147.59,24.79 147.89,25.1 148.17,25.1 148.47,24.8 148.47,24.52 148.16,24.22 148.16,24.03 148.3,23.89 148.49,23.89 148.79,24.2 149.07,24.2 149.37,23.9 149.37,23.62 149.07,23.31 149.07,23.12 149.2,22.99 149.78,22.99 151.03,21.74 151.03,15.89 150.54,15.4 150.54,14.73 150.83,14.44 151.18,14.44 v1(151.45,14.71)
  BOTTOM w0.076: 127.24,44.48 127.23,44.49 127.23,49.12 127.04,49.31 127.04,50.61 126.91,50.74 126.85,50.83 126.85,51.12 126.89,51.26 126.89,51.46 126.84,51.58 126.84,51.76 126.91,51.92 126.91,52.09 126.8,52.32 126.7,52.42 126.64,52.42 126.55,52.52 UC1.AY26 ; 127.45,44.27 127.59,44.27 v1(127.81,44.49)
  BOTTOM w0.099: 127.24,44.48 127.45,44.27 ; JDIMM2.74 150.42,14.15 150.76,14.48 151.22,14.48 v1(151.45,14.71)
DDR_B_DQS#6: length 91.6
  IN4 w0.076: 132.68,46.34 131.18,46.34 128.2,49.32 127.79,49.32 127.33,49.78 127.33,50.65 125.81,52.17 125.81,53.01 125.23,53.59 125.23,54.77 125.54,55.08 v1(125.6,55.08)
  IN4 w0.091: v1(188.19,17.99) 188.19,17.78 187.92,17.52 187.77,17.52 187.57,17.73 187.57,19.14 187.66,19.24 187.96,19.24 188.19,19.46 188.19,19.87 187.96,20.09 187.66,20.09 187.57,20.19 187.57,20.5 187.66,20.59 187.84,20.59 188.06,20.82 188.06,21.22 187.84,21.45 187.66,21.45 187.57,21.54 187.57,21.86 187.66,21.95 187.89,21.95 188.11,22.17 188.11,22.58 187.89,22.81 187.66,22.81 187.57,22.9 187.57,23.93 186.41,25.09 186.41,26.48 172.79,40.11 171.38,40.11 170.37,41.11 151.72,41.11 151.45,41.38 145.09,41.38 143.88,42.58 141.48,42.58 140.01,44.05 139.48,44.05 137.19,46.34 132.68,46.34
  BOTTOM w0.076: UC1.AR25 v1(125.6,55.08)
  BOTTOM w0.099: v1(188.19,17.99) 188.19,17.75 188.34,17.59 188.65,17.59 188.99,17.92 188.99,18.71 188.87,18.83 188.82,18.83 188.68,18.98 JDIMM2.219
