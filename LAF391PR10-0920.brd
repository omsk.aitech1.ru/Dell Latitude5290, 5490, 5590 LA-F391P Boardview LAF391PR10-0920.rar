# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CORE_VID1: length 91.7
  IN1 w0.152: v1(163.12,96.69) 163.28,96.85 163.28,97.19 163.64,97.56 165.08,97.56 165.41,97.89 165.41,101.42 165.16,101.67 165.16,104.5 166.04,105.39 170.22,105.39 172.34,103.28 173.73,103.28 173.88,103.43 173.88,104 v1(173.74,104.14)
  IN2 w0.152: v1(133.81,56.35) 134.29,56.83 134.29,57.45 135.06,58.21 135.67,58.21 135.99,57.89 137.46,57.89 141.19,54.16 143.9,54.16 146.83,57.1 147.73,57.1 148.37,57.73 148.37,58.72 146.99,60.09 146.99,61.13 147.68,61.82 148.93,61.82 149.52,62.42 149.52,63.47 149.43,63.56 149.43,66.06 151.68,68.31 152.52,68.31 153.08,68.87 153.08,69.3 152.89,69.49 152.89,77.36 153.22,77.7 v1(153.22,77.9)
  BOTTOM w0.152: v1(173.74,104.14) 173.74,103.64 PR411.1 ; v1(163.12,96.69) 163.33,96.49 163.33,91.11 162.11,89.89 158.58,89.89 155.38,86.69 155.38,81.96 156.16,81.17 156.16,79.88 155.43,79.14 154.66,79.14 153.42,77.9 v1(153.22,77.9) ; UC1.AN13 133.41,56.74 v1(133.81,56.35)
CPU_B+: length 0.8
  BOTTOM w0.508: v1(60.04,69.8) 60.3,69.8 PR603.2
  vias: v1(63.54,54.71) v1(64.18,54.71) v1(64.27,56.7) v1(64.27,56.1) v1(64.22,55.41) v1(64.99,57.04) v1(65.22,52.88) v1(65.22,52.12) v1(65.64,57.03) v1(65.85,52.88) v1(65.85,52.12) v1(69.37,58.52) v1(69.37,57.88) v1(69.96,58.49) v1(69.96,57.86) v1(70.54,58.48) v1(70.54,57.84) v1(73.59,80.37) v1(73.78,81.07) v1(74.44,81.8) v1(74.44,81.16) v1(74.46,79.61) v1(74.46,78.85) v1(74.9,57.59) v1(75.1,79.61) v1(75.1,78.85) v1(75.52,57.58) v1(75.85,58.99) v1(76.1,57.58) v1(76.43,58.99) v1(76.69,57.6) v1(77.04,58.97) v1(77.63,58.97) v1(78.26,58.77) v1(80.29,60.12) v1(80.29,59.48) v1(81.06,60.12) v1(81.06,59.48) v2(85.92,88.1)
CPU_DP1_AUXN: length 15.8
  TOP w0.094: T281.1 112.96,80.76 113.05,80.85 113.22,80.85 113.41,80.67 113.41,79.79 112.16,78.55 112.16,77.97 112.39,77.74 112.39,76.07 112.04,75.72 110.72,75.72 109.7,74.7 109.7,73.53 111.4,71.82 111.4,70.68 111.5,70.59 111.5,70.27 v1(111.87,69.89)
  BOTTOM w0.076: UC1.G50 112.07,69.89 v1(111.87,69.89)
CPU_DP1_AUXP: length 15.6
  TOP w0.094: v1(111.87,70.52) 111.82,70.52 111.59,70.76 111.59,71.9 109.88,73.61 109.88,74.62 110.8,75.54 112.12,75.54 112.58,75.99 112.58,77.82 112.35,78.05 112.35,78.47 113.59,79.72 113.59,80.74 113.3,81.04 113.05,81.04 112.96,81.13 T282.1
  BOTTOM w0.076: UC1.F50 112.34,70.54 112.22,70.66 112.01,70.66 v1(111.87,70.52)
CPU_DP1_CTRL_CLK: length 176.3
  TOP w0.076: 135.19,67.82 135.17,67.82 135.16,67.81 134.95,67.81 134.89,67.75 134.59,67.75 134.45,67.89 134.11,67.89 133.93,67.7 133.93,67.49 v1(133.68,67.24)
  TOP w0.094: RC175.1 146.4,67 145.76,67 144.33,68.43 140.32,68.43 139.56,67.67 138.93,67.67 138.49,68.12 136.17,68.12 135.87,67.82 135.19,67.82
  IN1 w0.076: 133.35,66.87 133.37,66.87 133.38,66.87 133.72,66.87 133.83,66.97 133.83,67.1 v1(133.68,67.24)
  IN1 w0.089: v1(24.74,48.1) 24.52,48.32 24.4,48.32 24.07,48.32 23.85,48.54 23.85,49.17 24.36,49.68 28.06,49.68 29.47,51.09 29.47,52.95 33.68,57.17 33.68,60.68 35.18,62.18 36.55,62.18 37.42,63.04 43.52,63.04 45.42,64.94 53.31,64.94 54.03,65.66 54.18,65.66 54.18,65.66 56.27,65.66 58.22,67.61 58.22,69.52 60,71.29 60,74.52 61.95,76.47 61.95,79.26 65.4,82.7 69.14,82.7 72.06,85.62 72.78,85.62 74.08,86.92 74.46,86.92 75.11,87.58 75.67,87.58 76.89,88.8 77.88,88.8 78.72,89.63 83.09,89.63 85.48,92.02 88.2,92.02 88.88,92.71 93.24,92.71 93.82,92.13 100.96,92.13 103.87,89.23 103.87,84.88 105.37,83.38 105.37,81.63 106.69,80.31 106.69,79.33 106.58,79.23 106.58,78.31 108.88,76.01 108.88,75.45 109.84,74.49 109.84,74.16 110.59,73.4 116.18,73.4 117.81,71.78 119.21,71.78 119.26,71.73 120.88,71.73 121.21,72.05 122.18,72.05 122.46,71.78 123.15,71.78 124.41,70.51 124.41,69.54 125.1,68.86 127.97,68.86 128.38,68.45 128.38,67.62 129.12,66.88 133.35,66.88 133.35,66.87
  BOTTOM w0.076: UC1.L13 133.07,67.43 133.07,67.31 133.14,67.24 v1(133.68,67.24)
  BOTTOM w0.094: v1(24.74,48.1) 24.54,48.3 23.76,48.3 23.72,48.27 23.12,48.27 23.09,48.3 22.86,48.3 22.03,49.13 22.03,49.73 21.54,50.21 QV3.1
CPU_DP1_CTRL_DATA: length 176.3
  TOP w0.076: 135.19,67.64 135.17,67.64 135.16,67.65 135.02,67.65 134.96,67.59 134.52,67.59 134.38,67.73 134.18,67.73 134.09,67.64 134.09,67.47 v1(134.32,67.24)
  TOP w0.094: RC178.1 146.23,66.82 145.69,66.82 144.26,68.25 140.4,68.25 139.64,67.48 138.86,67.48 138.41,67.93 136.24,67.93 135.95,67.64 135.19,67.64
  IN1 w0.076: v1(134.32,67.24) 134.21,67.24 133.99,67.03 133.99,66.9 133.79,66.7 133.38,66.7 133.37,66.7 133.35,66.7
  IN1 w0.089: 133.35,66.7 129.05,66.7 128.2,67.55 128.2,68.37 127.9,68.68 125.02,68.68 124.23,69.47 124.23,70.44 123.07,71.6 122.38,71.6 122.11,71.87 121.28,71.87 120.96,71.55 119.18,71.55 119.13,71.6 117.73,71.6 116.11,73.22 110.52,73.22 109.66,74.09 109.66,74.42 108.7,75.37 108.7,75.94 106.4,78.24 106.4,79.3 106.51,79.41 106.51,80.23 105.19,81.56 105.19,83.31 103.69,84.81 103.69,89.15 100.89,91.95 93.74,91.95 93.16,92.53 88.96,92.53 88.27,91.84 85.55,91.84 83.16,89.45 78.79,89.45 77.96,88.62 76.97,88.62 75.74,87.4 75.19,87.4 74.53,86.74 74.15,86.74 72.85,85.44 72.14,85.44 69.22,82.52 65.47,82.52 62.13,79.18 62.13,76.4 60.18,74.45 60.18,71.22 58.4,69.44 58.4,67.54 56.35,65.48 54.1,65.48 53.38,64.76 45.49,64.76 43.59,62.86 37.5,62.86 36.63,62 35.26,62 33.86,60.6 33.86,57.09 29.65,52.88 29.65,51.02 28.13,49.5 24.44,49.5 24.03,49.09 24.03,48.61 24.15,48.5 24.4,48.5 24.52,48.5 v1(24.74,48.71)
  BOTTOM w0.076: UC1.L12 133.99,67.68 v1(134.32,67.24)
  BOTTOM w0.094: v1(24.74,48.71) 24.52,48.48 v4(23.42,48.48) 22.94,48.48 22.21,49.21 22.21,49.81 21.72,50.3 21.72,50.75 22.49,51.51 QV3.4
CPU_DP1_HPD: length 175.1
  TOP w0.102: v2(14.43,54.66) v1(15.04,54.66) RV20.1 15.85,53.64 QV5.3
  IN1 w0.089: v1(136.18,67.22) 136.16,67.22 135.76,66.83 135.24,66.83 135,66.59 135,66.1 134.66,65.75 133.66,65.75 133.27,65.37 127.76,65.37 125.66,67.47 123.19,67.47 122.91,67.74 122.91,68.45 122.07,69.3 116.41,69.3 116.24,69.47 109.07,69.47 108.73,69.81 108.73,71.46 107.41,72.78 107.41,75.34 104.33,78.42 104.33,78.81 103.68,79.45 103.68,82.42 102.41,83.69 102.41,88.62 100.35,90.68 93.23,90.68 92.65,91.26 89.49,91.26 88.8,90.57 86.11,90.57 83.52,87.98 82.55,87.98 80.94,86.37 75.13,86.37 74.82,86.05 74.44,86.05 72.15,83.77 71.24,83.77 70.65,83.18 v1(70.51,83.18) ; v1(46.28,85.77) 46.16,85.9 41.84,85.9 37.81,81.87 31.26,81.87 30.02,80.63 28.47,80.63 26.66,78.83 25.63,78.83 25.26,78.46 25.26,75.68 24.69,75.1 21.39,75.1 19.66,73.38 19.66,64.82 20.42,64.05 20.76,64.05 21.14,63.67 21.14,61.39 20.12,60.37 20.12,59.48 18.47,57.83 17.58,57.83 15.04,55.29 v1(15.04,54.66)
  IN2 w0.122: v1(70.51,83.18) 69.77,83.93 62.1,83.93 61.21,83.04 57.04,83.04 55.74,84.34 52.47,84.34 51.04,82.91 50.16,82.91 47.3,85.77 v1(46.28,85.77)
  BOTTOM w0.076: UC1.L9 136.18,67.42 v1(136.18,67.22)
CPU_DP1_N0: length 139.6
  IN4 w0.089: v1(21.59,43.58) 21.18,43.18 20.42,43.18 20.12,43.48 20.12,49.32 20.91,50.11 22.15,50.11 23.05,51.01 25.47,51.01 26.19,51.74 29.65,51.74 30.66,52.75 33.43,52.75 35.54,54.86 36.25,54.86 37.11,55.72 37.11,56.84 37.55,57.27 37.55,62.94 41.64,67.03 41.64,68.93 44.45,71.75 45.72,71.75 48.58,74.61 50.23,74.61 53.27,77.64 56.17,77.64 62.21,83.69 62.87,83.69 65.03,85.85 70.16,85.85 71.23,86.91 72.67,86.91 73.59,87.83 74.88,87.83 75.11,88.06 76.36,88.06 76.92,88.62 84.54,88.62 86.59,90.67 88.71,90.67 89.47,91.43 92.41,91.43 93.5,90.34 100.22,90.34 102.18,88.39 102.18,81.8 102.47,81.51 102.47,79.14 101.85,78.52 101.85,76.91 102.54,76.21 102.54,75.55 104.26,73.83 106.64,73.83 107.55,72.92 108.28,72.92 109.4,71.8 109.53,71.8 109.73,71.6 109.73,71.01 109.63,70.92 109.45,70.92 109.23,71.14 v1(109.23,71.29)
  BOTTOM w0.076: v1(109.23,71.29) 109.34,71.4 109.62,71.4 109.8,71.22 109.8,71.14 UC1.E55
  BOTTOM w0.094: CV32.1 20.64,43.42 20.75,43.31 21.32,43.31 v1(21.59,43.58)
CPU_DP1_N1: length 131.2
  IN4 w0.089: v1(107.29,71.16) 107.07,70.94 106.81,70.94 106.08,71.67 105.49,71.67 105.24,71.93 99.6,71.93 97.72,73.81 97.72,78.71 97.92,78.91 98.05,78.91 98.71,79.58 98.71,79.98 99.01,80.28 99.01,81.5 100.6,83.09 100.6,87.78 99.61,88.77 92.86,88.77 92.53,89.1 87.2,89.1 84.97,86.86 84.18,86.86 83.22,85.9 73.84,85.9 73.28,85.34 71.83,85.34 69.75,83.26 66.05,83.26 63.79,81 62.47,81 59.43,77.96 59.43,76.88 54.1,71.56 54.1,65.78 52.56,64.24 44.92,64.24 39.65,58.97 39.65,56.59 38.74,55.67 38.74,54.55 38.1,53.92 38.1,53.46 36.8,52.16 35.05,52.16 34.04,51.15 31.41,51.15 29.66,49.4 24.51,49.4 22.17,47.05 21.78,47.05 v1(21.6,47.23)
  BOTTOM w0.076: UC1.E58 v1(107.29,71.16)
  BOTTOM w0.094: v1(21.6,47.23) 21.43,47.05 20.94,47.05 CV34.1
CPU_DP1_N2: length 139.6
  IN4 w0.089: v1(110.06,70.48) 110.54,70.01 110.54,69.39 110.23,69.08 109.07,69.08 108.65,69.51 108.65,71.68 107.99,72.34 107.3,72.34 106.38,73.25 102.24,73.25 100.28,75.21 100.28,76.4 101.25,77.36 101.25,78.73 101.83,79.32 101.83,80.41 101.59,80.65 101.59,88.16 99.99,89.76 93.25,89.76 92.16,90.85 89.7,90.85 88.93,90.09 86.82,90.09 84.76,88.03 81.94,88.03 81.38,87.47 75.44,87.47 75.14,87.17 73.74,87.17 72.9,86.33 71.45,86.33 70.26,85.13 65.54,85.13 63.45,83.05 62.4,83.05 56.31,76.96 53.47,76.96 49.46,72.94 48.06,72.94 44.71,69.59 43.44,69.59 42.65,68.81 42.65,67.17 41.08,65.6 41.08,63.29 38.26,60.48 38.26,56.92 37.7,56.36 37.7,55.21 36.71,54.22 35.71,54.22 33.66,52.17 30.97,52.17 29.9,51.1 26.37,51.1 25.71,50.44 23.37,50.44 22.43,49.5 21.19,49.5 20.81,49.12 20.81,45.46 21,45.27 21.51,45.27 v1(21.6,45.36)
  BOTTOM w0.076: UC1.F53 110.24,70.28 110.06,70.46 v1(110.06,70.48)
  BOTTOM w0.094: CV36.1 20.91,45.3 21.55,45.3 v1(21.6,45.36)
CPU_DP1_N3: length 129.2
  IN4 w0.089: v1(108.26,70.61) 108.05,70.41 107.92,70.41 107.85,70.48 107.85,71.53 107.54,71.85 107.07,71.85 106.1,72.82 101.71,72.82 99.88,74.65 99.88,79.4 100.46,79.98 100.46,82.12 101.19,82.84 101.19,88.01 99.84,89.36 93.09,89.36 92.77,89.68 86.97,89.68 84.79,87.5 83.93,87.5 82.91,86.49 73.62,86.49 73.05,85.92 71.61,85.92 69.6,83.92 65.08,83.92 63.76,82.6 62.79,82.6 57.97,77.77 57.97,76.25 53.45,71.73 47.86,71.73 45.79,69.65 45.79,68.76 41.91,64.89 41.91,62.73 38.74,59.56 38.74,56.69 38.13,56.08 38.13,54.86 37.52,54.25 37.52,53.73 36.52,52.73 34.79,52.73 33.8,51.74 31.17,51.74 29.45,50.01 24.19,50.01 22.93,48.75 21.84,48.75 v1(21.61,48.98)
  BOTTOM w0.076: UC1.F56 108.59,70.28 v1(108.26,70.61)
  BOTTOM w0.094: v1(21.61,48.98) 21.41,48.78 20.99,48.78 CV38.2
CPU_DP1_P0: length 139.6
  IN4 w0.089: v1(21.59,43) 20.35,43 19.94,43.41 19.94,49.4 20.83,50.29 22.08,50.29 22.98,51.19 25.39,51.19 26.12,51.92 29.57,51.92 30.58,52.93 33.35,52.93 35.46,55.04 36.18,55.04 36.93,55.8 36.93,56.92 37.37,57.35 37.37,63.01 41.46,67.1 41.46,69.01 44.38,71.93 45.65,71.93 48.51,74.79 50.16,74.79 53.19,77.82 56.1,77.82 62.14,83.87 62.79,83.87 64.95,86.03 70.08,86.03 71.15,87.1 72.6,87.1 73.51,88.01 74.81,88.01 75.04,88.24 76.28,88.24 76.84,88.8 84.46,88.8 86.52,90.85 88.63,90.85 89.39,91.61 92.48,91.61 93.57,90.52 100.29,90.52 102.36,88.46 102.36,81.87 102.65,81.58 102.65,79.07 102.03,78.45 102.03,76.98 102.72,76.28 102.72,75.62 104.34,74.01 106.71,74.01 107.62,73.1 108.36,73.1 109.48,71.98 109.6,71.98 109.91,71.67 109.91,70.94 109.71,70.74 109.34,70.74 v1(109.21,70.61)
  BOTTOM w0.076: v1(109.21,70.61) 109.54,70.28 UC1.F55
  BOTTOM w0.094: v1(21.59,43) 21.46,43.13 20.92,43.13 CV31.1
CPU_DP1_P1: length 131.3
  IN4 w0.089: v1(107.29,70.53) 107.05,70.76 106.74,70.76 106,71.49 105.42,71.49 105.16,71.75 99.52,71.75 97.54,73.73 97.54,78.79 97.85,79.09 97.97,79.09 98.53,79.65 98.53,80.06 98.83,80.36 98.83,81.58 100.42,83.17 100.42,87.7 99.53,88.59 92.79,88.59 92.46,88.92 87.28,88.92 85.04,86.68 84.25,86.68 83.29,85.72 73.92,85.72 73.36,85.16 71.91,85.16 69.83,83.08 66.12,83.08 63.86,80.82 62.54,80.82 59.61,77.88 59.61,76.81 54.28,71.48 54.28,65.71 52.63,64.05 44.99,64.05 39.83,58.9 39.83,56.51 38.92,55.6 38.92,54.48 38.28,53.85 38.28,53.39 36.87,51.98 35.12,51.98 34.12,50.97 31.49,50.97 29.73,49.22 24.59,49.22 22.24,46.87 21.83,46.87 v1(21.6,46.64)
  BOTTOM w0.076: v1(107.29,70.53) UC1.F58
  BOTTOM w0.094: v1(21.6,46.64) 21.38,46.87 21.04,46.87 CV33.1
CPU_DP1_P2: length 139.8
  IN4 w0.089: v1(110.05,69.88) 110.26,69.88 110.36,69.78 110.36,69.46 110.15,69.26 109.15,69.26 108.83,69.58 108.83,71.75 108.07,72.52 107.37,72.52 106.46,73.43 102.31,73.43 100.46,75.28 100.46,76.32 101.43,77.29 101.43,78.66 102.01,79.24 102.01,80.49 101.77,80.73 101.77,88.23 100.07,89.94 93.32,89.94 92.23,91.03 89.62,91.03 88.86,90.27 86.74,90.27 84.69,88.21 81.87,88.21 81.31,87.65 75.37,87.65 75.06,87.35 73.67,87.35 72.82,86.51 71.38,86.51 70.18,85.31 65.46,85.31 63.38,83.23 62.33,83.23 56.23,77.14 53.39,77.14 49.38,73.13 47.99,73.13 44.63,69.77 43.36,69.77 42.47,68.88 42.47,67.25 40.9,65.67 40.9,63.37 38.08,60.55 38.08,56.99 37.52,56.43 37.52,55.29 36.63,54.4 35.64,54.4 33.58,52.35 30.89,52.35 29.83,51.28 26.3,51.28 25.63,50.62 23.3,50.62 22.36,49.68 21.11,49.68 20.63,49.2 20.63,45.38 20.92,45.09 21.29,45.09 v1(21.6,44.78)
  BOTTOM w0.076: v1(110.05,69.88) 110.25,69.88 UC1.G53
  BOTTOM w0.094: CV35.1 20.64,44.87 20.89,45.12 21.26,45.12 v1(21.6,44.78)
CPU_DP1_P3: length 129.2
  IN4 w0.089: v1(108.26,69.98) 108.01,70.23 107.84,70.23 107.67,70.4 107.67,71.46 107.46,71.67 107,71.67 106.03,72.64 101.63,72.64 99.7,74.57 99.7,79.47 100.28,80.06 100.28,82.19 101,82.91 101,87.93 99.76,89.18 93.02,89.18 92.69,89.5 87.05,89.5 84.87,87.32 84,87.32 82.99,86.31 73.69,86.31 73.13,85.74 71.68,85.74 69.67,83.74 65.15,83.74 63.83,82.42 62.87,82.42 58.15,77.7 58.15,76.17 53.52,71.55 47.93,71.55 45.97,69.58 45.97,68.69 42.09,64.82 42.09,62.66 38.92,59.49 38.92,56.61 38.31,56 38.31,54.78 37.7,54.18 37.7,53.66 36.6,52.55 34.87,52.55 33.88,51.56 31.25,51.56 29.52,49.83 24.26,49.83 23,48.57 21.78,48.57 v1(21.61,48.4)
  BOTTOM w0.076: UC1.G56 108.61,69.63 v1(108.26,69.98)
  BOTTOM w0.094: CV37.2 20.99,48.6 21.41,48.6 v1(21.61,48.4)
CPU_DP2_AUXN: length 104.7
  TOP w0.094: CV95.1 173.64,82.85 173.85,82.85 174.41,82.29 174.41,82.13 174.89,81.65 176.17,81.65 v1(176.37,81.85)
  IN1 w0.089: v1(114.33,82.51) 114.53,82.3 116.65,82.3 117.93,81.02 119.76,81.02 120.81,79.98 127.53,79.98 129.6,77.92 129.6,77.55 131.97,75.18 133.25,75.18 133.66,75.59 133.66,77.06 133.25,77.47 133.25,77.65 132.77,78.13 132.77,78.61 132.89,78.73 132.89,82.09 137.97,87.17 138.67,87.17 140.07,88.57 141.63,88.57 144.28,91.21 151.01,91.21 152.3,89.91 157.46,89.91 158.81,88.57 160.91,88.57 164.26,85.22 170.18,85.22 173.89,81.51 176.02,81.51 v1(176.37,81.85)
  IN4 w0.089: v1(114.33,82.51) 114.13,82.3 113.83,82.3 113.59,82.06 113.59,80.49 114.86,79.22 114.86,73.89 116.08,72.67 116.08,69.59 115.83,69.34 113.69,69.34 113.36,69.67 113.36,70.1 113.49,70.24 113.49,70.71 113.21,70.99 112.95,70.99 v1(112.79,71.15)
  BOTTOM w0.076: v1(112.79,71.15) 113,70.94 113.24,70.94 UC1.E48
CPU_DP2_AUXN_C: length 1.9
  TOP w0.094: UV7.25 171.59,82.97 171.7,82.86 172.05,82.86 172.06,82.85 172.67,82.85 CV95.2
CPU_DP2_AUXP: length 104.7
  TOP w0.094: CV94.1 173.64,82.67 173.78,82.67 174.23,82.22 174.23,82.05 174.81,81.47 176.17,81.47 v1(176.37,81.27)
  IN1 w0.089: v1(114.33,81.92) 114.53,82.12 116.58,82.12 117.86,80.84 119.69,80.84 120.73,79.8 127.45,79.8 129.41,77.84 129.41,77.48 131.89,75 133.33,75 133.84,75.51 133.84,77.14 133.43,77.54 133.43,77.72 132.95,78.2 132.95,78.53 133.07,78.66 133.07,82.01 138.05,86.99 138.75,86.99 140.15,88.39 141.71,88.39 144.35,91.03 150.93,91.03 152.23,89.73 157.38,89.73 158.73,88.39 160.84,88.39 164.19,85.04 170.11,85.04 173.82,81.33 176.31,81.33 v1(176.37,81.27)
  IN4 w0.089: v1(114.33,81.92) 114.13,82.12 113.91,82.12 113.77,81.99 113.77,80.56 115.04,79.29 115.04,73.96 116.26,72.74 116.26,69.52 115.9,69.16 113.61,69.16 113.18,69.6 113.18,70.18 113.31,70.31 113.31,70.64 113.14,70.81 112.98,70.81 112.79,70.63 v1(112.79,70.52)
  BOTTOM w0.076: v1(112.79,70.52) 113.01,70.52 UC1.F48
CPU_DP2_AUXP_C: length 1.9
  TOP w0.094: CV94.2 172.67,82.66 171.98,82.66 171.97,82.68 171.71,82.68 171.6,82.57 UV7.24
CPU_DP2_CTRL_CLK: length 55.3
  TOP w0.102: v1(153.92,73) 154.02,72.89 154.51,72.89 155.36,73.75 155.36,75.08 155.26,75.18 RC176.1 155.37,75.64 155.37,76.07 155.9,76.6 v4(158.11,76.6) 162.37,76.6 163.73,75.23 170.24,75.23 174.65,79.65 174.65,80.21 173.23,81.63 171.73,81.63 171.6,81.77 UV7.22
  IN1 w0.076: 140.04,69.71 140.03,69.7 139.81,69.7 138.1,67.99 137.24,67.99 137.12,67.87 137.12,67.65 v1(137.54,67.23)
  IN1 w0.089: v1(153.92,73) 154.04,72.88 154.35,72.88 154.72,72.5 154.72,71.94 154.28,71.5 152.01,71.5 151.13,70.61 147.77,70.61 146.53,71.85 142.3,71.85 141.74,71.29 140.58,71.29 140.22,70.94 140.22,69.9 140.04,69.71
  BOTTOM w0.076: UC1.N7 v1(137.54,67.23)
CPU_DP2_CTRL_DATA: length 55.4
  TOP w0.102: UV7.23 171.6,82.17 171.65,82.11 173.43,82.11 175.14,80.41 175.14,79.45 170.44,74.75 163.53,74.75 162.17,76.11 156.1,76.11 155.85,75.87 155.85,75.64 RC177.1 155.85,74.71 155.85,73.54 154.71,72.41 v1(153.92,72.41)
  IN1 w0.076: v1(136.96,67.26) 136.96,67.94 137.17,68.16 138.04,68.16 139.69,69.82 139.69,70.03 139.71,70.04
  IN1 w0.089: 139.71,70.04 139.75,70.09 139.75,71.13 140.39,71.76 141.54,71.76 142.1,72.32 146.73,72.32 147.97,71.08 150.93,71.08 151.82,71.97 154.09,71.97 154.25,72.13 154.25,72.31 154.15,72.41 v1(153.92,72.41)
  BOTTOM w0.076: UC1.N8 v1(136.96,67.26)
CPU_DP2_HPD: length 41.1
  TOP w0.102: UV7.3 163.59,80.01 v1(163.4,79.83) ; v1(137.54,68.66) 137.66,68.78 138.66,68.78 139.07,69.19 143.67,69.19 144.06,69.59 144.06,70.02 144.5,70.47 144.5,71.67 143.23,72.94 143.23,76.22 143.47,76.46 143.47,77.11 143.61,77.25 143.61,78.32 144.72,79.42 144.73,79.42 145.54,80.23 146.59,80.23 147.89,81.53 v2(148.49,81.53) 150.37,81.53 150.8,81.96 v1(153.73,81.96)
  IN4 w0.089: v1(153.73,81.96) 155.43,81.96 157.95,79.43 163.01,79.43 v1(163.4,79.83)
  BOTTOM w0.076: v1(137.54,68.66) 137.57,68.63 137.57,68.1 137.22,67.75 UC1.L7
CPU_DP2_N0: length 79.6
  TOP w0.094: CV87.1 164.77,78.11 164.77,77.91 v1(164.97,77.71)
  IN1 w0.089: v1(112.84,78.22) 112.84,78.82 113.29,79.27 115.27,79.27 117.81,76.73 125.37,76.73 125.91,76.19 125.91,74.55 126.14,74.32 126.14,73.48 126.77,72.85 134.78,72.85 136.25,74.32 136.25,74.93 136.48,75.15 136.48,77.39 136.12,77.75 136.12,79.47 144.1,87.45 150.78,87.45 154.38,83.84 157,83.84 157.54,83.31 159.72,83.31 162.21,80.82 164.35,80.82 164.97,80.2 v1(164.97,77.71)
  BOTTOM w0.076: 112.9,75.8 112.9,75.78 112.91,75.77 112.91,75.38 112.56,75.04 112.56,73.54 112.53,73.44 112.53,73.19 112.56,73.1 112.56,72.89 112.5,72.76 112.42,72.68 112.3,72.68 112.22,72.6 112.22,72.43 UC1.C50
  BOTTOM w0.094: v1(112.84,78.22) 112.68,78.22 112.59,78.13 112.59,77.87 112.68,77.78 112.96,77.78 113.06,77.69 113.06,77.33 112.9,77.17 112.9,75.8
CPU_DP2_N0_C: length 2
  TOP w0.094: UV7.7 165.19,80.17 165.08,80.06 165.08,79.5 164.77,79.19 164.77,79.08 CV87.2
CPU_DP2_N1: length 100.4
  TOP w0.094: v1(167.33,77.23) 167.25,77.31 167.12,77.31 167.01,77.2 167.01,76.92 166.93,76.83 166.55,76.83 166.18,77.2 166.18,77.26 166.09,77.34 166.09,77.8 166.18,77.9 166.56,77.9 166.65,77.99 166.65,78.13 CV89.1
  IN1 w0.089: v1(167.33,77.23) 167.45,77.35 167.66,77.35 167.75,77.26 167.75,76.92 167.83,76.83 169.88,76.83 170.82,77.77 170.82,80.08 168.56,82.34 168.56,82.89 167.79,83.66 163.25,83.66 159.7,87.22 158.98,87.22 157.74,88.46 152.58,88.46 150.65,90.39 144.53,90.39 141.94,87.8 140.39,87.8 138.99,86.4 138.29,86.4 133.66,81.77 133.66,80.39 134.01,80.03 134.01,77.77 134.42,77.37 134.42,75.28 133.56,74.42 131.66,74.42 128.83,77.25 128.83,77.6 127.52,78.91 120.81,78.91 119.46,80.26 117.63,80.26 117.05,80.84 114.41,80.84 113.85,81.4 111.21,81.4 110.24,80.44 110.24,78.94 110.12,78.81 110.12,78.48 110.27,78.33 110.4,78.33 110.52,78.46 110.57,78.46 110.69,78.58 v1(110.69,78.64)
  BOTTOM w0.076: UC1.C52 111.23,72.35 111.31,72.43 111.31,72.55 111.19,72.67 111.01,72.67 110.97,72.71 110.9,72.91 110.9,73.08 110.96,73.28 110.96,73.43 110.9,73.54 110.9,73.82 111.17,74.08 111.17,74.86 110.8,75.23 110.8,75.9 110.81,75.91 110.81,75.93
  BOTTOM w0.094: v1(110.69,78.64) 111.31,78.02 111.31,77.16 110.81,76.66 110.81,75.93
CPU_DP2_N1_C: length 1.9
  TOP w0.094: CV89.2 166.28,79.08 166.28,80.04 166.39,80.15 UV7.10
CPU_DP2_N2: length 83.2
  TOP w0.094: CV91.1 167.44,78.11 167.44,77.96 v1(167.64,77.76)
  IN1 w0.089: v1(111.73,77.87) 111.84,77.77 112.11,77.77 112.2,77.86 112.2,79.37 112.68,79.85 116.64,79.85 117.22,79.27 119.05,79.27 121.01,77.32 125.99,77.32 126.5,76.81 126.5,74.77 126.83,74.44 126.83,74.06 127.46,73.43 134.55,73.43 135.23,74.11 135.23,74.72 135.89,75.38 135.89,77.16 135.54,77.52 135.54,79.78 143.79,88.04 151.49,88.04 152.07,87.45 155.53,87.45 158.07,84.91 158.07,84.3 158.47,83.89 160.56,83.89 162.98,81.47 165.32,81.47 165.66,81.13 166.37,81.13 167.64,79.86 v1(167.64,77.76)
  BOTTOM w0.076: UC1.A50 112.3,73.54 112.22,73.47 112.1,73.47 112,73.56 112,74.1 112.27,74.37 112.27,75.23 112.47,75.44 112.47,75.8
  BOTTOM w0.094: 112.47,75.8 112.47,77.33 112.15,77.65 111.95,77.65 v1(111.73,77.87)
CPU_DP2_N2_C: length 1.9
  TOP w0.094: CV91.2 167.44,79.08 167.44,79.63 167.48,79.68 167.48,80.05 167.59,80.15 UV7.13
CPU_DP2_N3: length 90.8
  TOP w0.094: CV93.1 168.88,78.12 168.88,77.85 v1(169.08,77.66)
  IN1 w0.089: v1(169.08,77.66) 168.88,77.86 168.88,79.97 166.32,82.52 162.74,82.52 160.59,84.68 160.59,85.44 159.21,86.82 158.83,86.82 157.59,88.06 152.35,88.06 151.79,88.62 143.36,88.62 140.77,86.03 139.25,86.03 135.82,82.6 135.82,80.95 134.42,79.55 134.42,77.95 134.82,77.54 134.82,75.13 133.71,74.01 127.76,74.01 127.59,74.19 127.59,75.71 127.49,75.82 127.49,76.7 125.73,78.46 120.7,78.46 119.31,79.86 117.45,79.86 116.87,80.44 114.25,80.44 113.69,81 112.02,81 111.13,80.11 111.13,77.01 111.46,76.68 112.2,76.68 112.45,76.42 112.45,75.97 112.17,75.69 111.77,75.69 111.65,75.81 111.65,75.93 v1(111.86,76.15)
  BOTTOM w0.076: 111.82,75.76 111.82,75.1 111.65,74.94 111.65,73.42 112.03,73.04 112.03,72.55 111.73,72.26 UC1.D51
  BOTTOM w0.094: 111.82,75.76 111.82,76.1 v1(111.86,76.15)
CPU_DP2_N3_C: length 2
  TOP w0.094: CV93.2 168.87,79.08 168.87,79.63 168.68,79.83 168.68,80.03 168.79,80.13 UV7.16
CPU_DP2_P0: length 79.6
  TOP w0.094: v1(164.39,77.71) 164.59,77.91 164.59,78.11 CV86.1
  IN1 w0.089: v1(113.42,78.22) 113.42,78.43 113.34,78.51 113.12,78.51 113.02,78.61 113.02,78.75 113.36,79.09 115.19,79.09 117.73,76.55 125.3,76.55 125.73,76.12 125.73,74.47 125.96,74.24 125.96,73.4 126.7,72.67 134.85,72.67 136.43,74.24 136.43,74.85 136.66,75.08 136.66,77.47 136.3,77.82 136.3,79.4 144.17,87.27 150.7,87.27 154.31,83.66 156.92,83.66 157.46,83.13 159.64,83.13 162.13,80.64 164.28,80.64 164.79,80.13 164.79,78.11 v1(164.39,77.71)
  BOTTOM w0.076: UC1.D50 112.61,72.01 112.61,72.59 112.73,72.85 112.73,73.13 112.69,73.22 112.69,73.42 112.73,73.51 112.73,74.97 113.07,75.31 113.07,75.77 113.08,75.78 113.08,75.8
  BOTTOM w0.094: 113.08,75.8 113.08,77.09 113.24,77.25 113.24,78.04 v1(113.42,78.22)
CPU_DP2_P0_C: length 2
  TOP w0.094: CV86.2 164.59,79.08 164.59,79.27 164.89,79.58 164.89,80.06 164.79,80.17 UV7.6
CPU_DP2_P1: length 100.4
  TOP w0.094: CV88.1 165.9,77.27 165.99,77.18 165.99,77.13 166.47,76.65 v1(167.33,76.65)
  IN1 w0.089: v1(110.69,78.05) 110.59,78.15 110.19,78.15 109.94,78.41 109.94,78.89 110.06,79.01 110.06,80.51 111.13,81.58 113.92,81.58 114.48,81.02 117.12,81.02 117.71,80.44 119.54,80.44 120.88,79.09 127.6,79.09 129.01,77.68 129.01,77.32 131.73,74.6 133.48,74.6 134.24,75.36 134.24,77.29 133.83,77.7 133.83,79.96 133.48,80.31 133.48,81.85 138.22,86.58 138.92,86.58 140.31,87.98 141.86,87.98 144.45,90.57 150.73,90.57 152.66,88.64 157.81,88.64 159.06,87.4 159.77,87.4 163.33,83.84 167.86,83.84 168.74,82.97 168.74,82.42 171,80.16 171,77.7 169.95,76.65 v1(167.33,76.65)
  BOTTOM w0.076: 110.62,75.93 110.62,75.91 110.63,75.9 110.63,75.16 111,74.79 111,74.15 110.74,73.89 110.74,73.5 110.8,73.39 110.8,73.3 110.74,73.11 110.74,72.89 110.75,72.86 110.86,72.48 110.88,72.29 110.9,72.2 UC1.D52
  BOTTOM w0.094: 110.62,75.93 110.62,76.74 111.13,77.24 111.13,77.94 110.92,78.15 110.79,78.15 v1(110.69,78.05)
CPU_DP2_P1_C: length 1.9
  TOP w0.094: UV7.9 165.99,80.14 166.09,80.03 166.09,79.08 CV88.2
CPU_DP2_P2: length 83.1
  TOP w0.094: v1(167.06,77.76) 167.26,77.96 167.26,78.11 CV90.1
  IN1 w0.089: v1(167.06,77.76) 167.46,78.16 167.46,79.78 166.3,80.95 165.59,80.95 165.25,81.29 162.91,81.29 160.48,83.71 158.4,83.71 157.89,84.22 157.89,84.83 155.45,87.27 152,87.27 151.41,87.85 143.87,87.85 135.72,79.7 135.72,77.59 136.07,77.24 136.07,75.31 135.41,74.65 135.41,74.04 134.62,73.25 127.38,73.25 126.65,73.99 126.65,74.37 126.32,74.7 126.32,76.73 125.91,77.14 120.94,77.14 118.98,79.09 117.15,79.09 116.57,79.67 112.75,79.67 112.38,79.3 112.38,77.78 112.18,77.59 112.03,77.59 v1(111.73,77.29)
  BOTTOM w0.076: 112.29,75.8 112.28,75.79 112.28,75.76 112.3,75.74 112.3,75.7 112.31,75.69 112.31,75.51 112.1,75.3 112.1,74.43 111.84,74.17 111.84,73.5 112.3,73.03 UC1.B50
  BOTTOM w0.094: 112.29,75.8 112.29,77.26 112.07,77.47 111.91,77.47 v1(111.73,77.29)
CPU_DP2_P2_C: length 1.9
  TOP w0.094: 167.19,80.68 167.19,80.16 167.29,80.05 167.29,79.75 167.25,79.71 167.25,79.08 CV90.2
CPU_DP2_P3: length 90.8
  TOP w0.094: v1(168.49,77.66) 168.69,77.85 168.69,78.11 CV92.1
  IN1 w0.089: v1(111.25,76.15) 111.47,75.93 111.47,75.73 111.69,75.51 112.25,75.51 112.63,75.89 112.63,76.5 112.27,76.86 111.53,76.86 111.31,77.08 111.31,80.03 112.09,80.82 113.62,80.82 114.18,80.26 116.79,80.26 117.38,79.68 119.23,79.68 120.63,78.28 125.66,78.28 127.31,76.63 127.31,75.74 127.41,75.64 127.41,74.11 127.69,73.83 133.79,73.83 135.01,75.05 135.01,77.62 134.6,78.02 134.6,79.47 136,80.87 136,82.52 139.32,85.85 140.85,85.85 143.44,88.44 151.72,88.44 152.28,87.88 157.51,87.88 158.75,86.64 159.14,86.64 160.41,85.37 160.41,84.6 162.67,82.34 166.25,82.34 168.7,79.89 168.7,77.86 v1(168.49,77.66)
  BOTTOM w0.076: 111.32,75.8 111.56,75.8 111.64,75.72 111.64,75.7 111.65,75.69 111.65,75.17 111.48,75 111.48,73.36 111.73,73.1 111.73,73.03 111.68,72.97 111.55,72.97 111.47,72.89 111.47,72.71 111.56,72.61 111.67,72.61 UC1.C51
  BOTTOM w0.094: v1(111.25,76.15) 111.25,75.87 111.32,75.8
CPU_DP2_P3_C: length 2
  TOP w0.094: UV7.15 168.39,80.13 168.49,80.02 168.49,79.75 168.69,79.56 168.69,79.08 CV92.2
CPU_DP3_AUXN: length 1
  TOP w0.102: T1.1 113.79,70.21 v1(113.79,69.96)
  BOTTOM w0.076: v1(113.79,69.96) 114.12,69.63 UC1.G46
CPU_DP3_AUXP: length 1.3
  TOP w0.102: T2.1 114.38,69.65 v1(114.63,69.9)
  BOTTOM w0.076: UC1.F46 114.25,70.28 v1(114.63,69.9)
CPU_POPIRCOMP: length 11
  TOP w0.381: v1(131.08,54.44) 131.18,54.44 131.64,53.99 v2(131.64,52.05) 131.64,51.22 131.68,51.18 131.68,49.57 131.6,49.49 131.6,46.19 132.31,45.48 RC88.1
  BOTTOM w0.254: v1(131.08,54.44) 131.53,54.78 UC1.AT16
CPU_XDP_PRDY#: length 33.2
  TOP w0.102: v1(106.99,78.47) 106.53,78.93 v2(106.53,79.21) 106.53,82.19 105.97,82.74 105.97,83.89 109.07,86.98 109.07,88.3 109.3,88.53 109.3,90.17 108.06,91.41 106.54,91.41 103.41,94.53 102.82,94.53 102.19,95.17 v1(102.19,95.98)
  BOTTOM w0.076: UC1.D56 108.48,72.03 108.4,72.29 108.4,72.41 108.32,72.69 108.27,72.86 108.26,72.89 108.26,73.11 108.32,73.3 108.32,73.39 108.26,73.5 108.26,73.89 108.46,74.08 108.46,74.55 107.73,75.27 107.73,76.06 107.69,76.11 107.69,77.47 107.17,77.99
  BOTTOM w0.102: v1(102.19,95.98) 102.14,96.03 JXDP1.5 ; 107.17,77.99 106.99,78.17 v1(106.99,78.47)
CPU_XDP_PREQ#: length 32.9
  TOP w0.102: v1(103.23,93.8) 106.2,90.83 108,90.83 108.84,89.98 108.84,88.72 108.61,88.49 108.61,87.17 104.96,83.52 v1(104.96,79.93)
  BOTTOM w0.076: UC1.D61 106.49,71.97 106.49,72.15 106.51,72.17 106.51,72.53 106.49,72.55 106.49,73.92 106.62,74.05 106.62,74.6 105.85,75.36 105.85,76.24 104.96,77.14 104.96,77.85
  BOTTOM w0.102: v1(103.23,93.8) 103.17,93.8 RC138.1 102.64,94.39 JXDP1.3 ; 104.96,77.85 104.45,78.36 v2(104.45,79.12) 104.45,79.42 v1(104.96,79.93)
CPU_XDP_TCLK: length 66.4
  IN1 w0.089: v1(89.24,99.89) 89.87,100.53 92.2,100.53 92.56,100.88 104.53,100.88 105.77,99.65 106.91,99.65 108.81,97.76 v1(109.66,97.76)
  BOTTOM w0.076: 103.81,78.3 104.49,77.62 104.49,77.13 105.52,76.1 105.52,75.1 105.88,74.74 105.88,74.22 105.95,74.15 105.95,73.54 106.01,73.43 106.01,73.21 UC1.B61
  BOTTOM w0.102: RC139.1 89.14,96.03 JXDP1.57 89.14,99.79 v1(89.24,99.89) ; v1(109.66,97.76) 109.66,95.79 108.71,94.84 108.54,94.84 107.7,94 107.7,92.74 108.51,91.93 109.02,91.93 109.59,92.5 110.29,92.5 110.93,91.87 111.64,91.87 113.34,90.17 113.34,84.88 112.87,84.41 RC328.1 112.6,84.3 112.07,83.77 106.28,83.77 105.39,82.87 105.39,81.3 v2(105.03,80.94) 103.81,79.73 103.81,78.3
CPU_XDP_TDI: length 40.8
  TOP w0.102: UC8.6 105.15,97.75 105.31,97.58 106.35,97.58 106.46,97.68 107.14,97.68 107.29,97.53 RC134.1 107.29,96.26 107.93,95.63 v2(108.84,95.63) 109.5,95.63 112.75,92.38 113.34,92.38 v1(113.82,92.86)
  BOTTOM w0.076: UC1.D60 106.78,72.26 107.07,72.55 107.07,72.8 106.88,72.98 106.88,73.85 106.95,73.91 106.95,74.79 106.31,75.43 106.31,76.61 105.57,77.35 105.57,77.85
  BOTTOM w0.102: v1(113.82,92.86) 114.74,91.94 114.74,84.95 112.61,82.83 110.75,82.83 110.09,82.17 107.42,82.17 106.74,81.48 106.74,80.97 105.68,79.92 105.68,79.28 105.57,79.17 105.57,77.85
CPU_XDP_TDO: length 39.2
  TOP w0.102: UC8.3 103.65,97.12 104.45,96.31 RC135.1 104.63,95.88 105.08,95.42 105.08,94.79 105.59,94.28 v2(107.12,94.28) 107.4,94.28 107.9,93.77 v1(108.16,93.77)
  BOTTOM w0.076: UC1.A61 106.21,74.77 105.69,75.29 105.69,76.17 104.67,77.19 104.67,77.71 104.08,78.3
  BOTTOM w0.102: 104.08,78.3 104.08,79.61 104.86,80.39 105.16,80.39 106.23,81.45 106.23,81.62 107.23,82.62 109.9,82.62 110.56,83.28 112.42,83.28 113.86,84.72 113.86,90.33 111.69,92.5 110.98,92.5 110.47,93.01 108.69,93.01 108.49,93.22 108.49,93.45 v1(108.16,93.77)
CPU_XDP_TMS: length 40.4
  TOP w0.102: v1(113.29,93.14) v2(112.75,93.68) 112.45,93.98 112.45,94.53 111.94,95.04 110.52,95.04 108.64,96.92 108.64,98.8 108.46,98.98 107.93,98.98 RC131.1 107.29,98.93 106.62,99.61 UC8.8
  BOTTOM w0.076: UC1.C60 106.72,72.74 106.72,73.92 106.78,73.98 106.78,74.67 106.1,75.35 106.1,76.44 105.34,77.2 105.34,77.85
  BOTTOM w0.102: v1(113.29,93.14) 113.29,92.76 114.13,91.92 114.13,84.66 112.52,83.05 110.66,83.05 110,82.39 107.33,82.39 106.48,81.55 106.48,81.06 105.45,80.03 105.45,79.4 105.34,79.29 105.34,77.85
CPU_XDP_TRST#: length 54.4
  TOP w0.102: v1(105.15,75.36) 106.67,76.88 106.67,78.09 106.1,78.66 v1(106.1,79.61) 106.1,79.74 RC136.1 106.3,80.95 106.3,82.1 105.74,82.65 105.74,83.98 108.84,87.08 108.84,88.39 109.07,88.62 109.07,90.08 108.02,91.13 106.5,91.13 103.32,94.31 102.73,94.31 101.78,95.25 101.78,96.19 v3(100.49,97.48) 99.72,98.24 99.72,100.28 101.1,101.65 101.1,102.41 102.01,103.32 104.73,103.32 105.34,102.71 CC308.1 104.65,102.36 104.15,101.85 UC8.11
  BOTTOM w0.076: 107.11,74.9 107.11,73.84 107.05,73.78 107.05,73.29 UC1.B59 ; v1(105.15,75.36) 105.15,75.24 105.71,74.68 105.71,74.15 105.78,74.08 105.78,73.5 105.8,73.48 105.82,73.42 105.82,72.87 106.21,72.47 UC1.C61
  BOTTOM w0.102: v1(106.1,79.61) 106.1,79.29 105.85,79.04 105.85,77.52 106.56,76.81 106.56,75.46 107.11,74.9
CSI2_COMP: length 13.7
  TOP w0.102: v1(134.74,74.2) 135.01,73.94 136.15,73.94 140.59,78.38 v2(140.59,79.16) 140.59,80.11 RC3.1
  BOTTOM w0.076: v1(134.74,74.2) 134.61,74.2 134.33,73.92 134.33,72.55 134.31,72.53 134.31,72.17 134.33,72.15 134.33,71.9 134.16,71.73 133.91,71.73 133.76,71.58 UC1.E13
CSIN_ISL9538: length 6.5
  TOP w0.102: PC927.1 31.03,41.63 v2(31.94,41.63)
  TOP w0.203: PC927.1 30.78,41.14 v1(30.4,40.75)
  BOTTOM w0.203: v1(30.4,40.75) 30.45,40.81 PU901.14
  BOTTOM w0.254: v1(30.4,40.75) 30.6,40.55 30.6,39.32 30.24,38.96 PC925.2 29.38,38.96 PR910.2
CSIP_ISL9538: length 5.8
  TOP w0.102: v2(31.09,40.47) 30.92,40.29 30.14,40.29 29.81,40.62 v1(29.81,40.65)
  TOP w0.203: v1(29.81,40.65) 29.79,40.67 29.79,41.26 PC926.1
  BOTTOM w0.203: v1(29.81,40.65) 29.81,41.11 30.05,41.35 PU901.15
  BOTTOM w0.254: v1(29.81,40.65) 30.07,40.39 PC925.1 29.67,39.87 PR909.2
CSON_ISL9538: length 7.4
  TOP w0.203: PC946.1 33.87,46.06 34.3,46.06 34.34,46.02 34.34,46.01 34.34,46.01 34.34,46.02 v1(34.35,46.02)
  BOTTOM w0.102: v2(36.66,47.89) 36.12,47.89 35.92,48.09 35.28,48.09 34.96,47.78 34.96,47.3 35.09,47.17 PC945.1
  BOTTOM w0.203: PR938.1 35.89,46.44 PC945.1 34.76,46.44 34.35,46.02 v1(34.35,46.02) ; PU901.1 33.47,45.44 33.81,45.77
  BOTTOM w0.254: v1(34.35,46.02) 34.06,46.02 33.81,45.77
CSOP_ISL9538: length 4
  TOP w0.254: v1(34.36,45.44) 33.86,45.44 PC942.1
  BOTTOM w0.203: PU901.2 33.54,45.04 33.94,45.44 v1(34.36,45.44) 34.41,45.49 35.06,45.49 PC945.2 35.11,45.55 35.56,45.55 PR937.1
CV2_ON: length 45
  TOP w0.102: v1(263.03,11.15) 263.03,10.78 262.6,10.34 JUSH1.24
  IN3 w0.122: v1(265.5,42.69) 263.58,40.76 263.58,37.33 261.09,34.84 261.09,31.64 260.02,30.57 260.02,30.53 259.01,29.51 259.01,27.61 258.12,26.72 257.74,26.72 255.78,24.76 255.78,23.59 256.98,22.4 258.77,22.4 260.35,20.81 260.35,17.18 259.69,16.52 259.69,14 261.84,11.86 262.33,11.86 v1(263.03,11.15)
  BOTTOM w0.102: v2(265.12,43.76) 265.05,43.7 265.05,43.14 v1(265.5,42.69) 265.17,42.35 265.17,41.65 RE539.2
CV2_ON_R: length 15.8
  TOP w0.076: UE1.H8 264.82,48.52 v1(265.21,48.13)
  TOP w0.102: v1(265.64,42.12) 265.28,41.76 265.28,39.15 265.28,38.81 265.55,38.54 265.55,37.83 v3(265.68,37.7) 265.73,37.65 RPE10.1
  IN3 w0.122: v1(265.21,48.13) 265.21,47.93 264.82,47.54 264.82,47.01 264.6,46.78 264.6,44.88 266,43.48 266,42.48 v1(265.64,42.12)
  BOTTOM w0.102: v1(265.64,42.12) 265.94,41.81 265.94,40.88 RE539.1
DAT_DDC2_CRT: length 8.4
  TOP w0.102: UV6.16 286.62,50.22 v1(286.69,50.29)
  BOTTOM w0.102: JCRT1.12 291.02,53.01 290.53,53.01 RV119.1 288.37,50.85 288.09,50.85 287.89,50.64 287.05,50.64 v1(286.69,50.29)
DAT_TP_SIO_I2C_CLK: length 123.1
  TOP w0.076: 269.55,52.29 269.08,52.29 268.91,52.12 268.4,52.12 268.02,52.49 UE1.C12
  TOP w0.102: v1(211.9,16.56) 211.9,17 212.15,17.24 212.15,18.4 211.32,19.22 210.92,19.22 v2(210.02,20.12) 208.18,21.96 208.18,23.91 207.52,24.57 207.52,26.92 205.92,28.52 205.92,28.75 205.01,29.66 203.49,29.66 203,29.18 203,28.52 CZ80.1 RZ347.2 202.57,26.69 RZ22.2 ; v1(272.74,51.69) 272.74,51.98 272.44,52.29 269.55,52.29
  IN2 w0.122: v1(211.9,16.56) 212.32,16.14 218.46,16.14 218.83,16.51 229.21,16.51 230.05,15.67 230.74,15.67 233.86,12.54 238.94,12.54 239.65,13.25 240.47,13.25 241.48,14.27 241.94,14.27 243.23,15.55 244.14,15.55 244.99,16.41 246.79,16.41 248.12,15.08 250.04,15.08 250.26,14.86 251.05,14.86 251.98,15.79 253.47,15.79 256.14,18.46 256.85,18.46 257.87,19.48 257.87,20.37 259.24,21.74 259.24,27.96 259.77,28.49 260.33,28.49 261.94,30.11 262.65,30.11 263.58,31.03 265.82,31.03 267.62,32.84 267.62,33.42 268.99,34.79 269.5,34.79 271.24,36.53 271.24,39.33 271.96,40.06 271.96,40.81 271.31,41.47 271.31,43.33 271.83,43.85 271.83,45.77 271.58,46.02 271.58,49.96 270.82,50.72 270.82,51.48 271.33,51.99 272.44,51.99 v1(272.74,51.69)
DAT_TP_SIO_R: length 9.2
  TOP w0.102: RZ22.1 202.38,25.12 202.12,24.86 v3(202.12,24.47) 202.12,24.24 202.77,23.59 202.77,23.44 RZ18.2 202.77,22.53 202.77,21.41 203.23,20.95 CZ88.1 204.72,19.34 204.91,19.34 205.15,19.09 JKBTP1.13
DCIN1_EN: length 351.7
  TOP w0.102: v1(38.92,82.22) 38.74,82.04 v2(38.74,81.09) PR1221.1 ; v1(242.24,41.42) 242.24,42.74 243.01,43.51 244.07,43.51 244.72,44.15 244.72,44.75 247.08,47.11 v1(248.34,47.11) ; UE1.K4 v1(262.01,47.32)
  IN3 w0.122: v1(242.24,41.42) 242.09,41.27 241.91,41.27 241.46,40.81 241.46,39.63 240.34,38.51 240.34,38.2 238.56,36.42 237.75,36.42 236.59,35.26 235.84,35.26 235.15,34.58 233.88,34.58 232.82,33.51 229.61,33.51 228.02,31.92 225.84,31.92 225.57,31.66 224.35,31.66 223.7,32.3 221.86,32.3 221.02,31.47 220.96,31.47 220.21,30.71 218.11,30.71 217.14,29.74 211.54,29.74 210.69,30.59 203.39,30.59 203,30.21 197.6,30.21 196.38,31.43 180.63,31.43 179.26,30.06 153.79,30.06 153.34,29.61 144.91,29.61 144.26,30.26 101.52,30.26 99.35,28.1 69.25,28.1 66.66,25.5 62.74,25.5 57.52,30.72 52.89,30.72 52.09,29.92 52.09,28.27 53.01,27.35 53.01,25.7 51.62,24.3 47.81,24.3 46.54,23.03 40.06,23.03 38.28,21.26 36.25,21.26 35.74,21.76 34.35,21.76 33.3,22.81 22.23,22.81 18.34,26.69 18.34,33.32 19.36,34.34 19.36,41.58 16.31,44.62 16.31,50.47 17.71,51.86 17.71,52.75 15.17,55.29 15.17,63.22 16.17,64.22 16.17,67.04 17.23,68.09 17.23,75.58 21.23,79.59 22.13,79.59 23.28,80.74 29.65,80.74 30.54,81.64 38.46,81.64 38.92,82.09 v1(38.92,82.22)
  IN4 w0.089: v1(248.34,47.11) 249.03,47.8 253.55,47.8 254.18,48.43 255.58,48.43 255.83,48.18 259.01,48.18 260.02,47.16 261.85,47.16 v1(262.01,47.32)
DCIN2_EN: length 325
  TOP w0.076: UE1.L12 268.41,45.74 v1(268.41,45.72)
  IN3 w0.122: v1(243.48,42.77) 243.96,42.29 243.96,41.03 241.1,38.17 241.1,37.79 239.67,36.36 239.67,35.64 238.76,34.73 237.53,34.73 236.91,34.11 235.77,34.11 235.49,33.83 234.27,33.83 233.11,32.67 229.91,32.67 227.61,30.37 225.38,30.37 225.11,30.64 221.25,30.64 219.49,28.88 217.61,28.88 217.04,28.31 215.41,28.31 214.84,28.88 211.35,28.88 210.38,29.84 204,29.84 202.53,28.38 199.47,28.38 198.66,29.19 197.22,29.19 196.01,30.41 180.71,30.41 179.01,28.71 154.55,28.71 154.39,28.55 143.64,28.55 143.23,28.95 101.96,28.95 100.03,27.02 69.51,27.02 66.42,23.92 48.11,23.92 v1(46.46,22.27) ; v1(45.78,38.71) 45.34,38.71 44.07,39.98 44.07,40.98 42.63,42.43 39.84,42.43 38.53,43.74 38.53,48.34 38.19,48.69 38.19,57.2 43.44,62.46 44.87,62.46 47.36,64.94 50.55,64.94 52.71,67.1 53.4,67.1 54.11,67.81 54.11,77.34 56.7,79.93 56.7,81.71 v1(55.68,82.72)
  IN4 w0.089: v1(268.41,45.72) 267.03,44.33 264.58,44.33 263.13,42.88 262.22,42.88 260.9,44.2 259.65,44.2 256.63,41.18 253.93,41.18 253.28,41.83 246.79,41.83 246.18,42.44 243.81,42.44 v1(243.48,42.77)
  BOTTOM w0.102: v1(55.68,82.72) 55.43,82.47 v2(55.03,82.47) 54.22,82.47 52.25,84.44 52.25,86.15 51.8,86.6 PR26.1 ; v1(46.46,22.27) 46.28,22.45 46.28,27.48 44.76,29 44.76,37.69 v1(45.78,38.71)
DCIN_ISL9538: length 4.3
  TOP w0.254: v1(27.92,41.65) 28.21,41.65 28.71,41.16 PR916.1
  BOTTOM w0.203: v1(27.92,41.65) 28.31,42.05 28.31,42.3 28.65,42.64 PU901.17
  BOTTOM w0.254: PC931.2 27.11,41.22 27.49,41.22 v1(27.92,41.65)
DDR_A_ACT#: length 59.3
  IN1 w0.142: v1(107.08,47.71) 107.48,47.31 107.48,44.15 107.48,44.14 107.48,43.79 107.48,43.78 107.48,42.71 106.91,42.14 106.69,42.14 96.57,32.01 88.3,32.01 78.86,22.57 78.86,21.69 77.56,20.39 77.56,17.02 78.45,16.13 78.45,14.25 v1(78.04,13.85)
  BOTTOM w0.076: UC1.BA55 109.12,51.77 109.12,51.53 109.06,51.4 108.98,51.32 108.98,49.89 107.08,47.99 v1(107.08,47.71)
  BOTTOM w0.168: v1(78.04,13.85) 78.43,13.46 JDIMM1.114
DDR_A_ALERT#: length 84.8
  IN2 w0.196: v1(74.48,37.79) 75.09,37.18 112.63,37.18 113.72,38.27 113.72,52.88 112.86,53.74 v1(112.73,53.74)
  IN4 w0.142: v1(74.48,37.79) 77.14,35.12 77.14,20.62 77.97,19.8 v1(77.97,15.37)
  BOTTOM w0.168: JDIMM1.116 78.93,14.61 78.17,15.37 v1(77.97,15.37)
  BOTTOM w0.254: UC1.AW50 112.3,53.31 v1(112.73,53.74)
DDR_A_BA0: length 60.4
  IN1 w0.076: v1(110.98,53.81) 111.53,53.26 111.53,52.27 111.73,52.07 111.73,51.86
  IN1 w0.142: 111.73,51.86 111.73,51.57 113.52,49.78 113.52,41.44 113.38,41.31 112.25,40.18 112.25,36.56 99.26,23.57 91.61,23.57 86.68,18.64 86.68,15.27 87.37,14.59 87.38,14.59 v1(88.25,13.72)
  BOTTOM w0.076: UC1.AU52 111.31,54.14 v1(110.98,53.81)
  BOTTOM w0.168: v1(88.25,13.72) 89.43,12.55 JDIMM1.150
DDR_A_BA1: length 61.5
  IN1 w0.076: v1(112.79,55.1) 112.75,55.1 112.27,54.62 112.27,54.25 112.19,54.18 112.19,52.63 113.75,51.08 114.15,51.08 114.73,50.49 114.73,48.67 114.15,48.08 114.15,40.51 113.67,40.03 113.67,39.74
  IN1 w0.142: 113.67,39.74 113.67,36.19 111.7,34.22 111.7,33.98 111.86,33.83 111.86,33.59 111.69,33.42 111.45,33.42 111.3,33.58 111.06,33.58 110.9,33.41 110.9,33.18 111.05,33.02 111.05,32.79 110.89,32.62 110.65,32.62 110.49,32.78 110.26,32.78 110.09,32.61 110.09,32.37 110.25,32.22 110.25,31.98 110.08,31.82 109.85,31.82 109.69,31.97 109.45,31.97 109.29,31.8 109.29,31.57 109.44,31.41 109.44,31.18 109.28,31.01 109.04,31.01 108.88,31.17 108.65,31.17 108.48,31 108.48,30.76 108.64,30.61 108.64,30.37 108.47,30.21 108.24,30.21 108.08,30.36 107.84,30.36 99.78,22.3 93.06,22.3 90.13,19.38 89.86,19.38 89.64,19.59 89.43,19.59 88.65,18.8 88.65,17.72 88.48,17.55 v1(88.28,17.55)
  BOTTOM w0.076: v1(112.79,55.1) 113.11,54.79 UC1.AT48
  BOTTOM w0.168: v1(88.28,17.55) 88.18,17.66 JDIMM1.145
DDR_A_BG0: length 60.8
  IN1 w0.142: v1(107.05,44.6) 106.05,43.6 106.05,42.69 96.71,33.35 88.44,33.35 76.51,21.42 76.51,20.54 75.95,19.98 75.95,19.14 76.31,18.78 76.31,17.4 76.35,17.36 76.35,16.31 76.52,16.14 76.94,16.14 v1(77.05,16.25)
  BOTTOM w0.076: 107.52,45.14 107.52,48.03 109.76,50.27 109.76,50.62 109.58,50.8 109.58,51.17 109.59,51.2 109.61,51.25 109.61,51.43 109.58,51.55 109.58,51.81 109.61,51.91 109.61,52.11 109.54,52.25 109.25,52.55 UC1.AY55
  BOTTOM w0.168: 107.52,45.14 107.52,45.07 v1(107.05,44.6) ; JDIMM1.115 78.68,19.02 77.69,18.04 77.69,16.88 v1(77.05,16.25)
DDR_A_BG1: length 60.3
  IN1 w0.142: v1(107.06,43.97) 107.05,43.97 106.47,43.38 106.47,42.51 96.88,32.93 96.15,32.93 95.98,32.76 95.98,32.6 95.81,32.43 95.58,32.43 95.41,32.6 95.41,32.76 95.24,32.93 95.01,32.93 94.84,32.76 94.84,32.6 94.68,32.43 94.44,32.43 94.27,32.6 94.27,32.76 94.11,32.93 93.87,32.93 93.7,32.76 93.7,32.6 93.54,32.43 93.3,32.43 93.14,32.6 93.14,32.76 92.97,32.93 92.73,32.93 92.57,32.76 92.57,32.6 92.4,32.43 92.16,32.43 92,32.6 92,32.76 91.83,32.93 91.6,32.93 91.43,32.76 91.43,32.6 91.26,32.43 91.03,32.43 90.86,32.6 90.86,32.76 90.69,32.93 90.46,32.93 90.29,32.76 90.29,32.6 90.12,32.43 88.13,32.43 77.05,21.36 77.05,20.03 76.91,19.89 76.51,19.89 76.37,19.74 76.37,19.49 76.51,19.34 76.91,19.34 77.05,19.2 77.05,18.66 76.91,18.52 76.86,18.52 76.73,18.39 76.73,17.98 76.93,17.78 v1(77.05,17.78)
  BOTTOM w0.076: UC1.AY54 109.81,52.22 109.81,51.97 109.74,51.78 109.74,51.59 109.78,51.46 109.78,51.21 109.74,51.13 109.74,50.87 109.92,50.69 109.92,50.2 107.82,48.1 107.82,47.93
  BOTTOM w0.168: 107.82,47.93 107.82,44.65 107.14,43.97 v1(107.06,43.97) ; v1(77.05,17.78) 77.25,17.98 77.25,18.22 78.18,19.14 JDIMM1.113
DDR_A_CKE0: length 60.2
  IN1 w0.142: v1(75.69,17.09) 75.69,16.33 75.5,16.14 75.23,16.14 75.04,16.33 75.04,18.89 75.27,19.13 75.27,19.48 75.04,19.72 75.04,20.34 75.27,20.57 75.62,20.57 75.86,20.81 75.86,21.69 88.19,34.02 96.46,34.02 105.58,43.15 105.58,43.2 105.58,44.37 v1(107.07,45.87)
  BOTTOM w0.076: UC1.BA56 108.68,51.52 108.54,51.38 108.54,51.38 108.54,51.38 108.42,51.13 108.42,51.13 108.42,50.82 108.48,50.76 108.48,49.93 106.4,47.85 106.4,47.67
  BOTTOM w0.168: JDIMM1.109 77.18,18.77 76.15,17.74 76.15,17.55 v1(75.69,17.09) ; 106.4,47.67 106.4,46.54 v1(107.07,45.87)
DDR_A_CKE1: length 59.8
  IN1 w0.142: v1(107.06,46.53) 105.16,44.63 105.16,43.46 96.15,34.45 88.02,34.45 74.61,21.04 74.61,16.16 v1(76.42,14.35)
  BOTTOM w0.076: UC1.BB56 108.65,50.98 108.65,49.84 106.63,47.82 106.63,46.96 v1(107.06,46.53)
  BOTTOM w0.168: JDIMM1.110 77.43,13.24 77.19,13.47 77.19,13.83 76.67,14.35 v1(76.42,14.35)
DDR_A_CKE2: length 2
  TOP w0.168: v1(108.2,53.8) 107.25,53.8 T3.1
  BOTTOM w0.076: UC1.AW56 108.68,53.24 108.2,53.72 v1(108.2,53.8)
DDR_A_CKE3: length 11.8
  TOP w0.168: v1(106.91,42.72) 106.91,42.01 T4.1
  BOTTOM w0.076: 106.38,45.79 106.1,46.07 106.1,47.8 108.25,49.95 108.25,51.16 108.27,51.21 108.42,51.57 108.42,51.85 108.68,52.12 UC1.AY56
  BOTTOM w0.168: v1(106.91,42.72) 106.38,43.25 106.38,45.78 106.38,45.79
DDR_A_CLK0: length 62
  IN1 w0.076: v1(110.05,54.44) 110.23,54.27 110.41,54.27 110.61,54.07 110.61,53.55 111.09,53.08 111.09,52.65 111.09,52.64 111.09,52.62
  IN1 w0.089: 111.09,52.62 111.09,52.28 110.86,52.05 110.86,51.8 111.36,51.3 111.36,50.9 110.75,50.29 110.75,50.01 111.43,49.32 111.66,49.32 112.22,49.88 112.66,49.88 113.22,49.32 113.22,45.77 113.01,45.56 113.01,41.82 111.48,40.29 111.48,39.63 111.61,39.49 111.61,38.9 111.48,38.76 111.48,38.48 111.59,38.38 111.59,36.78 99,24.19 91.25,24.19 86.06,19 86.06,17.21 85.86,17.01 v1(85.25,17.01)
  BOTTOM w0.076: v1(110.05,54.44) 110.05,54.54 110.31,54.79 UC1.AT53
  BOTTOM w0.094: v1(85.25,17.01) 85.04,17.23 84.69,17.23 84.33,17.58 84.33,19.02 84.18,19.17 JDIMM1.137
DDR_A_CLK1: length 62.2
  IN1 w0.076: 109.7,52.62 109.7,52.64 109.69,52.65 109.69,53.65 109.64,53.7 109.64,53.98 109.43,54.19 109.19,54.19 109.09,54.29 v1(109.09,54.43)
  IN1 w0.089: v1(85.52,15.48) 85.19,15.14 85.03,15.14 84.74,15.44 84.74,18.75 90.86,24.88 98.59,24.88 110.8,37.09 110.8,40.41 111.27,40.88 111.27,42.2 111.94,42.87 111.94,47.85 110.04,49.76 110.04,51.74 109.7,52.08 109.7,52.62
  BOTTOM w0.076: v1(109.09,54.43) 109.45,54.79 UC1.AT55
  BOTTOM w0.094: v1(85.52,15.48) 85.31,15.27 84.85,15.27 84.43,14.85 JDIMM1.138
DDR_A_CLK#0: length 62.1
  IN1 w0.076: 110.91,52.62 110.91,52.64 110.92,52.65 110.92,53.01 110.45,53.49 110.45,54 110.34,54.1 110.2,54.1 110.05,53.96 v1(110.05,53.81)
  IN1 w0.089: v1(85.25,17.94) 85.25,17.6 85.67,17.19 85.78,17.19 85.88,17.28 85.88,19.07 91.18,24.37 98.93,24.37 111.41,36.85 111.41,38.3 111.3,38.41 111.3,38.84 111.43,38.97 111.43,39.42 111.3,39.55 111.3,40.36 112.83,41.89 112.83,45.63 113.04,45.84 113.04,49.25 112.58,49.7 112.3,49.7 111.74,49.14 111.36,49.14 110.57,49.93 110.57,50.36 111.18,50.97 111.18,51.23 110.68,51.72 110.68,52.13 110.91,52.36 110.91,52.62
  BOTTOM w0.076: UC1.AU53 110.3,54.14 110.05,53.89 v1(110.05,53.81)
  BOTTOM w0.094: v1(85.25,17.94) 85.25,17.61 85.06,17.41 84.76,17.41 84.51,17.66 84.51,19.03 84.68,19.19 JDIMM1.139
DDR_A_CLK#1: length 62.2
  IN1 w0.076: v1(109.09,53.8) 109.09,53.91 109.21,54.03 109.36,54.03 109.47,53.91 109.47,53.63 109.52,53.58 109.52,52.65 109.52,52.64 109.52,52.62
  IN1 w0.089: 109.52,52.62 109.52,52 109.86,51.66 109.86,49.96 109.86,49.95 109.86,49.68 111.35,48.19 111.35,48.18 111.76,47.78 111.76,42.94 111.61,42.79 111.61,42.79 111.09,42.27 111.09,40.96 110.62,40.49 110.62,37.16 98.51,25.06 90.79,25.06 89.07,23.34 87.4,21.67 84.56,18.83 84.56,15.36 84.96,14.96 85.28,14.96 v1(85.52,14.72)
  BOTTOM w0.076: v1(109.09,53.8) 109.44,54.14 UC1.AU55
  BOTTOM w0.094: v1(85.52,14.72) 85.52,14.9 85.34,15.08 84.92,15.08 84.61,14.77 84.61,12.93 84.73,12.81 84.8,12.81 84.93,12.68 JDIMM1.140
DDR_A_CS#0: length 64.8
  IN1 w0.076: v1(114.62,53.81) 114.62,52.48 115.76,51.34 115.76,47.6 116.06,47.3 116.06,47.16
  IN1 w0.142: v1(89.45,16.81) 90.12,16.13 90.12,13.86 90.73,13.25 91.36,13.25 92.05,13.94 92.05,15.99 92.43,16.38 92.43,18.35 93.86,19.78 101.36,19.78 116.08,34.5 116.08,40 116.26,40.18 116.26,42.9 116.06,43.1 116.06,47.16
  BOTTOM w0.076: UC1.AU45 v1(114.62,53.81)
  BOTTOM w0.168: v1(89.45,16.81) 88.87,17.39 88.87,18.66 89.18,18.97 89.18,20 JDIMM1.149
DDR_A_CS#1: length 65.9
  IN1 w0.142: v1(115.54,53.81) 115.54,53.35 116.34,52.55 116.34,51.41 116.94,50.8 116.94,48.77 117.25,48.46 117.25,40.06 116.92,39.73 116.92,34.14 101.69,18.91 101.64,18.91 101.47,18.74 101.47,17.97 101.3,17.8 101.07,17.8 100.9,17.97 100.9,18.74 100.73,18.91 100.13,18.91 99.88,18.65 99.88,16.43 99.39,15.95 97.47,15.95 97.21,15.69 96.21,15.69 96.04,15.86 96.04,18.68 95.88,18.84 95.64,18.84 95.47,18.68 95.47,15.86 95.31,15.69 94.61,15.69 v1(92.88,17.42)
  BOTTOM w0.076: UC1.AU43 v1(115.54,53.81)
  BOTTOM w0.168: v1(92.88,17.42) 92.69,17.42 91.18,18.93 91.18,19.86 91.18,19.86 JDIMM1.157
DDR_A_D0: length 75.1
  IN1 w0.089: v1(96.88,56.83) 96.88,57.17 95.52,58.53 89.14,58.53 82.64,52.03 82.64,49.96 79.02,46.34 77.97,46.34 50.93,19.3 50.93,17.09 v1(50.33,16.49)
  BOTTOM w0.076: v1(96.88,56.83) 97.53,57.48 98.14,57.48 98.6,57.94 99.87,57.94 99.96,57.84 UC1.AL71
  BOTTOM w0.102: JDIMM1.7 51.68,17.73 50.43,16.49 v1(50.33,16.49)
DDR_A_D1: length 75.7
  IN1 w0.089: v1(50.18,18.01) 50.61,18.44 50.61,19.41 77.85,46.64 78.89,46.64 82.34,50.09 82.34,52.16 89.01,58.83 96.77,58.83 97.81,57.79 97.81,56.59 98.01,56.38 98.49,56.38 98.69,56.59 v1(98.69,56.91)
  BOTTOM w0.076: v1(98.69,56.91) 98.89,56.71 99.37,56.71 99.61,56.95 100.12,56.95 100.15,56.94 100.23,56.9 100.34,56.9 100.56,56.97 100.71,56.97 100.86,56.91 101.05,56.91 101.2,56.99 101.72,56.99 101.92,57.19 UC1.AL68
  BOTTOM w0.102: JDIMM1.3 50.68,18.51 v1(50.18,18.01)
DDR_A_D2: length 77
  IN1 w0.089: v1(93.08,54.91) 92.68,55.31 89.31,55.31 85.06,51.06 85.06,48.54 80.38,43.86 78.88,43.86 61.41,26.39 61.41,26.25 62.02,25.64 62.02,25.5 61.91,25.39 61.77,25.39 61.16,26 61.02,26 60.91,25.89 60.91,25.74 61.51,25.14 61.51,24.99 61.41,24.89 61.26,24.89 60.66,25.49 60.51,25.49 60.41,25.39 60.41,25.24 61.01,24.64 61.01,24.49 60.91,24.39 60.76,24.39 60.16,24.99 60.01,24.99 59.91,24.89 59.91,24.74 60.51,24.13 60.51,23.99 60.4,23.88 60.26,23.88 59.8,24.34 59.65,24.34 59.55,24.24 59.55,24.09 60.01,23.63 60.01,23.48 58.72,22.2 57.54,22.2 55.24,19.9 55.24,18.5 v1(54.68,17.94)
  BOTTOM w0.076: UC1.AN68 101.34,56.33 100.85,56.33 100.61,56.09 99.68,56.09 99.64,56.05 98.68,56.05 98.18,56.05 97.72,55.59 95.47,55.59 95.31,55.43
  BOTTOM w0.102: 95.31,55.43 94.29,54.4 93.59,54.4 v1(93.08,54.91) ; JDIMM1.21 55.18,18.44 v1(54.68,17.94)
DDR_A_D3: length 76.4
  IN1 w0.089: v1(91.72,56.73) 92.13,56.32 92.13,56.12 91.93,55.92 89.05,55.92 84.45,51.32 84.45,49.15 79.86,44.56 78.71,44.56 53.46,19.3 53.46,16.87 54.28,16.05 54.28,15.73 54.18,15.63 53.52,15.63 53.42,15.52 53.42,15.38 53.52,15.27 54.18,15.27 54.28,15.17 54.28,14.27 53.99,13.97 v1(53.61,13.97)
  BOTTOM w0.076: 94.04,55.93 94.19,56.08 97.44,56.08 97.9,56.54 98.88,56.54 98.88,56.54 99.44,56.54 99.68,56.79 100.08,56.79 100.18,56.74 100.37,56.74 100.54,56.79 100.73,56.79 100.88,56.73 100.92,56.72 101.17,56.72 UC1.AN69
  BOTTOM w0.102: v1(53.61,13.97) 54.07,13.52 54.07,12.96 53.93,12.82 JDIMM1.16 ; 94.04,55.93 92.52,55.93 v1(91.72,56.73)
DDR_A_D4: length 76.1
  IN1 w0.089: v1(51.91,14.63) 51.91,14.68 51.23,15.36 51.23,19.17 78.1,46.03 79.19,46.03 82.95,49.79 82.95,51.91 89.26,58.22 94.19,58.22 v1(95.58,56.83)
  BOTTOM w0.076: UC1.AL70 100.47,57.84 100.3,58.02 100.17,58.08 100.06,58.11 98.52,58.11 98.07,57.66 96.42,57.66 v2(96.21,57.46) v1(95.58,56.83)
  BOTTOM w0.102: JDIMM1.4 50.93,13.65 v1(51.91,14.63)
DDR_A_D5: length 76.3
  IN1 w0.089: v1(94.93,56.83) 93.87,57.9 89.37,57.9 83.25,51.78 83.25,49.63 79.35,45.73 78.23,45.73 51.54,19.04 51.54,16.38 52.71,15.21 52.71,13.87 v1(51.93,13.08)
  BOTTOM w0.076: v1(94.93,56.83) 95.93,57.83 98,57.83 98.45,58.28 100.08,58.28 100.11,58.27 100.17,58.25 100.24,58.24 100.32,58.23 100.44,58.19 100.62,58.19 100.8,58.11 101.07,57.84 UC1.AL69
  BOTTOM w0.102: JDIMM1.8 v1(51.93,13.08)
