# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N39469998: length 3.6
  BOTTOM w0.102: v2(84.32,87.18) 84.65,86.85 PR619.1
  BOTTOM w0.508: PC611.1 85.46,87.59 85.53,87.52 PR619.1
N39470129: length 0.9
  TOP w0.254: PR646.2 68.25,72.5 68.25,73.31 68.27,73.33 PC640.1
N39470145: length 2.2
  BOTTOM w0.102: PC601.1 67.73,74.46 v2(67.87,74.6)
  BOTTOM w0.254: PR652.2 67.69,72.48 67.69,73.28 PC601.1
N39470173: length 2.3
  TOP w0.102: PR641.1 64.8,73.66 64.16,73.66 v2(64.05,73.54)
  TOP w0.254: PR641.1 65.13,72.87 PC632.2
N39470189: length 43.4
  TOP w0.102: v2(62.73,72.56) 62.79,72.5 v1(63.48,72.5)
  IN2 w0.254: v1(63.48,72.5) 63.48,72.37 63.91,71.94 64.78,71.94 69.4,76.56 69.4,80.3 69.81,80.72 71.9,80.72 73.9,82.72 73.9,84.16 74.15,84.41 83.9,84.41 84.03,84.29 87.81,84.29 88.61,83.49 95.18,83.49 v1(95.31,83.36)
  BOTTOM w0.254: v1(95.31,83.36) 95.26,83.32 PH604.1 ; v1(63.48,72.5) 63.49,72.5 63.49,72.26 PR642.2
N39470446: length 5.5
  TOP w0.203: PC603.1 63.4,68.28 v1(63.81,67.86) 64,67.68 64.71,67.68 64.78,67.61 PU602.34
  BOTTOM w0.203: v1(63.81,67.86) 63.48,68.19 v2(62.62,68.19) PR602.1
N39470448: length 6.2
  TOP w0.203: PU602.33 64.4,68.01 63.81,68.6 v1(63.81,69.13) 63.81,69.26 63.59,69.48 PC604.1
  BOTTOM w0.203: v1(63.81,69.13) 63.55,69.4 v2(63.09,69.4) PR603.1
N39470528: length 2.9
  TOP w0.203: v1(64.57,68.5) 64.66,68.41 PU602.32
  BOTTOM w0.102: v1(64.57,68.5) 64.52,68.45 v2(64.01,68.45)
  BOTTOM w0.203: v1(64.57,68.5) 64.75,68.5 PR608.1
N39470532: length 3.1
  TOP w0.203: PU602.31 65.15,68.81 64.83,69.13 v1(64.57,69.13)
  BOTTOM w0.102: v2(64.57,69.94) v1(64.57,69.13)
  BOTTOM w0.203: v1(64.57,69.13) 64.99,69.13 PR611.1
N40719702: length 2.3
  TOP w0.102: CE57.1 254.69,36.78 RE350.2 255.93,38.02 v2(255.93,38.53)
N41288260: length 2.5
  BOTTOM w0.102: JNGFF2.25 264.75,28.21 264.98,27.99 264.98,27.28 RZ326.1
N41303246: length 2.1
  TOP w0.102: RZ334.1 CZ38.2 v2(116.27,95.93)
N41840158: length 6.4
  TOP w0.102: RN192.2 226.66,34.32 RN183.1 226.54,33.31 QN4.5 224.65,33.31 224.32,32.98 224.32,31.59 RN182.2 225.51,31.48 v2(225.72,31.26)
N41840194: length 2.8
  TOP w0.102: QN5.2 RN185.1 RN184.2 RN186.2
N41840238: length 6.5
  TOP w0.102: QN5.5 233.23,29.51 232.85,29.13 232.01,29.13 RN188.1 230.56,27.68 RN187.2 RN189.2 230.26,26.79 229.61,26.15 229.01,26.15 v2(228.88,26.02)
N44308050: length 2.7
  TOP w0.102: v2(280.65,30.88) 280.45,30.88 280,30.43 RI14.2 279.29,30.43 279.2,30.51 UI3.16
N44315031: length 6.5
  TOP w0.102: PC947.1 32.19,47.16 32.19,47.35 v2(32.55,47.72) 32.77,47.94 32.77,48.36 32.59,48.54 31.97,48.54 31.85,48.66 PR947.1 PR935.1
  TOP w0.203: PC947.1 31.7,46.73 31.7,47.32 v1(31.63,47.39)
  BOTTOM w0.203: v1(31.63,47.39) 31.63,47.32 31.25,46.94 PU901.29
N44519703: length 3.4
  BOTTOM w0.203: PU901.30 31.65,46.77 v2(32.11,47.22) 32.11,47.66 31.71,48.06 PR936.1 30.89,48.3 PR948.1
N44621211: length 6.4
  TOP w0.203: v1(29.86,47.32) 30.04,47.49 PR933.2 29.51,48.6 29.51,49.44 29.9,49.83 v2(29.9,50.25) 29.9,51.51 PR951.2
  BOTTOM w0.203: v1(29.86,47.32) 29.86,46.88 30.05,46.69 PU901.26
N45247841: length 2.2
  BOTTOM w0.102: JNGFF2.67 275.25,28.1 275.4,27.95 T225.1
N45314468: length 8.9
  TOP w0.102: v1(253.17,36.98) 253.17,37.38 253.78,37.99 253.78,38.53 v2(254.56,39.31) 255.07,39.82 RE375.1
  BOTTOM w0.102: v1(253.17,36.98) 252.56,37.59 250.95,37.59 RE560.1 250.15,37.59 JESPI.8
N45617512: length 3
  TOP w0.305: v1(257.36,89.03) 257.44,88.95 v2(257.86,88.95) CL17.1
  BOTTOM w0.508: TL1.4 v1(257.36,89.03)
N45617514: length 3
  TOP w0.305: v1(257.36,86.03) v2(257.87,86.03) CL16.1
  BOTTOM w0.508: TL1.1 v1(257.36,86.03)
N45617540: length 4
  TOP w0.102: v2(258.72,93) CL20.1
  TOP w0.305: CL20.1 257.39,91.99 257.36,92.03 v1(257.41,92.03)
  BOTTOM w0.508: TL1.7 v1(257.41,92.03)
N45617554: length 3.2
  TOP w0.305: CL21.1 v2(257.76,95.04) 257.26,95.04 257.24,95.03 v1(257.23,95.03)
  BOTTOM w0.508: TL1.10 v1(257.23,95.03)
N45925426: length 7.4
  TOP w0.076: 30.62,66.25 30.54,66.25 29.9,65.61 28.92,65.61 28.6,65.3 28.6,64.81 28.19,64.41 UT5.D1
  TOP w0.102: 30.62,66.25 30.8,66.44 30.8,68.23 30.63,68.4 v2(30.63,68.74) 30.63,68.93 30.92,69.21 RT378.1
N45925428: length 8.9
  TOP w0.076: UT5.D2 27.94,64.06 27.94,64.43 28.26,64.75 28.26,65.34 28.85,65.93 v2(29.22,65.93) 29.3,65.86 29.9,65.86 30.3,66.25
  TOP w0.102: RT379.1 31.44,70.15 30.3,69.01 30.3,68.4 30.57,68.13 30.57,66.53 30.3,66.25
N46047516: length 6.1
  BOTTOM w0.254: PQ8.3 51.77,81.56 50.29,83.03 v2(50.29,84.02) 50.29,85.15 PR28.1 PR26.2
N46047518: length 5.8
  BOTTOM w0.254: PQ8.1 49.86,82.38 v2(49.86,85.42) 49.88,85.43 PR27.1 50.77,87.48 PR22.1
N46047526: length 3.2
  BOTTOM w0.102: PR29.1 52.45,83.92 53.27,83.1 v2(53.27,82.93)
  BOTTOM w0.254: PQ8.2 51.76,83.04 PR29.1
N46050852: length 2.7
  TOP w0.102: PQ1208.2 47.9,50.44 v2(47.55,50.1)
  TOP w0.254: PQ1208.2 PQ1208.3 49.48,50.99 PR1259.1
N46050860: length 6.7
  TOP w0.102: v2(51.73,53.49) 49.95,53.49 49.56,53.1 PR1244.2
  TOP w0.254: PR1260.2 49.56,52.99 PR1244.2 49.37,53.18 49.37,53.76 49.09,54.03 48.27,54.03 PR1261.1 47.9,53.66 PQ1208.5
N46050887: length 7.1
  TOP w0.102: v2(46.22,52.6) 46.51,52.89 PQ1208.6
  TOP w0.254: PQ1208.6 47.25,53.36 47.15,53.45 PR1261.2 PR1234.1 46.85,54.7 46.55,54.4 45.48,54.4 44.86,55.02 44.86,55.68 44.78,55.76 PQ1211.1
N46050911: length 3.1
  TOP w0.254: PQ1211.5 45.43,58.09 46.16,57.36 PR1233.1 PR1242.2
N46050913: length 3.6
  TOP w0.102: PR1235.1 47.16,55.63 PR1257.2 46.85,55.62 46.49,55.26 v2(46.03,55.26) 46.03,55.83 PQ1211.2
N46050923: length 1.4
  TOP w0.254: PQ1210.5 41.6,57.96 41.19,58.37 41.19,58.49 40.94,58.75 PR1245.2
N46051012: length 17.2
  TOP w0.102: PQ1207.6 42.55,52.52 v2(42.07,52.03)
  TOP w0.254: PR1258.2 47.09,59.1 46.33,58.34 PQ1211.4 46.08,58.72 45.29,59.51 40.53,59.51 40.16,59.14 40.16,57.45 41.25,56.36 41.25,55.94 41.73,55.46 PR1230.1 42.16,54.98 41.9,54.72 41.9,53.35 42.17,53.08 PQ1207.6
N46051197: length 2.9
  TOP w0.102: v2(44.45,55.51) PQ1207.3
  TOP w0.254: PR1232.1 44.83,54.38 PQ1207.3 PQ1207.2
N46051213: length 3.6
  TOP w0.102: PR1241.2 43.01,51.41 v2(43.01,51.1)
  TOP w0.254: PQ1207.5 43.04,53.73 43.61,53.15 PR1241.2
N46101144: length 5.6
  TOP w0.102: v2(55.16,77.83) 55.33,77.83 56.25,78.76 PR1201.2
  TOP w0.381: PU1201.3 57.01,78.69 PR1203.1 56.25,78.76 PR1201.2 56.25,79.63 PC1206.1 57.09,79.63 PR1219.1
N46101200: length 6.7
  TOP w0.381: PU1201.2 57.66,76.45 58.07,76.04 58.49,76.04 58.83,76.39 58.83,77.47 v1(59.01,77.64) 59.37,78 PR1208.2 59.7,78.82 PR1217.1 60.6,78.85 PC1205.1
  BOTTOM w0.102: v1(59.01,77.64) v2(59.01,78.19)
N46209617: length 5
  TOP w0.102: PQ1205.2 36.07,76.04 36.07,77.54 PR1225.1 36.91,78.43 36.81,78.53 36.64,78.53 v2(36,79.17)
N46209621: length 8.4
  TOP w0.127: PQ1205.1 34.2,75.25 v2(34.2,75.01)
  TOP w0.254: PR1215.1 37.55,76.86 37.55,75.03 37.19,74.67 35.64,74.67 35.54,74.77 ; 35.54,74.77 35.1,74.34 PR1226.2 ; 35.54,74.77 35.56,74.8 35.56,75.66 35.27,75.95 PQ1205.1
N46209625: length 5.2
  TOP w0.102: PR1221.2 38.98,78.38 39.92,79.32 v2(39.92,79.83)
  TOP w0.254: PQ1205.3 36.81,77.33 PR1224.1 37.86,78.38 PR1221.2
N46209711: length 2.3
  TOP w0.102: v2(40.86,77.33) 40.46,76.93 PR1211.2 40.32,76.19 PU1200.1
N46209717: length 2.8
  TOP w0.102: PU1200.2 38.72,77.12 PR1215.2 v2(40.03,78.43)
N46210543: length 1.1
  TOP w0.102: PU1200.4 38.07,73.51 PR1216.2
N46212351: length 3.7
  TOP w0.254: PQ1215.2 42.61,70.54 v1(42.61,71.5) 42.5,71.61 PR1251.2 42.5,72.38 PR1252.1
  BOTTOM w0.102: v1(42.61,71.5) v2(42.61,70.95)
N46212363: length 2.8
  TOP w0.254: PQ1214.6 42.91,74.14 43.17,73.88 43.79,73.88 v2(44.17,73.5) 44.17,72.45 PR1252.2
N46455859: length 2
  TOP w0.102: QZ3.1 267.76,29.18 RZ25.1
N46814682: length 26.1
  TOP w0.254: PR610.1 66.52,61.42 65.63,62.32 v1(65.63,62.57)
  IN4 w0.254: v1(85.97,64.04) 85.28,63.36 78.49,63.36 77.13,62 75.82,62 75.16,62.66 71.23,62.66 70.32,61.76 68.95,61.76 68.3,62.4 65.79,62.4 v1(65.63,62.57)
  BOTTOM w0.102: v1(65.63,62.57) 65.92,62.28 v2(65.92,62.05)
  BOTTOM w0.254: PR631.2 65.31,62.89 v1(65.63,62.57) ; v1(85.97,64.04) PH601.2
N46814700: length 1.9
  TOP w0.102: PC627.1 72.31,62.27 v2(72.48,62.1)
  TOP w0.254: PR632.2 71.54,61.41 PC627.1
N46814728: length 2.3
  TOP w0.102: v2(86.41,72.37) 86.29,72.5 v1(86.29,72.88)
  TOP w0.254: PR628.2 85.83,73.34 v1(86.29,72.88)
  BOTTOM w0.254: v1(86.29,72.88) 85.83,73.34 PR628.2
N46814746: length 8
  TOP w0.203: PC627.2 70.62,62.33 69.93,63.02 v1(69.93,63.34) 69.93,63.42 69.37,63.98 PU602.8
  BOTTOM w0.254: v1(69.93,63.34) 70.02,63.43 71.47,63.43 71.54,63.51 72.34,63.51 72.48,63.65 74.36,63.65 74.62,63.39 PR638.2
N46814769: length 3.6
  TOP w0.102: PC617.2 69.56,59.1 70.63,59.1 71.14,59.61 v2(71.14,59.9)
  TOP w0.203: PR621.1 69.08,59.48 PC617.2
N46815156: length 1.5
  TOP w0.203: PU602.1 66.57,64.07 66.16,63.66 PR620.2
N46815164: length 2.2
  TOP w0.102: PC621.2 67.58,58.45 v2(66.6,58.45)
  TOP w0.203: PR623.1 67.72,59.13 PC621.2
N46815166: length 6.8
  TOP w0.102: v2(66.46,59.91) 66.94,60.4 PR623.2
  TOP w0.203: PU602.5 68.17,63.99 68.27,63.89 68.27,63.35 67.62,62.71 PR622.2 67.11,61.79 67.11,60.65 PR623.2 PR621.2
N46815186: length 4.9
  TOP w0.203: PU602.4 67.77,63.68 67.82,63.62 v1(67.82,63.62)
  BOTTOM w0.102: PR617.2 67.49,61.98 v2(67.34,62.14)
  BOTTOM w0.203: v1(67.82,63.62) 67.71,63.74 PC616.2
  BOTTOM w0.254: PR617.2 67.86,62.57 67.86,63.59 v1(67.82,63.62)
N46815188: length 0.8
  BOTTOM w0.254: PR617.1 PC614.2
N46815204: length 2.7
  TOP w0.203: PU602.3 v2(67.37,63.28) 67.37,62.88 66.83,62.34 PR610.2
N46815214: length 3.4
  TOP w0.203: PU602.2 66.97,63.8 v1(66.86,63.69)
  BOTTOM w0.102: v1(66.86,63.69) 67.1,63.69 v2(67.34,63.45)
  BOTTOM w0.254: v1(66.86,63.69) 66.86,63.86 66.29,64.44 PC613.2 65.34,64.44 PR613.2
N46816449: length 0.9
  BOTTOM w0.254: PR650.2 74.46,65.04 PC647.2
N46816463: length 2.9
  TOP w0.102: PC629.2 74.9,65.74 75.39,66.24 v2(76.04,66.24)
  TOP w0.254: PC629.2 74.83,65.03 PR639.1
N46816511: length 13
  TOP w0.102: v1(70.65,55.3) 70.65,55.19 v2(70.22,54.76)
  TOP w0.254: v1(74.02,61.57) 74.02,63.24 PR647.2 74.89,64.15 PR635.1
  IN1 w0.254: v1(74.02,61.57) 74.02,61.12 71.82,58.93 71.82,56.82 70.65,55.65 v1(70.65,55.3)
  BOTTOM w0.254: v1(70.65,55.3) 70.38,55.58 PH603.2
N46816791: length 4.4
  TOP w0.102: PC630.1 72.16,72.11 v2(71.98,72.3)
  TOP w0.203: PU602.20 71.25,68.81 71.57,69.12 71.57,69.64 72.11,70.18
  TOP w0.254: PC630.1 72.16,71.1 PR640.1 72.11,70.18
N46816817: length 2.3
  TOP w0.102: PC630.2 73.07,72.05 v2(73.37,72.35)
  TOP w0.254: PR644.1 73.95,71.1 PC630.2
N46816821: length 3.9
  TOP w0.102: v1(72.25,54.52) v2(71.58,54.52)
  TOP w0.254: PR657.2 73.52,54.52 v1(72.25,54.52)
  BOTTOM w0.254: v1(72.25,54.52) 72.14,54.63 PH605.1
N46816907: length 0.9
  BOTTOM w0.254: PC639.2 74.86,65.95 PR645.1
N46907385: length 2.5
  TOP w0.102: UT9.32 v1(24.86,76.48)
  BOTTOM w0.102: v1(24.86,76.48) 24.86,76.26 v2(25.09,76.02) 25.41,76.02 RT380.2
N46924944: length 2.1
  BOTTOM w0.203: PU901.21 27.36,44.24 PR920.2
N46924987: length 2.3
  BOTTOM w0.203: PU901.22 27.91,44.64 v2(27.89,44.62) 27.85,44.62 PR922.2
N46998600: length 1.8
  TOP w0.102: RZ63.1 CZ56.1 167.05,66.7 v2(167.07,66.72)
N46999447: length 34.7
  TOP w0.102: v1(278.34,51.33) 277.92,51.75 RZ132.2
  IN1 w0.089: v1(265.22,48.97) 265.56,49.31 267.94,49.31 268.94,50.32 271.59,50.32 273.08,48.82 273.65,48.82 276.45,51.62 278.05,51.62 v1(278.34,51.33)
  BOTTOM w0.102: JNGFF2.58 273,37.41 272.75,37.66 272.75,39.08 272.1,39.73 272.1,42.85 272.15,42.9 272.15,44.69 270.74,46.1 v2(269.82,46.1) 268.95,46.1 268.55,46.5 266.15,46.5 265.61,47.04 265.61,48.57 v1(265.22,48.97)
N47324022: length 0.7
  TOP w0.102: v1(162.06,103.04) v3(162.81,103.04)
N47329694: length 1.4
  TOP w0.102: QE12.1 264.98,62.9 RE94.1
N48068474: length 2.2
  BOTTOM w0.102: v2(167,106.46) 166.43,105.89 PC307.2
  BOTTOM w0.254: PR308.1 165.94,105.9 PC307.2
N48704005: length 46.7
  IN2 w0.254: v1(96.19,83.99) 95.94,84.25 88.93,84.25 88.13,85.05 84.35,85.05 84.22,85.18 73.54,85.18 73.14,84.77 73.14,83.03 71.58,81.48 69.5,81.48 68.64,80.62 68.64,76.88 65.59,73.84 63.88,73.84 v1(63.05,73.01)
  BOTTOM w0.102: v2(62.41,73.64) v1(63.05,73.01)
  BOTTOM w0.254: PL614.3 95.91,85.75 96.32,85.34 96.32,84.12 v1(96.19,83.99) ; PR624.1 62.67,72.63 v1(63.05,73.01)
N49117945: length 3.7
  TOP w0.203: PR932.1 30.47,47.19 v1(30.47,47.31)
  BOTTOM w0.102: v2(29.04,47.94) 29.25,47.72 30.08,47.72 30.47,47.34 v1(30.47,47.31)
  BOTTOM w0.203: PU901.27 30.45,46.09 30.45,47.29 v1(30.47,47.31)
N49204882: length 4.6
  TOP w0.102: v2(72.43,53.08) 72.95,52.56 73.78,52.56 v1(73.8,52.54)
  TOP w0.254: v1(73.8,52.54) 73.96,52.54 74.67,51.82 PR661.1
  BOTTOM w0.254: v1(73.8,52.54) 73.8,52.1 73.4,51.7 PL612.3
N49222948: length 2.7
  BOTTOM w0.102: v2(84.92,56.45) 84.64,56.73 PR687.2
  BOTTOM w0.254: PU610.1 83.71,58.37 84.16,57.92 84.38,57.92 84.64,57.67 PR687.2
N49223679: length 1.4
  BOTTOM w0.229: PU610.2 83.21,58.28 83.8,57.69 PR659.2
N49225697: length 17.5
  TOP w0.254: PR686.2 76.08,62.66 v1(76.39,62.66)
  IN1 w0.254: v1(76.39,62.66) 77.61,63.88 83.95,63.88 86.07,61.75 86.07,59.46 v1(86.03,59.42)
  BOTTOM w0.102: v1(86.03,59.42) 86.22,59.42 86.35,59.29 86.35,59.15 85.75,58.54 v2(85.59,58.54)
  BOTTOM w0.254: PU610.17 84.98,59.24 85.17,59.05 85.67,59.05 v1(86.03,59.42)
N49226542: length 2.6
  BOTTOM w0.102: PR692.2 v2(72.31,74.25)
  BOTTOM w0.254: PR692.2 72.36,75.21 73.38,76.23 PU613.1
N49226544: length 3.5
  BOTTOM w0.102: PR671.2 71.87,75.69 v2(70.41,75.69)
  BOTTOM w0.254: PR671.2 72.47,76.15 73.06,76.73 PU613.2
N49227484: length 1.6
  BOTTOM w0.102: PC671.2 71.6,82.55 70.99,83.17 70.99,83.69 v2(70.89,83.8)
N49227486: length 1.6
  BOTTOM w0.102: PR672.2 70.42,78.8 v2(70.12,79.1)
N49227488: length 1.5
  BOTTOM w0.102: PC671.1 70.31,81.15 v2(70.16,81.01)
N49228457: length 3.2
  TOP w0.102: v1(73.38,75.5) v2(73.38,74.38)
  TOP w0.254: PR689.2 v1(73.38,75.5)
  BOTTOM w0.254: v1(73.38,75.5) 73.38,75.29 73.58,75.09 73.96,75.09 74.21,75.35 PU613.17
N49230528: length 10.4
  TOP w0.102: v1(70.57,46.96) v2(69.97,46.96)
  TOP w0.254: PR681.2 64.41,47.08 64.68,46.8 v1(65.09,46.8)
  BOTTOM w0.254: v1(70.57,46.96) 70.5,46.9 69.11,46.9 67.76,45.55 66.31,45.55 65.09,46.77 v1(65.09,46.8) 64.98,46.91 PU612.17
N49231011: length 2.5
  BOTTOM w0.102: PR665.1 61.56,51.5 60.9,51.5 v2(60.5,51.91)
  BOTTOM w0.635: PC663.1 PR665.1
N49231017: length 2.9
  BOTTOM w0.102: v2(60.49,50.53) 60.72,50.76 62.09,50.76 62.88,51.55 PR665.2
N49231205: length 4.1
  BOTTOM w0.102: v2(61.08,48.94) 61.24,49.09 62.74,49.09 63.11,48.73 PR664.2
  BOTTOM w0.254: PR664.2 63.14,48.59 63.76,48.59 64.28,49.11 PU612.1
N49231242: length 2
  TOP w0.254: PR662.2 64.32,49.53 v1(63.58,49.53)
  BOTTOM w0.254: PU612.2 63.97,49.91 v1(63.58,49.53)
N49939391: length 2.4
  TOP w0.102: RZ364.2 262.61,12.01 262.61,10.82 262.1,10.3 JUSH1.23
N50084581: length 3
  TOP w0.102: RC433.2 246.28,42.77 246.56,42.49 QC6.1 245.86,41.7 v2(245.51,42.06)
N50084583: length 7.8
  TOP w0.102: v2(245.32,43.41) 245.8,43.88 246.72,43.88 246.87,43.72 246.88,43.72 RC433.1 247.68,43.4 248.72,44.45 249.15,44.45 249.57,44.03 RC432.2 250.45,41.87 CC340.1
N50204886: length 2
  BOTTOM w0.102: PR914.2 31.01,38.05 29.7,38.05 v2(29.58,37.93)
N50205391: length 0.8
  TOP w0.102: PC944.1 30.92,49.76 PR934.2
N50521287: length 3.2
  TOP w0.102: RV97.1 172.38,79.54 v2(171.76,79.54) 171.01,79.54 170.39,80.16 UV7.20
N50521312: length 2.1
  TOP w0.102: UV7.17 169.19,80.17 169.37,79.98 169.37,79.27 CV96.1
N50577367: length 1.9
  TOP w0.102: RZ62.1 153.7,61.51 154.64,60.58 UZ12.27
N50631091: length 4.7
  TOP w0.102: v2(248.4,33.42) 248.4,34.08 247.68,34.81 246.91,34.81 CZ126.1 246.44,34.36 245.95,34.85 UZ5.12
N50631103: length 3.9
  TOP w0.102: v2(246.85,32.49) 246.44,32.9 CZ127.1 246,33.89 246,34.27 245.15,35.12 UZ5.10
N50631939: length 6.1
  TOP w0.203: UA1.25 268.31,17.85 268.41,17.75 268.41,17.45 v1(268.15,17.19)
  BOTTOM w0.203: CA49.2 272.51,17.98 v2(271.09,17.98) 268.94,17.98 v1(268.15,17.19)
N50631945: length 3.7
  TOP w0.203: CA25.2 269.92,20.65 v2(269.18,20.65) 268.03,20.65 UA1.32
N50631959: length 30.3
  TOP w0.102: v1(268.84,21.13) 268.77,21.05 UA1.33
  BOTTOM w0.102: v1(268.84,21.13) 267.35,22.61 262.68,22.61 261.78,21.72 261.78,20.86 261.04,20.11 260.25,20.11 258.83,21.54 258.83,21.98 258.55,22.26 258.15,22.26 256.69,23.72 256.42,23.72 254.61,25.52 254.61,26.06 255.15,26.59 v2(255.68,26.59) 256.09,26.59 256.6,26.08 258.35,26.08 258.75,26.49 260.1,26.49 260.4,26.79 261.68,26.79 262.67,25.8 RA53.1 RA57.1
N50631969: length 2.3
  TOP w0.203: UA1.24 267.52,17 CA29.2
N50632394: length 4
  TOP w0.203: UA1.38 266.78,23.51 267.06,23.8 268.28,23.8 268.48,23.59 v2(269.13,23.59) 269.92,23.59 CA35.2
N50632521: length 6.8
  TOP w0.203: 268.62,24.14 268.5,24.27 v2(266.96,24.27) 266.38,23.68 UA1.39
  TOP w0.508: RA44.2 271.07,23.02 CA51.2 270.86,24.14 268.62,24.14
N50632689: length 10
  TOP w0.203: UA1.21 265.98,16.04 266.27,15.74 v1(267.01,15.74)
  BOTTOM w0.203: CA52.2 273.68,16.06 273.21,15.59 270.92,15.59 v2(270.63,15.88) 270.34,16.18 267.21,16.18 267.01,15.97 v1(267.01,15.74)
N50632795: length 4.1
  TOP w0.203: UA1.23 266.78,16.59 267.06,16.3 267.71,16.3 268.22,15.79 268.22,14.91 CA29.1
N50632802: length 8.1
  TOP w0.102: v2(258.87,17.45) 259.81,17.45 259.87,17.38 CA53.2
  TOP w0.203: v1(265,15.79) 265.18,15.97 UA1.19
  TOP w0.381: CA53.2 v1(261.05,17.38)
  BOTTOM w0.381: v1(261.05,17.38) 262.64,15.79 v1(265,15.79)
N50670221: length 2.6
  TOP w0.102: CA33.1 RA17.1 255.93,19.33 v2(256.21,19.33)
N50714989: length 4.8
  TOP w0.102: v2(290.28,48.26) 288.6,48.26 288.14,47.8 RV620.2 286.85,47.8 286.43,48.22 UV6.11
N50740210: length 5.5
  TOP w0.102: v2(73.76,110.48) 74.59,110.48 RV326.2 74.22,109.83 74.22,109.01 74.68,108.56 RV323.2 RV324.2 74.39,108.03 QV7.2
N50865698: length 9.1
  TOP w0.102: v1(104.3,71.34) v2(102.13,73.51) 101.38,74.27 101.38,74.63 99.88,76.13 RC436.2
  BOTTOM w0.076: v1(104.3,71.34) 104.3,70.91 103.96,70.57 UC1.F65 UC1.G65
N50938785: length 23.1
  TOP w0.102: DE2.1 259.17,60.88 260.44,62.15 260.9,62.15 261.09,61.96 CE64.1 261.5,61.57 v1(261.74,61.32) 261.95,61.11 RE565.1 ; QE15.2 276.69,64.39 RE543.2 276.51,64.56 RE541.2 v1(275.65,63.14)
  BOTTOM w0.102: v1(261.74,61.32) 263.49,61.32 264.37,62.2 v2(270.57,62.2) 270.7,62.2 270.85,62.35 274.86,62.35 v1(275.65,63.14)
N50938791: length 22
  TOP w0.102: v1(274.83,63.75) 275.24,63.34 v2(275.24,60.85) 275.24,60.5 RE546.2 ; v1(258.32,63.34) 258.32,63.67 258.76,64.12 QE17.1
  BOTTOM w0.102: v1(258.32,63.34) 258.5,63.52 274.6,63.52 v1(274.83,63.75)
N51488834: length 2.6
  TOP w0.102: UV6.12 v1(286.66,48.61)
  BOTTOM w0.102: v2(284.92,48.76) RV622.2 286.51,48.76 v1(286.66,48.61)
N51859224:
  vias: v2(258.45,69.08)
N52552880: length 7.7
  TOP w0.102: v2(63.39,102.41) CZ200.1 RZ380.2 62.76,99.88 62.37,99.88 61.52,99.03 61.52,97.98 62.09,97.41 QZ1.2
N119328643: length 5.6
  TOP w0.102: PR930.1 27.63,46.03
  TOP w0.203: 27.63,46.03 PR931.2 29.1,46.03 v1(29.15,46.09) ; PR930.1 27.59,46.05 PC938.1
  BOTTOM w0.102: v2(27.91,47.33) 29.15,46.09 v1(29.15,46.09)
  BOTTOM w0.203: v1(29.15,46.09) 29.15,46.48 29.27,46.59 29.52,46.59 29.65,46.46 PU901.25
N132000604: length 2.4
  BOTTOM w0.102: v2(37.9,41.7) 37.85,41.75 PR921.2
  BOTTOM w0.508: PC934.1 PR921.2
N132005053: length 34.6
  TOP w0.102: v1(36.71,46.2) 37.25,46.75 v2(37.25,46.78)
  TOP w0.254: v1(37.44,25.32) 37.6,25.32 37.84,25.56 PR917.3
  IN1 w0.254: v1(36.71,46.2) 36.83,46.32 37.74,46.32 38.84,45.22 38.84,43.38 40.09,42.13 40.09,41.37 42.26,39.19 43.82,39.19 45.27,37.75 45.27,28.62 44,27.35 43.74,27.35 42.47,26.08 42.47,25.95 41.97,25.45 37.57,25.45 v1(37.44,25.32)
  BOTTOM w0.254: v1(36.71,46.2) 36.82,46.31 PR938.2
N5052105529: length 4
  TOP w0.102: UV7.4 163.99,79.81 163.55,79.37 163.12,79.37 162.82,79.07 162.82,77.97 T204.1
N5052105531: length 5.3
  TOP w0.102: UV7.2 163.19,80.25 162.59,79.65 162.59,77.06 163.48,76.17 T223.1
N5052105558: length 5.6
  TOP w0.102: UV7.14 167.99,80.02 168.05,79.96 168.05,76.78 167.14,75.87 T224.1

## Copper pours and planes (outline as drawn)
2.5VSP on TOP (solid shape): 217.17,16.51 217.17,14.07 217.05,13.94 215.93,13.94 215.76,14.11 215.76,14.89 215.31,15.34 214.01,15.34 213.7,15.65 213.7,16.24 213.83,16.38 214.4,16.38 214.4,15.86 214.84,15.86 214.84,16.38 215.5,16.38 215.85,16.73 216.95,16.73
3V_SN on TOP (solid shape): 139.88,106.47 139.88,105.46 139.76,105.33 137.34,105.33 137.22,105.46 137.22,106.47 137.34,106.6 139.76,106.6
3V_VIN on TOP (solid shape): 156.92,111.11 156.92,110.59 156.37,110.59 156.37,110.04 156.92,110.04 156.92,109.79 156.37,109.79 156.37,109.24 156.92,109.24 156.92,108.49 156.8,108.37 155.79,108.37 153.96,110.2 146.8,110.2 146.71,110.11 142.7,110.11 142.45,110.36 142.45,111.22 142.57,111.35 142.8,111.35 142.82,111.33 143.38,111.33 143.41,111.36 156.66,111.36
3V_VIN on BOTTOM (solid shape): 155.62,111.23 155.62,109.08 155.5,108.96 155.24,108.96 154.05,110.15 147.12,110.15 147,110.03 144.64,110.03 144.01,109.39 144.01,107.86 143.84,107.69 142.41,107.69 142.36,107.74 142.36,111.3 142.61,111.55 155.3,111.55
3V_VIN on IN2 (solid shape): 155.58,111.35 155.58,109.06 155.48,108.96 149.58,108.96 148.52,110.03 142.42,110.03 142.32,110.13 142.32,111.27 142.6,111.55 155.38,111.55
3V_VIN on IN4 (solid shape): 155.58,110.87 155.58,109.04 155.5,108.96 149.84,108.96 148.84,109.97 142.77,109.97 142.32,110.41 142.32,111.27 142.6,111.55 154.89,111.55
3V_VIN on IN3: 142.6,111.55 155.28,111.55 155.67,111.16 155.67,109.16 155.48,108.96 149.46,108.96 148.39,110.03 142.45,110.03 142.32,110.16 142.32,111.27
5V_SN on TOP (solid shape): 45.39,50.47 45.39,49.45 45.27,49.32 42.47,49.32 42.35,49.45 42.35,50.47 42.47,50.59 45.27,50.59
5V_VIN on TOP (solid shape): 45.97,43.98 46.07,43.88 46.19,43.82 46.21,43.82 46.51,43.52 46.51,42.34 45.96,42.34 45.96,41.83 46.51,41.83 46.51,41.54 45.96,41.54 45.96,41.03 46.45,41.03 46.49,41 46.49,40.02 46.05,39.58 43.45,39.58 43.36,39.67 43.36,40.63 43.43,40.69 43.43,42.3 43.51,42.36 43.58,42.44 43.62,42.51 43.64,42.58 43.63,42.75 43.55,42.89 43.54,42.9 43.53,42.93 43.54,42.97 43.55,42.98 43.64,43.16 43.62,43.37 43.56,43.47 43.47,43.55 43.44,43.56 43.44,44.8 43.59,44.95 44.99,44.95
5V_VIN on BOTTOM (solid shape): 44.2,45.03 44.2,44.71 44.49,44.42 45.21,44.42 45.55,44.08 45.55,40.11 45.09,39.65 43.49,39.65 43.41,39.72 43.41,40.23 43.41,40.26 43.41,42.14 43.67,42.4 43.67,43.56 43.63,43.61 43.06,43.61 42.97,43.69 42.97,43.73 43,43.83 43,44.04 42.98,44.14 42.97,44.15 42.97,45.15 43.06,45.23 44,45.23
+0.6V_DDR_VTT on TOP (solid shape): 117.25,13.48 117.25,13.2 117.23,13.17 117.23,12.72 117.11,12.61 117.11,12.07 116.74,11.71 115.55,11.71 115.21,11.36 113.69,11.36 113.53,11.53 113.53,12.55 113.81,12.83 114.92,12.83 115.66,13.57 117.16,13.57
+0.6V_DDR_VTT on TOP (solid shape): 199.71,13.58 199.71,10.69 199.37,10.34 196.37,10.34 196.3,10.37 196.27,10.45 195.89,10.84 195.51,10.45 195.48,10.37 195.41,10.34 193.86,10.34 193.7,10.5 193.7,13.41 193.92,13.63 194,13.66 194.08,13.62 194.16,13.54 194.27,13.49 194.33,13.42 194.32,13.33 194.41,12.8 194.94,12.89 195.03,12.94 195.11,12.89 195.69,12.84 195.65,13.42 195.61,13.47 195.61,13.53 195.84,13.75 197.62,13.75 197.62,13.75 198.1,13.75 198.11,13.76 199.53,13.76
+0.6V_DDR_VTT on BOTTOM (solid shape): 57.59,53.46 58.73,53.46 58.78,53.41 58.78,52.73 58.65,52.6 56.95,52.6 56.79,52.76 56.79,53.43 57.03,53.67 57.38,53.67
+0.6V_DDR_VTT on BOTTOM (solid shape): 199.83,13.74 199.83,13.09 199.71,12.98 198.85,12.98 198.58,12.71 198.58,11.04 198.49,10.95 198.36,10.95 198.27,11.04 198.27,12.69 197.94,13.03 197.94,13.78 198.13,13.98 199.59,13.98
+0.6V_DDR_VTT on BOTTOM (solid shape): 117.29,13.46 117.29,13.2 117.02,12.94 116.83,12.94 116.58,12.69 116.58,11.02 116.49,10.93 116.36,10.93 116.27,11.02 116.27,12.93 116.12,13.08 116.12,13.48 116.28,13.63 117.12,13.63
+0.6V_DDR_VTT on IN1 (solid shape): 74.73,14.07 74.73,12.09 74.68,12.04 73.72,12.04 73.51,12.24 73.51,13.99 73.69,14.17 74.63,14.17
+0.6V_DDR_VTT on IN1 (solid shape): 199.73,13.66 199.73,12.24 199.15,11.66 197.69,11.66 197.32,12.03 197.32,13.05 198.14,13.87 199.52,13.87
+0.6V_DDR_VTT on IN1 (solid shape): 117.25,13.52 117.25,11.92 117.06,11.73 115.98,11.73 115.87,11.84 115.87,13.55 115.99,13.66 117.11,13.66
+0.6V_DDR_VTT on IN4 (solid shape): 117.28,13.5 117.28,12.28 117.01,12.01 116.21,12.01 116.03,12.2 116.03,13.38 116.26,13.61 117.16,13.61
+0.6V_DDR_VTT on IN4 (solid shape): 75.09,22.86 75.09,14.58 74.82,14.31 74.82,12.73 74.6,12.52 73.44,12.52 73.21,12.75 73.21,14.98 72.95,15.24 72.95,22.25 68.99,26.21 64.37,26.21 63.72,26.86 63.72,27.79 64.08,28.15 69.79,28.15
+0.6V_DDR_VTT on IN3: 63.61,26.82 61.78,28.65 61.78,43.3 58.91,46.17 58.91,51.81 58.24,52.48 56.7,52.48 56.6,52.58 56.6,53.64 56.84,53.87 59.11,53.87 59.11,53.87 64.31,53.87 64.62,53.56 64.62,49.55 65.18,48.99 65.18,46.27 64.42,45.51 64.42,31.47 65.43,30.45 65.43,27.3 64.95,26.82
+0.6VSP on BOTTOM (solid shape): 55.58,58.7 55.58,57.81 56.21,57.17 56.21,55.95 56.9,55.27 57.48,55.27 57.79,54.96 58.48,54.96 58.71,54.73 58.71,53.64 58.68,53.61 58.41,53.61 58.41,54.15 57.98,54.15 57.98,53.61 57.66,53.61 57.46,53.81 56.85,53.81 56.85,53.82 56.07,54.6 56.07,54.93 55.99,55.01 55.9,55.16 55.75,55.25 55.5,55.5 55.5,56.97 54.84,57.63 54.84,58.7 54.92,58.77 55.5,58.77
+0.9V_LAN on TOP (solid shape): 258.3,66.52 258.3,65.33 258.17,65.21 257.15,65.21 257.05,65.31 257.05,66.5 257.13,66.58 258.24,66.58
+0.9V_LAN on TOP (solid shape): 266.38,70.01 266.38,68.57 265.91,68.11 265.34,68.11 265.13,67.89 264.42,67.89 264.12,68.18 264.12,70.11 264.38,70.37 266.02,70.37
+0.9V_LAN on IN2: 256.61,65.29 258.25,65.29 258.31,65.35 258.31,66.54 258,66.84 256.9,66.84 256.55,66.49 256.55,65.35
+0.9V_LAN on IN2: 264.45,68.66 265.99,68.66 266.03,68.7 266.03,69.94 265.96,70.01 264.56,70.01 264.38,69.83 264.38,68.72
+0.9V_LAN on IN4: 259.16,78.11 260.58,78.11 260.79,77.9 260.79,75.62 260.13,74.96 260.13,72.86 261.47,71.51 265.14,71.51 266,70.65 266,69.48 264.26,67.74 262.47,67.74 262.46,67.75 261.92,67.75 259.85,69.82 257.31,69.82 257.18,69.95 257.18,70.82 257.07,70.93 254.41,70.93 254.24,71.1 254.24,76.75 254.32,76.84 255.94,76.84 255.94,76.83 258.9,76.83 259.04,76.97 259.04,77.99
+1.0V_APLL on TOP (solid shape): 133.66,64.82 133.66,64.47 133.63,64.46 133.45,64.31 133.41,64.08 133.41,63.95 133.47,63.82 133.47,63.42 133.41,63.36 132.9,63.36 132.83,63.42 132.83,63.99 132.64,64.18 132.64,64.56 132.75,64.67 133.13,64.67 133.34,64.88 133.6,64.88
+1.0V_APLLEBB on TOP (solid shape): 130.48,66.25 130.48,65.95 130.04,65.52 129.75,65.52 129.74,65.51 129.7,65.51 129.7,65.48 129.59,65.37 129.59,64.83 129.56,64.8 129.36,64.8 129.36,64.79 128.97,64.79 128.94,64.83 128.94,65.69 129.08,65.83 129.54,65.83 129.59,65.83 129.83,65.97 129.88,66.24 130.05,66.41 130.31,66.41
+1.0V_APLLEBB on IN2 (solid shape): outline of 465 points within 129.47,65.81 135.39,72.2
+1.0V_CLK3 on IN2 (solid shape): outline of 300 points within 128.67,67.34 131.78,72.62
+1.0V_CLK6 on BOTTOM (solid shape): 136.02,74.85 136.07,74.72 136.18,74.62 136.23,74.55 136.2,74.46 135.87,74.13 135.77,74.13 135.49,73.85 135.49,73.24 135.38,73.13 135,73.13 134.85,73.28 134.85,73.55 134.85,73.61 134.85,73.71 134.87,73.74 134.9,73.76 135.16,73.92 135.18,74.22 135.18,74.39 135.64,74.85
+1.0V_CLK6 on BOTTOM: 136.75,79.4 139.34,79.4 139.46,79.29 139.46,78.85 139.34,78.72 136.83,78.72 136.73,78.83 136.73,79.38
+1.0V_DTS on BOTTOM: 143.27,65.54 141.72,65.54 141.57,65.39 140.88,65.39 140.87,65.38 140.39,65.38 140.16,65.38 140.05,65.48 140.05,65.83 140.18,65.95 140.41,65.95 140.42,65.95 140.49,65.92 140.56,65.91 140.65,65.91 140.72,65.92 140.78,65.95 140.79,65.95 141.39,65.95 141.65,66.22 141.66,66.22 141.83,66.39 142.62,66.39 143.68,67.46 147.39,67.46 147.66,67.74 148.65,67.74 148.76,67.63 148.76,67.05 148.71,67 148.23,67 147.95,66.72 144.44,66.72 144.01,66.29
+1.0V_MPHYAON on TOP (solid shape): outline of 262 points within 130.63,66.6 133.66,71.19
+1.0V_MPHYAON on BOTTOM: 145.59,68.84 145.38,68.84 144.72,68.17 143.39,68.17 143.38,68.17 143.33,68.17 143.2,68.04 142.1,68.04 141.91,68.23 141.91,68.86 142.19,69.13 143.29,69.13 143.95,69.8 143.95,70.12 143.9,70.17 143.91,70.2 143.86,70.59 143.5,70.73 143.47,70.73 143.42,70.76 143.42,70.78 143.33,70.93 143.18,71.02 143.15,71.03 143.15,71.28 143.29,71.42 144.23,71.42 145.8,69.85 145.91,69.85 145.95,69.81 146.21,69.81 146.23,69.82 146.87,69.82 147.07,69.77 147.27,69.82 147.52,69.82 147.68,69.99 148.59,69.99 148.71,69.86 148.71,68.93 148.61,68.84 145.59,68.84
+1.0V_MPHYGT on TOP (solid shape): 133.48,66.02 133.48,66.01 133.54,65.95 133.81,65.95 133.86,65.91 133.86,65.63 133.81,65.59 133.59,65.59 133.57,65.61 133.36,65.61 133.05,65.29 133.05,64.86 132.99,64.8 132.69,64.8 132.47,65.02 132.47,65.27 132.48,65.28 132.48,65.29 132.19,65.58 131.67,65.58 131.5,65.58 131.24,65.85 131.24,66.18 131.48,66.42 133.08,66.42
+1.0V_MPHYGT on BOTTOM (solid shape): 132.99,66.47 132.99,66.03 132.47,65.51 131.75,65.51 131.42,65.84 131.38,65.89 131.34,65.92 131.34,65.94 131.22,66.07 131.22,66.24 131.01,66.45 131.01,66.67 131.11,66.78 132.69,66.78
+1.0V_MPHYGT on BOTTOM (solid shape): 142.44,83.47 143.19,83.47 143.19,83.47 143.19,84.02 143.75,84.02 143.97,83.79 143.97,81.82 143.94,81.78 143.06,81.78 142.38,81.1 141.68,81.1 141.56,81.1 141.36,80.89 141.36,80.06 141.2,79.9 140.98,79.9 140.73,80.15 139.79,80.15 139.34,80.6 138.69,80.6 138.61,80.68 138.61,82.11 140.51,84.02 141.19,84.02 141.24,83.97 141.24,83.47 141.24,83.47 141.99,83.47 141.99,83.47 141.99,84.02 142.44,84.02
+1.0V_MPHYGT on IN2 (solid shape): outline of 1350 points within 131.17,65.43 141.83,81.58
+1.0V_MPHYGT on IN3 (solid shape): outline of 1738 points within 131.29,65.18 139.76,78.48
+1.0V_MPHYGT on VCC: 135.51,64.69 134.88,65.33 131.45,65.33 131.12,65.61 131.12,68.06 132.11,69.05 132.11,81.07 132.75,81.71 141.55,81.71 141.91,81.35 141.91,77.75 139.75,75.59 139.8,65.51 138.98,64.69
+1.0V_PRIM on TOP (solid shape): 161.94,101.09 161.94,100.57 161.4,100.57 161.4,99.86 161.94,99.86 161.94,99.37 161.4,99.37 161.4,98.66 161.94,98.66 161.94,97.91 162.51,97.33 162.51,96.36 162.26,96.11 158.69,96.11 158.45,96.35 158.45,101.06 158.67,101.28 161.75,101.28
+1.0V_PRIM on TOP (solid shape): 130.44,62.16 130.44,61.92 130.05,61.53 127.95,61.53 127.85,61.63 127.85,62.04 127.98,62.17 128.54,62.17 128.74,62.36 128.83,62.36 128.9,62.36 129.03,62.39 129.09,62.42 129.11,62.44 129.14,62.46 129.47,62.46 129.57,62.44 129.66,62.46 129.72,62.46 129.82,62.55 130.05,62.55
+1.0V_PRIM on BOTTOM (solid shape): 127.91,85.04 127.91,84.55 127.91,84.54 127.91,82.89 128.33,82.47 128.33,81.53 128.29,81.49 126.86,81.49 126.83,81.52 126.83,82.22 126.9,82.29 126.9,83.28 126.17,84.01 126.17,85.01 126.33,85.17 127.78,85.17
+1.0V_PRIM on BOTTOM (solid shape): 129.37,62.51 129.57,62.44 129.77,62.51 129.96,62.51 130,62.48 130.29,62.19 130.33,62.15 130.43,62.05 130.43,61.87 130.28,61.72 130.05,61.72 129.87,61.79 129.69,61.72 129.4,61.72 129.22,61.79 129.04,61.72 128.76,61.72 128.65,61.82 128.65,62.07 128.68,62.09 128.79,62.17 128.85,62.29 128.85,62.3 128.97,62.42 128.98,62.42 129.05,62.46 129.12,62.51
+1.0V_PRIM on BOTTOM (solid shape): 156.7,76.66 156.78,76.26 157.18,76.17 157.18,72.45 156.49,71.76 156.49,69.44 156.12,69.07 154.99,69.07 154.41,68.49 154.41,67.86 153.71,67.86 153.6,67.98 153.6,68.75 153.53,68.82 153.53,68.87 153.48,68.87 152.94,69.41 152.43,69.41 152.27,69.26 152.27,69.17 152.26,69.09 152.25,69.03 152.25,68.71 152.27,68.69 152.27,68.53 152.14,68.4 150.87,68.4 150.44,68.82 150.38,68.88 149.49,68.88 149.41,68.97 149.41,69.81 149.49,69.9 150.03,69.9 150.16,70.02 150.18,70.03 151.44,70.41 152.52,71.16 152.53,71.17 152.93,71.61 153.27,72.1 153.27,72.1 153.45,72.44 153.6,72.79 153.63,72.74 153.68,72.7 153.92,72.03 154.17,72.7 154.3,73 154.17,73.29 154.4,73.39 154.52,73.62 154.38,73.97 154,74.02 153.91,74.04 153.87,74.12 153.82,74.99 153.59,75.83 153.58,75.86 154.38,76.66
+1.0V_PRIM on BOTTOM: 161.57,91.77 161.29,91.68 161.29,91.67 161.25,91.66 161.22,91.67 161.21,91.68 161.02,91.77 160.8,91.74 160.69,91.66 160.63,91.59 159.01,89.97 145.02,89.97 144.15,89.1 144.15,84.39 143.96,84.2 143.05,84.2 143.03,84.18 143.03,83.67 143,83.64 142.62,83.64 142.59,83.67 142.59,84.18 141.83,84.18 141.83,83.67 141.81,83.64 141.43,83.64 141.4,83.67 141.4,84.18 140.72,84.18 140.71,84.18 139.55,84.18 138.22,82.85 137.09,82.85 136.71,82.47 136.71,80.56 136.86,80.41 137.22,80.41 137.32,80.31 137.32,79.76 137.28,79.72 135.76,79.72 135.69,79.79 135.69,81.7 134.92,82.47 134.92,82.52 134.55,82.9 131.99,82.9 131.55,83.34 131.04,83.85 131.04,85.71 131.2,85.87 132.2,85.87 132.76,86.43 132.76,97.91 133.26,98.41 141.43,98.41 142.78,99.76 149.21,99.76 151.49,97.48 162.32,97.48 162.54,97.26 162.54,97.11 162.41,96.69 162.54,96.28 162.54,91.84 162.5,91.75 162.4,91.74 162.17,91.77 161.97,91.65 161.9,91.62 161.83,91.65
+1.0V_PRIM on IN3: 147.83,68.93 145.48,68.93 145.11,68.56 145.11,66.45 145.34,66.23 149.12,66.23 149.47,66.57 149.47,68.1 149.64,68.27 150.15,68.27 150.69,67.73 152.15,67.73 152.27,67.86 152.27,69.48 152.08,69.68 148.56,69.68 148.56,69.66
+1.0V_PRIM on VCC: 143.67,50.85 142.91,51.61 142.4,51.61 141.38,52.62 136.73,52.62 136.22,52.12 134.4,52.12 133.89,52.62 133.63,52.62 133.08,53.17 132.65,53.17 131.47,54.35 131.47,56.99 130.72,57.75 130.41,57.75 128.93,57.76 127.74,57.76 127.35,58.14 127.35,63.06 129.11,64.82 134.67,64.82 135.3,64.19 139.19,64.19 140.31,65.3 140.26,75.38 142.42,77.54 142.42,81.56 141.77,82.22 135.8,82.22 135.56,82.45 135.56,87.19 135.92,87.55 142.06,87.55 143.51,86.1 145.29,84.2 147.63,81.86 147.63,71.7 149.15,70.17 149.15,55.02 144.98,50.85
+1.0V_PRIM_CORE on TOP (solid shape): 131.62,61.38 131.62,60.99 131.55,60.91 131.37,60.91 131.37,60.91 131.04,60.91 130.94,60.81 130.78,60.81 130.73,60.86 130.05,60.86 129.95,60.96 129.95,61.29 130.06,61.4 130.1,61.4 130.27,61.58 131.42,61.58
+1.0V_PRIM_CORE on BOTTOM (solid shape): 167.32,96.29 167.32,95.15 166.77,95.15 166.77,94.64 167.32,94.64 167.32,94.35 166.77,94.35 166.77,93.84 167.32,93.84 167.32,93.37 167.35,93.37 167.35,93.22 167.14,93.01 165.18,93.01 164.7,93.49 164.7,96.39 165.05,96.74 166.86,96.74
+1.0V_PRIM_CORE on BOTTOM (solid shape): 128.1,64.16 128.21,64.1 128.33,64.09 128.51,63.77 128.82,63.97 128.82,63.98 128.97,63.98 128.97,63.97 129.23,63.77 129.47,63.98 129.6,63.98 129.65,63.85 129.76,63.76 129.79,63.75 129.79,63.63 129.6,63.44 129.35,63.44 129.33,63.44 129.19,63.46 129.06,63.41 128.74,63.41 128.42,63.42 128.3,63.12 128.3,63.02 128.24,62.97 128.24,62.48 128.29,62.43 128.29,62.32 128.29,61.59 128.3,61.59 128.3,61.56 128.41,61.28 128.7,61.26 128.71,61.26 129,61.26 129.17,61.09 129.17,60.95 129.14,60.93 129.05,60.89 128.98,60.81 128.97,60.78 128.83,60.78 128.82,60.81 128.62,60.94 128.39,60.88 128.17,60.88 128.16,60.92 128.04,61.12 127.83,61.19 127.77,61.2 127.71,61.23 127.68,61.3 127.68,63.83 127.71,63.87 127.74,63.92 127.93,63.99 128.05,64.16
+1.0V_PRIM_CORE on IN3: outline of 379 points within 128.09,53.82 172.01,96.29
+1.0V_PRIM_COREP on TOP (solid shape): 169.63,96.22 169.63,95.3 169.6,95.27 169.6,94.03 169.47,93.9 168.46,93.9 168.2,94.15 168.2,96.19 168.38,96.36 169.48,96.36
+1.0V_PRIM_COREP on BOTTOM (solid shape): 170.06,97.53 170.06,96.62 169.63,96.19 169.63,93.72 169.32,93.42 167.47,93.42 167.47,93.5 167.44,93.5 167.44,93.97 166.89,93.97 166.89,94.22 167.44,94.22 167.44,94.77 166.89,94.77 166.89,95.02 167.44,95.02 167.44,96.34 167.44,96.34 167.44,97.38 167.62,97.56 170.03,97.56
+1.0V_SRAM on BOTTOM (solid shape): 140.74,79.41 140.74,78.32 140.65,78.23 140.65,76.66 139.96,75.97 139.52,75.97 139.51,75.98 139.49,75.98 139.27,76.2 139.27,76.89 139.71,77.34 139.71,79.34 139.83,79.46 140.69,79.46
+1.0V_SRAM on IN2 (solid shape): outline of 609 points within 128.62,63.03 141.2,76.9
+1.0V_SRAM on IN4 (solid shape): 129.13,64.64 129.13,63.09 129.09,63.08 129.04,63.08 128.55,62.93 128.65,62.43 128.7,62.35 128.66,62.27 128.54,62.1 128.53,61.9 128.12,61.49 127.89,61.23 127.97,60.89 128.02,60.82 128.1,60.76 128.1,60.68 127.87,60.45 127.61,60.45 127.48,60.58 127.48,63.31 128.26,64.09 128.59,64.28 128.53,64.65 128.6,64.72 129.06,64.72
+1.0V_VCCST on BOTTOM (solid shape): 129.2,84.65 129.2,83.5 129.75,82.95 129.75,82.48 130.1,82.14 130.1,81.9 129.54,81.9 129.54,81.42 130.1,81.42 130.1,81.05 129.95,80.91 129.95,79.72 129.92,79.71 129.72,79.57 129.65,79.33 129.77,79.04 130.08,78.94 130.13,78.94 130.23,78.84 130.28,78.84 130.35,78.77 130.35,78.51 130.28,78.44 129.63,78.44 129.01,79.05 129.01,80.42 128.54,80.89 128.54,82.53 128.08,82.99 128.08,84.62 128.21,84.75 129.09,84.75
+1.0V_VCCST on IN2 (solid shape): outline of 134 points within 126.69,66.45 128.55,72.94
+1.0V_VCCST_C on BOTTOM (solid shape): 134.05,82.49 134.05,82.16 133.7,81.81 132.98,81.81 132.34,81.17 132.15,81.17 132.05,81.07 131.64,81.07 131.63,81.07 130.33,81.07 130.25,81.15 130.25,81.57 129.69,81.57 129.69,81.75 130.25,81.75 130.25,82.12 130.31,82.18 131.19,82.18 131.62,82.61 133.93,82.61
+1.0V_VCCSTG on BOTTOM (solid shape): 128.86,87.65 128.86,87.17 128.91,87.12 129.36,87.12 129.38,87.14 129.38,87.69 129.39,87.7 129.63,87.7 129.65,87.69 129.65,86.76 129.4,86.52 129.4,86 129.92,85.49 129.92,83.52 129.77,83.37 129.55,83.37 129.4,83.52 129.4,85.12 129.14,85.38 128.25,85.38 128.15,85.48 128.15,87.54 128.31,87.7 128.81,87.7
+1.0V_VCCSTG_C on BOTTOM (solid shape): 132.49,89.58 132.49,88.18 132.34,88.03 129.8,88.03 129.64,87.86 129.22,87.86 129.22,87.86 129.22,87.33 129.19,87.3 129.07,87.3 129.04,87.33 129.04,87.86 129.04,87.86 128.6,87.86 128.53,87.93 128.53,88.54 128.76,88.77 130.68,88.77 130.86,88.96 130.86,89.45 131.1,89.68 132.38,89.68
+1.0VS_VCCIO on TOP (solid shape): 124.74,61.09 124.74,59.16 124.53,58.95 124.27,58.95 124.14,58.82 124.14,56.96 123.95,56.77 122.73,56.77 122.63,56.87 122.63,57.12 122.64,57.13 122.64,58.77 123.09,59.23 123.09,60.17 123.11,60.19 123.82,60.19 124.03,60.39 124.03,61.09 124.13,61.19 124.64,61.19
+1.0VS_VCCIO on BOTTOM (solid shape): 171.89,58.03 173.14,58.03 173.46,57.72 173.46,56.28 173.21,56.03 172.05,56.03 172.01,55.99 171.61,55.99 171.6,56 171.6,56.52 171.58,56.54 171.08,56.54 171.06,56.52 171.06,55.99 171.05,55.98 170.81,55.98 170.8,55.99 170.8,56.53 170.79,56.54 170.28,56.54 170.26,56.52 170.26,55.99 170.25,55.98 169.85,55.98 169.6,56.23 169.6,57.58 170.06,58.04 171.89,58.04
+1.0VS_VCCIO on BOTTOM (solid shape): outline of 189 points within 122.66,56.75 124.77,59.74
+1.0VS_VCCIO on IN3: outline of 163 points within 98.48,35.35 173.47,59.56
+1.2V_DDR_B+ on TOP (solid shape): 61.95,61.72 61.95,60.65 61.4,60.65 61.4,60.07 61.95,60.07 61.95,59.86 61.4,59.86 61.4,59.31 61.42,59.28 61.95,59.28 61.95,58.95 61.27,58.95 60.46,59.76 60.46,59.78 59.07,59.78 58.73,60.12 58.09,60.12 57.48,60.73 57.48,61.72 57.66,61.9 61.78,61.9
+1.2V_DDR_B+ on BOTTOM (solid shape): 60.68,61.59 60.68,60.09 60.56,59.97 59.06,59.97 58.92,60.1 55.76,60.1 55.74,60.12 55.74,60.57 55.79,60.62 57.46,60.62 57.56,60.72 57.56,61.87 58.27,62.58 58.98,62.58 59.69,62.58
+1.2V_DDRP on TOP (solid shape): 57.33,52.29 57.33,49.7 57.08,49.45 53.14,49.45 52.96,49.63 52.96,52.29 53.09,52.42 57.21,52.42
+1.2V_DDRP on BOTTOM (solid shape): 57.34,51.57 57.34,51.16 57.56,50.95 58.5,50.95 58.62,50.82 58.62,50.17 58.59,50.14 57.91,50.14 57.91,50.13 54.91,50.13 54.83,50.13 54.41,49.71 54.41,49.45 54.28,49.32 52.83,49.32 52.48,48.97 49.03,48.97 48.87,49.12 48.87,50.39 48.86,50.4 48.86,52.21 49.28,52.62 56.29,52.62
+1.2V_DDRP on BOTTOM (solid shape): 54.67,58.67 54.67,57.56 55.3,56.92 55.3,55.58 55.26,55.55 55.06,55.6 54.86,55.53 54.7,55.53 54.49,55.6 54.28,55.53 54.2,55.53 53.8,55.93 53.8,58.59 53.98,58.77 54.56,58.77
+1.2V_DDRP on IN2 (solid shape): 55.31,58.21 55.31,56.14 55.15,55.98 54.04,55.98 53.73,55.66 53.72,55.66 53.46,55.39 53.55,55.03 53.56,55 53.45,54.71 53.56,54.42 53.45,54.13 53.54,53.87 53.56,53.81 53.54,53.74 53.55,53.23 54.06,53.18 56.1,53.18 57.33,51.95 57.33,49.97 56.93,49.56 52.68,49.56 51.4,50.84 51.4,57.8 52.13,58.53 54.99,58.53
+1.2V_MEM on TOP (solid shape): 72.06,29.65 64.06,29.65 64.06,37.65 72.06,37.65
+1.2V_MEM on TOP (solid shape): 89.37,35.58 81.37,35.58 81.37,43.58 89.37,43.58
+1.2V_MEM on TOP (solid shape): 109.52,26.33 94.52,26.33 94.52,36.33 109.52,36.33
+1.2V_MEM on TOP (solid shape): outline of 9868 points within 49.16,9.92 194.24,56.63
+1.2V_MEM on BOTTOM (solid shape): 165.16,22.42 165.16,21.48 164.8,21.13 160.08,21.13 159.85,21.36 159.85,22.22 160.63,23.01 164.57,23.01
+1.2V_MEM on BOTTOM (solid shape): 170.72,22.04 170.72,21.87 170.46,21.61 170.16,21.61 168.74,23.03 168.74,23.41 168.89,23.57 169.19,23.57
+1.2V_MEM on BOTTOM (solid shape): 175.77,23.06 175.77,21.59 175.44,21.26 175.01,21.26 174.76,21.51 174.76,23.06 174.98,23.29 175.54,23.29
+1.2V_MEM on BOTTOM (solid shape): 173.38,23.62 173.38,21.56 173.11,21.28 172.14,21.28 172.01,21.41 172.01,22.17 172.09,22.25 172.09,23.57 172.37,23.85 173.16,23.85
+1.2V_MEM on BOTTOM (solid shape): 55.88,49.42 56.61,49.42 56.61,49.97 57.06,49.97 57.06,49.4 57.78,49.4 57.81,49.4 57.81,49.97 58.48,49.97 58.48,49.96 58.73,49.7 58.73,46.56 58.03,45.86 54.44,45.86 54.28,46.02 54.28,47.42 54.67,47.8 54.67,49.7 54.93,49.97 55.88,49.97
+1.2V_MEM on IN2 (solid shape): 112.65,26.59 112.65,24.91 112.02,24.28 112.02,22.48 112.04,22.45 112.04,21.69 111.36,21 77.32,21 76.23,22.09 76.23,24.99 76.74,25.5 102.29,25.5 104.12,27.33 111.92,27.33
+1.2V_MEM on IN2 (solid shape): 174.81,11.6 174.81,10.83 174.78,10.81 174.58,10.63 174.55,10.37 174.56,10.34 174.43,10.21 167.06,10.21 166.98,10.25 166.96,10.33 166.59,10.8 166.22,10.33 166.2,10.25 166.12,10.21 165.64,10.21 165.55,10.25 165.54,10.35 165.19,10.87 164.84,10.35 164.83,10.25 164.74,10.21 159.57,10.21 159.46,10.32 159.47,10.35 159.5,10.52 159.45,10.69 159.44,10.7 159.44,10.71 159.31,10.84 159.27,10.84 159.26,10.85 159.12,10.87 158.97,10.85 158.97,10.84 156.01,10.84 155.76,10.59 155.76,10.33 155.63,10.21 154.49,10.21 153.85,10.84 146.99,10.84 146.23,10.08 144.33,10.08 144.2,10.21 144.2,11.6 144.45,11.86 174.55,11.86
+1.2V_MEM on IN3 (solid shape): outline of 423 points within 89.93,9.99 107.14,11.53
+1.2V_MEM on IN4 (solid shape): 189.54,11.35 189.54,10.21 189.41,10.08 187.84,10.08 187.75,10.13 187.75,10.23 187.43,10.81 187.1,10.23 187.1,10.13 187.01,10.08 186.85,10.08 186.76,10.13 186.76,10.23 186.43,10.8 186.09,10.23 186.09,10.13 186,10.08 183.53,10.08 183.44,10.13 183.44,10.24 183.12,10.83 182.8,10.24 182.81,10.13 182.72,10.08 181.56,10.08 181.47,10.14 181.47,10.24 181.17,10.85 180.86,10.24 180.87,10.14 180.78,10.08 180.39,10.08 180.31,10.13 180.31,10.23 179.97,10.8 179.64,10.23 179.64,10.13 179.55,10.08 177.57,10.08 177.48,10.15 177.51,10.26 177.26,10.93 177,10.26 177.03,10.15 176.94,10.08 176.15,10.08 176.07,10.13 176.06,10.23 175.94,10.74 175.42,10.64 175.34,10.6 175.25,10.65 174.72,10.78 174.61,10.24 174.62,10.13 174.53,10.08 172.78,10.08 172.52,10.33 172.52,10.97 172.78,11.22 174.05,11.22 174.43,11.6 189.29,11.6
+1.8V_3.3V_ALW_VTR3 on TOP (solid shape): 240.66,47.11 240.66,46.56 240.67,46.56 242.09,46.56 242.28,46.37 242.28,45.42 241.71,44.85 240.66,44.85 240.66,44.85 240.66,44.3 240.65,44.29 240.48,44.29 240.48,44.85 240.47,44.85 240.07,44.85 240.07,44.86 240.07,46.55 240.07,46.55 240.47,46.55 240.48,46.56 240.48,47.11 240.48,47.12 240.65,47.12
+1.8V_PGPPF on TOP (solid shape): outline of 796 points within 131.22,58.09 146.55,62.99
+1.8V_PRIM on TOP (solid shape): 145.76,63.03 146.56,63.03 147.43,62.16 147.43,60.34 147.41,60.32 146.77,60.32 146.68,60.42 146.68,61.18 146.68,61.3 146.85,61.3 146.85,61.86 146.68,61.86 146.68,61.87 146.55,62 146.53,62 146.44,62.1 143.92,62.1 143.76,62.26 143.76,62.94 143.86,63.04 145.75,63.04
+1.8V_PRIM on TOP (solid shape): 239.83,45.13 239.83,44.78 239.89,44.71 240.33,44.71 240.33,44.15 240.34,44.14 240.8,44.14 240.81,44.15 240.81,44.7 240.81,44.7 241.07,44.7 241.13,44.65 241.13,43.51 240.85,43.23 240.85,41.45 239.55,40.15 239.55,39.51 240.16,38.9 240.16,38.28 239.25,37.37 236.36,37.37 236.28,37.45 236.28,38.19 236.39,38.3 237.7,38.3 237.77,38.3 238.46,38.99 238.46,39.6 238.33,39.74 238.33,42.23 238.53,42.43 238.53,42.53 238.54,42.54 238.54,44.05 238.53,44.05 238.53,45.01 238.82,45.3 239.65,45.3
+1.8V_PRIM on BOTTOM (solid shape): 167.76,104.93 167.76,104.51 168.31,104.51 168.31,104.33 167.76,104.33 167.76,103.81 167.65,103.7 166.9,103.7 166.79,103.81 166.79,104.8 166.92,104.93 167.76,104.93
+1.8V_PRIM on BOTTOM (solid shape): 145.83,62.94 145.99,62.77 146.97,62.77 148.62,62.77 148.73,62.66 148.73,61.27 148.68,61.22 148.07,61.22 148.02,61.24 147.97,61.25 147.91,61.31 144.93,61.31 144.24,62 143.01,62 142.89,62.12 141.84,62.12 141.57,62.39 141.57,62.61 141.63,62.66 142.59,62.66 142.8,62.87 143.55,62.87 143.62,62.94 144.16,62.94
+1.8V_PRIM on IN3 (solid shape): 167.67,104.72 167.67,102.7 167.49,102.52 166.7,102.52 166.52,102.71 166.52,104.7 166.72,104.9 167.49,104.9
+1.8V_PRIM on IN3 (solid shape): 178.07,53.61 178.16,53.51 178.16,51.83 177.44,51.1 176.63,51.1 176.49,51.24 176.49,52.23 176.71,52.45 176.71,53.87 176.94,54.1 177.57,54.1
+1.8V_PRIM on IN3 (solid shape): outline of 541 points within 211.09,38.21 239.71,45.56
+1.8V_PRIM on IN1: outline of 129 points within 144.15,52.09 177.46,62.97
+1.8V_RUN on TOP (solid shape): 238.63,34.56 239.03,34.56 239.14,34.45 239.14,33.72 239.01,33.59 237.13,33.59 236.75,33.97 236.33,33.97 236.25,34.05 236.25,34.46 236.36,34.56 238.4,34.56 238.4,35.12 238.63,35.12
+1.8V_RUN on TOP (solid shape): 265.87,13 265.87,12.49 266.12,12.24 267.64,12.24 267.77,12.11 267.77,9.44 267.49,9.16 267.42,9.13 267.35,9.15 266.99,9.23 266.73,8.97 266.72,8.94 265.61,8.94 265.28,9.27 265.28,12.2 264.85,12.63 264.85,13 264.98,13.13 265.74,13.13
+1.8V_RUN on BOTTOM (solid shape): 245.5,13.35 245.5,12.98 245.36,12.83 243.68,12.83 243.46,13.06 243.46,13.89 243.61,14.04 244.81,14.04
+1.8V_RUN on BOTTOM (solid shape): 238.51,33.87 238.51,32.57 238.43,32.49 237.53,32.49 237.31,32.72 237.31,33.42 236.96,33.77 236.96,34.16 237.14,34.35 238.03,34.35
+1.8V_RUN on IN2 (solid shape): 266.77,9.28 266.77,9.05 266.74,8.99 266.72,8.92 266.59,8.79 265.22,8.79 264.82,9.19 264.82,9.78 265.15,10.11 265.94,10.11
+1.8V_RUN on IN2 (solid shape): 245.68,13.25 245.68,11.42 245.2,10.95 244.01,10.95 243.63,11.33 243.63,12.2 244.64,12.2 244.64,12.17 244.65,12.12 244.67,12.06 244.69,12.01 244.72,11.97 244.76,11.93 244.8,11.89 244.85,11.86 244.9,11.84 244.96,11.82 245.01,11.82 245.07,11.82 245.12,11.83 245.17,11.85 245.22,11.87 245.27,11.91 245.31,11.95 245.34,11.99 245.37,12.04 245.39,12.09 245.4,12.15 245.41,12.2 245.4,12.26 245.39,12.31 245.37,12.36 245.34,12.41 245.31,12.46 245.27,12.49 245.22,12.53 245.17,12.55 245.12,12.57 245.07,12.58 245.01,12.58 244.96,12.58 244.9,12.56 244.85,12.54 244.8,12.51 244.76,12.48 244.72,12.43 244.69,12.39 244.67,12.34 244.65,12.28 244.64,12.23 244.64,12.2 243.63,12.2 243.63,12.46 244.45,13.28 245.64,13.28
+1.8V_RUN on BOTTOM: 238.05,27.22 237.8,26.97 237.8,25.7 239.2,24.3 239.96,24.3 240.47,24.81 240.47,26.59 239.83,27.22
+1.8V_RUN_CARD on BOTTOM: 85.91,111.04 84.76,111.04 84.38,110.66 84.38,109.14 84.13,108.89 82.73,108.89 82.48,108.63 82.48,108.25 82.73,108 85.27,108 86.03,108.76 86.03,110.92
+1.8V_RUN_CARD on IN4: 76.38,95.3 75.37,95.3 75.11,95.04 75.11,93.9 75.49,93.52 76.13,93.52 76.64,94.03 76.64,95.04
+1.8V_RUN_UZ8 on TOP (solid shape): 238.14,36.97 238.14,36.35 238.05,36.25 238.02,36.27 237.5,35.85 238.13,35.62 238.19,35.65 238.26,35.62 238.69,35.58 238.89,35.96 238.91,36.05 238.99,36.08 239.03,36.08 239.17,35.94 239.17,34.82 239.04,34.69 238.75,34.69 238.75,35.25 238.27,35.25 238.27,34.69 236.42,34.69 236.27,34.84 236.27,35.89 236.35,35.97 236.94,35.97 237.04,36.07 237.04,36.95 237.16,37.06 238.05,37.06
+1.8VALWP on TOP (solid shape): 170.55,106.61 170.55,105.41 170.06,104.92 168.43,104.92 168.08,105.27 168.08,106.22 168.2,106.35 169.23,106.35 169.69,106.81 170.36,106.81
+1.8VALWP on BOTTOM (solid shape): 172.1,106.13 172.1,105.16 172.06,105.12 172.03,105.12 171.91,105.12 171.8,105.09 171.79,105.09 169.84,105.09 169.34,104.59 169.34,103.46 169.2,103.31 168.04,103.31 167.91,103.44 167.91,104.2 168.45,104.2 168.45,104.63 168.44,104.64 167.91,104.64 167.91,106.24 168.04,106.37 171.86,106.37
+1VALWP on TOP (solid shape): 165.35,101.43 165.35,97.61 165.19,97.45 162.69,97.45 162.06,98.08 162.06,98.79 161.54,98.79 161.54,99.24 162.06,99.24 162.06,99.99 161.54,99.99 161.54,100.44 162.06,100.44 162.06,101.31 162.36,101.61 165.17,101.61
+1VALWP on BOTTOM (solid shape): 165.33,101.47 165.33,98 165.1,97.77 161.68,97.77 161.4,98.05 161.4,101.35 161.65,101.6 165.19,101.6
+1VALWP_B+ on TOP (solid shape): 159.75,109.64 159.75,107.94 159.49,107.67 159.21,107.67 158.93,107.39 158.93,106.44 158.77,106.28 156.37,106.28 156.15,106.5 156.15,107.97 156.3,108.12 158.34,108.12 158.81,108.59 158.81,109.49 159.06,109.74 159.65,109.74
+1VALWP_B+ on BOTTOM (solid shape): 159.77,109.69 159.77,107.74 159.67,107.64 159.21,107.64 158.94,107.37 158.94,106.49 158.95,106.47 159.17,106.25 159.18,106.25 159.6,106.25 159.68,106.17 159.68,104.72 159.59,104.63 158.19,104.63 157.99,104.83 157.85,104.83 157.8,104.84 157.75,104.83 156.44,104.83 156.01,106.47 155.5,107.49 155.5,108.65 155.78,108.93 155.78,109.68 155.9,109.8 156.34,109.8 156.34,109.77 156.36,109.77 156.36,109.27 156.87,109.27 156.87,109.77 156.89,109.77 156.89,109.8 157.14,109.8 157.14,109.77 157.16,109.77 157.16,109.27 157.67,109.27 157.67,109.77 157.69,109.77 157.69,109.8 158.06,109.8 158.06,109.8 159.66,109.8
+1VS_VCCIOP on TOP (solid shape): 170.83,54.84 170.83,52.33 170.62,52.12 169.73,52.12 169.49,52.35 169.49,54.86 169.68,55.04 170.64,55.04
+1VS_VCCIOP on BOTTOM: 168.58,55.6 168.84,55.85 169.22,55.85 169.22,55.85 170.37,55.85 170.39,55.87 170.39,56.39 170.41,56.4 170.65,56.4 170.66,56.39 170.66,55.86 170.67,55.85 171.17,55.85 171.19,55.87 171.19,56.39 171.21,56.41 171.45,56.41 171.47,56.4 171.47,55.87 171.48,55.86 172.04,55.86 172.14,55.76 172.14,55.24 171.99,55.09 170.87,55.09 170.72,54.94 170.72,54.28 171.02,53.97 171.02,49.82 170.64,49.43 168.76,49.43 168.58,49.61
