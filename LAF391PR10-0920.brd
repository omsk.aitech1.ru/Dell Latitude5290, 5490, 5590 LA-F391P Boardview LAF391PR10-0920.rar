# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ESPI_IO0_R: length 45.6
  TOP w0.102: RC366.1 168.94,40.75 v2(168.36,40.75) 165.8,40.75 164.01,42.54 v1(164.01,43.1)
  BOTTOM w0.076: 137.75,45.97 137.75,46.12 137.95,46.31 137.95,46.74 137.59,47.1 136.74,47.1 134.27,49.58 134.1,49.58 133.22,50.46 133.22,50.65 133.02,50.85 133.02,51.13 133.05,51.21 133.05,51.46 133.02,51.59 133.02,51.76 133.08,51.94 133.18,52.06 133.28,52.17 UC1.AY13
  BOTTOM w0.102: 137.75,45.97 137.75,45.63 138.96,44.42 144.88,44.42 148.75,40.56 161.47,40.56 v1(164.01,43.1)
ESPI_IO1: length 127.5
  TOP w0.076: UE1.L4 261.98,46.49 v1(261.98,46.53)
  TOP w0.102: v1(183.57,39.14) 183.57,38.91 v2(181.82,37.16) 177.32,37.16 175.87,38.6 175.38,38.6 175.28,38.71 175.28,39.09 175.18,39.19 174.98,39.19 174.88,39.09 174.88,38.71 174.77,38.6 174.57,38.6 174.47,38.71 174.47,39.09 174.37,39.19 174.17,39.19 174.06,39.09 174.06,38.71 173.96,38.6 173.76,38.6 173.66,38.71 173.66,39.09 173.56,39.19 173.35,39.19 173.25,39.09 173.25,38.71 173.15,38.6 172.95,38.6 172.84,38.71 172.84,39.09 172.74,39.19 172.54,39.19 172.44,39.09 172.44,38.71 172.34,38.6 172.13,38.6 172.03,38.71 172.03,39.09 171.93,39.19 171.73,39.19 171.63,39.09 171.63,38.71 171.52,38.6 171.32,38.6 171.22,38.71 171.22,39.09 171.12,39.19 170.91,39.19 170.81,39.09 170.81,38.71 170.71,38.6 RC367.2
  IN2 w0.122: v1(183.57,39.14) 184,39.57 184.54,39.57 184.79,39.32 184.79,35.71 186.09,34.41 194.32,34.41 194.71,34.79 205.76,34.79 206.36,34.2 211.14,34.2 212.8,32.53 214.61,32.53 215.19,33.12 225.4,33.12 225.99,33.7 232.18,33.7 233.58,35.1 235.5,35.1 236.04,35.63 236.07,35.63 239.7,39.27 239.7,40.01 240.38,40.69 240.64,40.69 v1(240.78,40.55)
  IN4 w0.089: v1(240.78,40.55) 240.51,40.82 240.51,45.69 241.03,46.21 242.26,46.21 244.54,43.93 248.32,43.93 251.7,47.32 256.32,47.32 257.13,46.5 261.95,46.5 v1(261.98,46.53)
  BOTTOM w0.102: v1(240.78,40.55) 242.68,38.65 244.53,38.65 245.14,38.05 245.7,38.05 248.16,35.59 JESPI.4
ESPI_IO1_R: length 44
  TOP w0.102: RC367.1 v2(168.15,38.6) 167.24,38.6 v1(162.74,43.1)
  BOTTOM w0.076: 138.74,45.97 138.74,46.47 138.45,46.75 137.75,47.46 136.89,47.46 134.43,49.92 134.22,49.92 133.55,50.59 133.55,51.41 UC1.BA13
  BOTTOM w0.102: 138.74,45.97 138.74,45.64 139.5,44.88 145.07,44.88 148.84,41.12 160.76,41.12 v1(162.74,43.1)
ESPI_IO2: length 127.5
  TOP w0.102: UE1.G6 v1(263.61,49.73) ; RC368.2 v2(174.73,39.52) 178.55,39.52 179.34,38.73 182.53,38.73 v1(182.94,39.14)
  IN2 w0.122: v1(182.94,39.14) 183.77,39.98 184.81,39.98 185.17,39.62 185.17,35.86 186.37,34.66 194.22,34.66 194.6,35.04 205.87,35.04 206.46,34.45 211.24,34.45 212.9,32.79 214.43,32.79 215.02,33.37 225.28,33.37 226.03,34.12 232.25,34.12 233.67,35.54 234.67,35.54 235.02,35.88 235.97,35.88 239.45,39.37 239.45,40.11 240.54,41.19 241.13,41.19 242.07,40.26 v1(242.17,40.26)
  IN4 w0.089: v1(242.17,40.26) 241.84,40.59 241.84,43.23 240.73,44.34 240.73,45.6 241.12,46 242.17,46 244.45,43.72 248.41,43.72 251.79,47.1 256.23,47.1 257.08,46.25 258.65,46.25 259.54,45.36 262.22,45.36 262.42,45.57 262.42,45.9 262.42,45.9 262.42,47.53 262.58,47.69 262.96,47.69 263.2,47.93 263.2,49.31 v1(263.61,49.73)
  BOTTOM w0.102: JESPI.5 247.99,36.09 245.8,38.27 245.42,38.27 243.44,40.26 v1(242.17,40.26)
ESPI_IO2_R: length 44
  TOP w0.102: v1(163.38,43.1) 163.38,42.8 166.36,39.81 v2(167.35,39.81) 168.97,39.81 RC368.1
  BOTTOM w0.076: 137.95,45.97 137.95,46.05 138.13,46.23 138.13,46.84 137.69,47.28 136.82,47.28 134.34,49.76 134.15,49.76 133.38,50.52 133.38,50.92 UC1.BB13
  BOTTOM w0.102: 137.95,45.97 137.95,45.76 139.06,44.65 144.98,44.65 148.84,40.79 161.07,40.79 v1(163.38,43.1)
ESPI_IO3: length 126.4
  TOP w0.076: UE1.L5 262.75,45.81 262.75,44.06 262.8,44 262.8,43.72 v1(262.84,43.68)
  TOP w0.102: v1(184.21,39.14) 184.21,39.01 181.87,36.67 176.89,36.67 v2(176.13,37.44) 175.26,38.3 170.76,38.3 RC369.2
  IN2 w0.122: v1(184.21,39.14) 184.48,38.86 184.48,35.35 185.68,34.16 194.87,34.16 195.25,34.55 205.66,34.55 206.25,33.95 211.03,33.95 212.73,32.25 220.98,32.25 221.29,32.56 225.23,32.56 225.96,33.3 232.13,33.3 233.53,34.69 235.45,34.69 235.56,34.8 235.59,34.8 239.8,39.01 241.51,39.01 243.12,40.62 v1(243.12,41.68)
  IN4 w0.089: v1(243.12,41.68) 242.47,42.33 242.47,42.9 240.94,44.43 240.94,45.51 241.21,45.78 242.08,45.78 244.36,43.5 248.5,43.5 249.55,44.55 251.64,44.55 253.31,46.21 254.12,46.21 254.66,45.67 256.26,45.67 256.63,46.03 258.56,46.03 259.45,45.14 262.04,45.14 262.95,44.24 262.95,43.77 262.86,43.68 v1(262.84,43.68)
  BOTTOM w0.102: v1(243.12,41.68) 243.78,41.02 244.24,41.02 244.78,40.47 244.78,40.2 245.8,39.19 246.03,39.19 246.21,39.01 246.21,38.32 247.95,36.59 JESPI.6
ESPI_IO3_R: length 44.8
  TOP w0.102: v1(162.11,43.1) 162.11,42.83 167.71,37.23 v2(168.15,37.23) 168.77,37.23 RC369.1
  BOTTOM w0.076: UC1.AY12 133.56,52.36 133.56,51.72 133.71,51.56 133.71,50.66 134.22,50.15 134.44,50.15 136.95,47.64 137.87,47.64 138.6,46.9 138.94,46.56 138.94,46
  BOTTOM w0.102: 138.94,46 138.94,45.94 139.78,45.11 145.17,45.11 148.17,42.11 161.12,42.11 v1(162.11,43.1)
ESPI_RESET#: length 177.7
  TOP w0.102: UE1.K6 263.22,46.91 263.55,46.58 v1(263.55,46.53) ; v2(140.89,45.35) 140.5,45.75 v1(140.47,45.75)
  IN1 w0.089: v1(140.47,45.75) 146.1,40.12 151.22,40.12 159.55,31.8 182.9,31.8 189.98,24.71 198.23,24.71 198.91,24.03 199.47,24.03 201.35,22.14 202.15,22.14 204.11,20.19 204.11,19.84 206.84,17.1 206.84,16.2 208.23,14.81 213.35,14.81 214.43,15.89 216.49,15.89 218.6,18 218.6,18.79 218.95,19.14 219.69,19.14 220.19,19.64 v1(222.06,19.64)
  IN2 w0.076: v1(263.55,46.53) 263.17,46.91 261.69,46.91
  IN2 w0.122: v1(222.06,19.64) 223.99,19.64 224.45,19.19 231.79,19.19 234.11,21.51 237.55,21.51 237.86,21.83 237.86,22.1 239.68,23.91 243.04,23.91 243.33,23.62 244.56,23.62 244.85,23.92 245.42,23.92 245.45,23.89 247.01,23.89 247.41,24.29 247.41,24.7 247.85,25.14 248.32,25.14 248.75,25.57 248.75,28.19 248.64,28.29 248.64,32.14 251.39,34.88 251.39,35.83 252.99,37.44 253.37,37.44 253.75,37.05 v1(253.75,36.98) 254.03,37.26 254.03,37.72 253.8,37.94 253.8,38.56 255.88,40.64 257.1,40.64 257.33,40.86 260.17,40.86 260.68,40.36 261.01,40.36 261.27,40.61 261.27,40.97 260.94,41.3 260.68,41.3 260.18,41.8 260.18,42.97 259.95,43.2 259.95,44.6 260.89,45.54 260.89,46.15 261.65,46.91 261.69,46.91
  BOTTOM w0.076: UC1.BA11 134.21,51.41 134.21,50.87 134.39,50.69 134.6,50.69 136.66,48.62 137.85,48.62 138.34,48.13 138.73,48.13 139.18,47.67 139.18,47.47 138.99,47.28 138.99,47.04 139.31,46.72 139.31,46.37
  BOTTOM w0.102: v1(253.75,36.98) 252.63,38.1 RE560.2 ; v1(140.47,45.75) 139.94,45.75 139.31,46.37
FB_1.8VALW: length 4.2
  BOTTOM w0.102: v2(176.85,103.07) 176.85,103.81 PR501.2
  BOTTOM w0.254: PC503.2 176.31,105.24 PU501.6 ; PC503.2 176.59,104.98 PR506.1 ; PC503.2 176.57,104.1 PR501.2
FB_+1VALWP: length 1.2
  BOTTOM w0.102: PR311.1 164.16,107.6 v2(163.86,107.91)
FB_GT: length 4.6
  TOP w0.203: PU602.17 72.32,67.61 72.37,67.56 v1(72.45,67.56)
  BOTTOM w0.254: v1(72.45,67.56) 72.45,67.49 PR648.2 73.11,65.95 PR645.2 73.11,65.43 PR650.1
FB_VSA: length 6.6
  TOP w0.203: PU602.25 68.57,70.83 v1(68.48,70.91) 68.25,71.15 PR646.1
  BOTTOM w0.102: PR652.1 68.44,72.31 v2(69.84,72.31)
  BOTTOM w0.254: PR649.1 PR652.1 67.83,71.57 v1(68.48,70.91)
FCCM_GT: length 36.5
  TOP w0.203: PU602.21 70.17,69.86 70.74,70.43 70.74,70.68 v1(70.77,70.71)
  TOP w0.254: PR662.1 65.54,48.64 65.27,48.37 v1(64.44,48.37)
  IN2 w0.254: v1(70.77,70.71) 70.81,70.71 72.62,68.9 72.62,68.07 72.93,67.76 72.93,64.85 67.68,59.6 67.68,57.67 69.51,55.85 69.51,52.86 69.94,52.43 69.94,49.18 69.13,48.37 v1(64.44,48.37)
  BOTTOM w0.102: v1(70.77,70.71) 71.1,70.71 v2(72.19,71.8)
FCCM_IA: length 42.2
  TOP w0.102: v2(70.08,76.45) 70.3,76.23 v1(70.69,76.23)
  TOP w0.203: v1(71.84,64.65) 71.77,64.65 71.2,65.21 PU602.11
  IN1 w0.254: v1(83.08,56.54) 83.86,56.54 86.54,59.22 86.54,61.82 84,64.36 v1(83.58,64.36) ; v1(70.69,76.23) 70.1,75.64 70.1,74.79 71.56,73.33 71.56,70.48 70.59,69.52 70.59,65.89 v1(71.84,64.65)
  IN4 w0.254: v1(71.84,64.65) 72.2,64.65 73.77,66.21 76.05,66.21 76.33,65.93 78.02,65.93 78.71,65.25 78.71,64.25 79.11,63.84 83.06,63.84 v1(83.58,64.36)
  BOTTOM w0.254: PR659.1 83.16,56.45 v1(83.08,56.54) ; v1(70.69,76.23) 70.78,76.15 PR671.1
FCCM_VSA: length 44.8
  TOP w0.203: PU602.29 66.97,69.99 66.52,70.44 v1(66.48,70.44)
  IN3 w0.254: v1(66.48,70.44) 66.48,70.17 66.12,69.82 65.7,69.82 65.31,70.21 65.31,73.07 61.88,76.5 61.88,79.6 62.51,80.23 62.51,81.86 63.73,83.08 68.58,83.08 71.56,86.05 80.6,86.05 81.06,85.59 85.07,85.59 85.32,85.85 85.32,86.1 v1(85.37,86.15)
  BOTTOM w0.102: v1(66.48,70.44) 66.48,70.21 v2(66.23,69.97)
  BOTTOM w0.254: v1(85.37,86.15) 84.85,86.15 84.26,85.56 84.26,84.81 84.56,84.5 PR679.2
FFS_INT2: length 185.8
  TOP w0.102: RC404.1 148.04,65.92 145.56,65.92 143.77,67.71 v1(141.12,67.71) ; v1(177.65,58.87) 177.65,58.29 185.42,50.52 185.42,47.16 v2(184.49,46.23) 183.19,44.93 v1(178.21,44.93) ; QN1.2 250.13,13.74 249.89,13.5 249.09,13.5 248.85,13.25 248.85,11.73 249.43,11.15 249.43,9.6 250.04,8.99 250.04,7.91 250.57,7.38 v1(250.57,6.09)
  IN1 w0.089: v1(177.65,58.87) 176.79,59.74 176.79,61.55 176.53,61.81 176.53,62.3 175.09,63.75 175.09,64.42 171.03,68.47 165.44,68.47 164.38,69.53 160.18,69.53 158.1,71.61 156.29,71.61 154.84,70.16 152.57,70.16 151.68,69.28 148,69.28 147.59,68.87 145.13,68.87 144.72,68.46 141.87,68.46 v1(141.12,67.71) ; v1(250.57,6.09) 250.18,6.09 247.76,8.52 246.68,8.52 244.89,10.31 244.4,10.31 v1(242.02,12.7)
  IN4 w0.089: v1(240.17,14.54) 239.99,14.35 233.47,14.35 232.47,15.36 229.72,15.36 229.11,15.97 220.77,15.97 220.09,15.29 217.73,15.29 216.72,16.3 216.72,16.89 215.92,17.69 214.23,17.69 213.13,18.79 211.81,18.79 209.85,20.75 202.09,20.75 198.32,24.51 198.32,27.91 194.84,31.39 193.43,31.39 186.41,38.4 186.41,38.91 180.4,44.93 v1(178.21,44.93)
  BOTTOM w0.076: UC1.J5 137.96,68.33 138.45,67.84 138.84,67.84 138.93,67.75 141.03,67.75 141.08,67.71 v1(141.12,67.71)
  BOTTOM w0.102: v1(240.17,14.54) v1(242.02,12.7) 244.21,10.5 LGA1.11
FFS_INT2_Q: length 14.2
  TOP w0.102: QN1.3 250.78,14.62 250.37,14.21 250.37,13.42 RN1.2 250.37,12.48 250.37,11.15 v2(250.31,11.08) 250.17,10.94 250.17,9.91 250.78,9.31 250.78,8.25 251.01,8.02 253.72,8.02 255.16,6.59 v1(255.16,6.17)
  BOTTOM w0.102: v1(255.16,6.17) 254.9,6.43 JSATA1.19
FIVR_EN: length 2.9
  BOTTOM w0.102: v2(93.44,91.23) RC218.1 RC219.1 92.29,92.22 RC217.1
FIVR_EN_R: length 5.4
  BOTTOM w0.102: JXDP1.45 v2(92.14,96.08) 92.14,95.76 91.7,95.33 RC126.2 91.37,94.45 RC132.1 RC217.2
GPIO011: length 7.3
  TOP w0.076: 266.45,42.85 266.3,42.99 266.3,43.55 265.8,44.06 265.41,44.06 265.14,44.33 265.14,45.58 264.96,45.77 264.72,45.77 264.39,46.1 264.39,46.56 UE1.K7
  TOP w0.102: T143.1 266.55,41.66 266.55,42.74 266.45,42.85
GPIO051: length 1.8
  TOP w0.076: UE1.D1 258.91,51.73 258.81,51.84 257.88,51.84 257.81,51.9 T141.1
GPIO054: length 4.2
  TOP w0.076: UE1.L11 267.7,45.66 267.7,44.42 268.91,43.2 268.91,42.85
  TOP w0.102: T142.1 268.91,42.85
GPIO100: length 2.1
  TOP w0.076: T144.1 258.31,44.42 UE1.M1
GPIO202: length 9.1
  TOP w0.076: v1(264.39,48.1) 263.59,48.1 UE1.J6
  BOTTOM w0.102: T262.1 268.3,44.09 266.7,44.09 264.65,46.14 264.65,46.57 264.01,47.21 264.01,47.72 v1(264.39,48.1)
GPP_B23: length 14.2
  TOP w0.102: v1(138.17,57.82) 138.66,57.32 141.28,57.32 v2(141.62,56.99) 143.36,55.24 147.38,55.24 147.62,55.48 147.97,55.48 149.09,56.6 RC317.1
  BOTTOM w0.076: v1(138.17,57.82) 138.13,57.78 137.42,57.78 UC1.AM7
GPP_C5: length 11.5
  BOTTOM w0.076: UC1.W1 142.32,63.51
  BOTTOM w0.102: RC25.1 150.77,65.01 148.99,65.01 148.6,64.62 144.93,64.62 144.49,64.18 v2(144.16,64.18) 143.78,64.18 143.25,63.65 142.46,63.65 142.32,63.51
GPP_C8: length 12.6
  BOTTOM w0.076: UC1.AB1 140.61,62.19 141.23,62.19 141.69,61.73 142.46,61.73 142.68,61.51 143.07,61.51 143.41,61.18
  BOTTOM w0.102: 143.41,61.18 v2(143.6,60.98) 144.12,60.46 146.26,60.46 146.8,59.91 148.92,59.91 149.12,60.11 150.5,60.11 150.74,60.35 150.74,60.97 RC405.1
GPP_E23: length 1.2
  TOP w0.102: v1(134.34,66.31) 134.34,66.42 T120.1
  BOTTOM w0.076: UC1.N12 133.97,66.65 134.31,66.31 v1(134.34,66.31)
GPS_DISABLE#: length 28.6
  TOP w0.102: v2(261.01,31.89) RE12.1 261.42,32.79 DZ6.1 263.54,31.73 264.49,31.73 264.75,31.99 264.75,32.2 265.18,32.64 265.18,33.45 v1(265.03,33.6) ; UE1.H5 v1(262.82,48.93)
  IN3 w0.122: v1(265.03,33.6) 265.03,34.86 267.14,36.97 267.14,39.19 267.69,39.75 267.69,47.19 267.16,47.72 266.58,47.72 266.42,47.88 266.42,48.38 266.27,48.54 264.6,48.54 264.57,48.51 263.24,48.51 v1(262.82,48.93)
GPS_DISABLE#_R: length 5.5
  TOP w0.102: DZ6.2 264.56,32.9 264.72,33.07 v2(264.72,33.13) 264.72,33.32 v1(264.44,33.6)
  BOTTOM w0.102: v1(264.44,33.6) 264.44,34.18 265,34.74 JNGFF2.26
GPU_PWR_LEVEL: length 5.8
  TOP w0.076: 270.69,49.36 v2(270.63,49.3) ; 271.04,50.6 270.75,50.89 270.43,50.89 270.01,50.47 268.49,50.47 UE1.E12
  TOP w0.102: 271.04,50.6 271.04,50.4 271.56,49.88 RE5.1 270.91,49.58 270.69,49.36
GPU_SMCLK: length 11.3
  TOP w0.076: v1(263.55,50.52) 263.64,50.52 UE1.F7
  BOTTOM w0.102: v1(263.55,50.52) 263.22,50.19 263.22,47.82 263.33,47.72 263.33,47.32 263.94,46.71 263.94,45.49 266.5,42.93 v2(266.5,42.39) RE525.1
GPU_SMDAT: length 8.1
  TOP w0.076: UE1.B6 262.91,53.65 262.91,54.69 262.36,55.24 262.36,55.93
  TOP w0.102: RE524.1 261.45,60.36 262.28,59.52 v2(262.28,58.89) 262.28,57.19 262.36,57.11 262.36,55.93
GREEN: length 12.1
  TOP w0.102: LV17.2 284.17,58.59 CV130.1 286.21,58.59 DV5.3 288.68,59.15 v2(289.92,57.91) 292.28,55.55 292.84,55.55 JCRT1.2
GREEN_CRT: length 11.9
  TOP w0.102: UV6.22 283.18,50.87 283.18,51.98 281.51,53.64 v2(281.51,54.09) 281.51,59.38 281.74,59.61 RV117.1 CV127.1 283.9,59.61 LV17.1
GT_SNUB: length 3.6
  TOP w0.102: PR669.2 v2(70.01,49.43)
  TOP w0.635: PR669.2 70.01,52.03 70.39,52.41 PC670.1
GT_SW: length 1.9
  TOP w0.102: PR669.1 v2(72.67,49.37)
  vias: v1(73.59,51.04) v1(73.59,50.4)
H_CATERR#: length 23.4
  BOTTOM w0.076: UC1.D63 105.08,72.03 105.16,72.29 105.16,72.41 105.24,72.69 105.28,72.84 105.29,72.86 105.3,72.89 105.3,73.13 105.27,73.19 105.27,73.45 105.28,73.48 105.3,73.5 105.3,73.93 104.77,74.45 104.77,76.62 104.33,77.06 104.33,77.39 104.2,77.52
  BOTTOM w0.102: RC79.1 112.12,86.18 112.12,84.5 111.87,84.25 110.01,84.25 109.45,84.81 v2(107.45,84.81) 106.64,84.81 104.91,83.07 104.91,81.5 103.56,80.16 103.56,78.16 104.2,77.52
H_CPU_SVIDALRT#: length 8.7
  TOP w0.102: v1(104.07,75.48) v2(104.89,76.31) 105.91,77.33 105.91,78.17 105.62,78.46 105.62,78.91 105.36,79.17 RC153.1
  BOTTOM w0.076: UC1.B63 104.54,73.33 104.54,73.98 104.28,74.24 104.28,74.85 104.07,75.06 v1(104.07,75.48)
H_CPUPWRGD: length 8.6
  BOTTOM w0.076: UC1.A68 101.74,73.67 101.24,74.16 100.94,74.16 100.05,75.04 100.05,77.85
  BOTTOM w0.102: 100.05,77.85 v2(100.05,78.32) 100.05,79.17 RC77.2 CC300.1
H_CPUPWRGD_R: length 2.2
  BOTTOM w0.102: RC77.1 100.64,82.55 T9.1
H_THERMTRIP#: length 317.7
  TOP w0.102: v1(165.83,14.46) 165.54,14.17 v2(165.54,13.85) 165.54,12.61 RD27.2 ; RD14.2 v1(83.53,13.19)
  IN3 w0.122: v1(46.28,44.19) 45.85,44.62 44.31,44.62 42.84,46.1 40.94,46.1 40.59,46.44 40.59,48.57 39.61,49.56 39.61,56.78 43.98,61.15 45.41,61.15 47.43,63.17 52.35,63.17 55.81,66.62 55.81,68.42 56.68,69.3 56.68,74.01 57.62,74.95 57.62,78.06 60.61,81.05 60.61,85.17 61.9,86.46 61.9,92.76 65.56,96.41 70.45,96.41 72.87,98.83 74.06,98.83 77.44,95.45 78.27,95.45 81.29,92.43 86.39,92.43 87.33,93.37 91.56,93.37 92.99,91.94 97.81,91.94 97.99,92.12 100.91,92.12 101.31,92.52 103.9,92.52 v1(104.59,91.83) ; v1(46.03,20.37) 46.41,19.99 50.47,19.99 50.73,20.24 80.83,20.24 82.1,18.97 82.1,14.62 v1(83.53,13.19) 84.19,13.19 84.51,13.51 84.51,19.1 85.65,20.24 92.38,20.24 95.31,23.16 114.23,23.16 116.13,25.07 128.58,25.07 133.28,20.37 163.38,20.37 165.03,18.72 165.03,16.68 165.66,16.05 165.66,14.91 165.83,14.74 v1(165.83,14.46)
  BOTTOM w0.076: UC1.C63 105.05,72.66 105.13,72.91 105.13,73.08 105.1,73.2 105.1,73.47 105.13,73.54 105.13,73.81 104.91,74.03 104.91,74.08 104.61,74.38 104.61,76.53 104.15,76.99 104.15,77.18
  BOTTOM w0.102: v1(46.28,44.19) 46.28,43.14 46.18,43.04 46.18,40.97 46.28,40.87 46.28,37.26 45.39,36.37 45.39,29.13 46.92,27.61 46.92,21.26 v1(46.03,20.37) ; v1(104.59,91.83) 104.56,91.81 QE4.3 104.96,91.02 105.68,91.74 107.24,91.74 109.66,89.33 109.66,88.82 110.16,88.31 110.55,88.31 110.88,87.98 110.88,85.34 111.54,84.68 RC80.1 CC312.1 109.83,85.21 106.47,85.21 104.45,83.19 104.45,81.73 103.05,80.34 103.05,78.28 104.15,77.18
H_VCCST_PWRGD_XDP: length 8.1
  BOTTOM w0.102: JXDP1.39 93.64,97.09 v2(94.54,96.19) 94.85,95.88 95,95.88 95.61,95.27 96.62,95.27 CC307.1 97.45,94.38 RC123.2 98.34,92.63 RC124.2
HDA_BIT_CLK: length 17.9
  TOP w0.102: RC93.2 129.85,36.39 129.85,36.61 128.63,37.83 v1(128.63,40.69)
  BOTTOM w0.076: 129.17,45.42 129.06,46.18 128.97,46.86 128.55,48.24 128.48,48.49 v2(128.45,48.57) 128.34,48.93 128.34,49.83 128.29,50.18 128.01,50.85 128.01,51.17 128.02,51.19 128.02,51.52 127.99,51.62 127.99,51.74 128.05,52 128.08,52.09 128.31,52.32 UC1.AY22
  BOTTOM w0.102: v1(128.63,40.69) 129.39,41.44 129.39,44.6 129.26,44.73 129.21,45.06 129.17,45.4 129.17,45.42
HDA_BIT_CLK_R: length 160.6
  TOP w0.102: CC27.1 RC93.1 131.17,34.16 132.94,34.16 135.21,31.89 160.04,31.89 160.51,32.36 183.42,32.36 v2(186.43,35.37) 186.87,35.81 188.45,35.81 192.55,31.71 196.18,31.71 198.51,29.38 201.99,29.38 202.75,30.15 205.21,30.15 206.46,28.9 206.46,28.67 208,27.12 208,24.77 208.67,24.11 208.67,22.2 211,19.86 v1(211.41,19.86) ; v1(255.86,15.53) 255.4,15.99 255.4,17.88 RA17.2 257.18,16.96 259.52,16.96 259.88,16.61 262.13,16.61 262.39,16.35 262.92,16.35 263.18,16.61 UA1.14
  IN4 w0.089: v1(211.41,19.86) 212.01,19.26 213.33,19.26 213.34,19.25 213.8,19.25 214.9,20.35 216.81,20.35 217.23,19.94 217.23,17.7 217.73,17.19 217.73,16.68 218.15,16.26 219.84,16.26 220.41,16.84 222.58,16.84 229.47,16.84 229.78,16.53 230.53,16.53 230.94,16.94 232.39,16.94 234.11,15.22 238.35,15.22 238.62,15.49 240.53,15.49 241.49,14.53 242.64,14.53 243.37,15.26 244.31,15.26 244.97,15.92 246.22,15.92 248.33,13.81 250.22,13.81 251.18,12.85 252.58,12.85 253.33,13.6 255.46,13.6 255.86,14 v1(255.86,15.53)
HDA_RST#: length 18.6
  TOP w0.102: RC95.2 131.26,35.92 CC331.1 v2(129.48,37.7) 129.4,37.78 v1(129.4,40.32)
  BOTTOM w0.076: UC1.AW22 128.64,52.59 128.71,52.42 128.71,52.17 128.64,52.1 128.64,52.1 128.55,52.02 128.54,52.02 128.48,52 128.35,51.98 128.27,51.94 128.23,51.89 128.17,51.77 128.17,51.6 128.18,51.55 128.18,51.15 128.17,51.13 128.17,50.92 128.42,50.37 128.47,50.14 128.51,49.86 128.51,49.75 128.54,49.42 128.64,48.95 128.65,48.95 128.71,48.81 128.91,48.32 128.94,48.22 129.09,47.8 129.27,47.23 129.3,47.14 129.49,46.49 129.76,45.54 129.79,45.4
  BOTTOM w0.102: v1(129.4,40.32) 129.79,40.72 129.79,45.4
HDA_RST#_R: length 153.1
  TOP w0.102: RC95.1 131.64,34.64 133.14,34.64 135.26,32.52 159.91,32.52 160.35,32.97 183.06,32.97 v2(183.54,33.45) 186.39,36.29 189.09,36.29 192.97,32.41 196.38,32.41 198.84,29.94 201.39,29.94 202.08,30.63 205.8,30.63 207.34,29.08 207.34,28.46 208.64,27.17 208.64,25.33 210.62,23.35 210.62,21.25 v1(212.02,19.86) ; v1(258.37,21.87) 258.3,21.94 RA50.1
  IN1 w0.089: v1(255.19,14.56) 255.33,14.42 256.62,14.42 257.42,15.22 257.42,18.22 258.1,18.9 258.1,21.59 v1(258.37,21.87)
  IN4 w0.089: v1(255.19,14.56) 254.69,14.56 253.94,15.32 251.94,15.32 251.23,14.61 248.51,14.61 246.51,16.61 244.68,16.61 244.06,15.99 243.09,15.99 242.33,15.22 241.77,15.22 240.81,16.18 239.6,16.18 237.42,18.36 229.8,18.36 229.11,17.67 223.17,17.67 221.74,19.1 218.46,19.1 218.15,19.41 218.15,20.09 217.21,21.03 214.06,21.03 213.3,20.27 212.43,20.27 v1(212.02,19.86)
HDA_SDIN0: length 168.2
  TOP w0.102: RA9.1 259.88,15.6 259.23,16.25 256,16.25 v1(255.87,16.12) ; v1(131.99,39.76) 131.99,38.55 132.97,37.57 132.97,36.69 CC332.1 134.14,35.52 134.53,35.52 136.74,33.31 v2(138.96,33.31) 159.59,33.31 159.97,33.7 182.01,33.7 185.28,36.98 189.44,36.98 193.23,33.19 197.15,33.19 197.55,32.79 197.69,32.79 197.98,33.08 198.12,33.08 198.34,32.87 198.34,32.72 198.05,32.43 198.05,32.29 198.34,32 206.18,32 207.93,30.25 208.99,30.25 209.95,29.3 209.95,28.02 209.33,27.4 209.33,25.67 212.81,22.19 212.81,21.71 212.49,21.4 212.49,19.97 v1(212.6,19.86)
  IN4 w0.089: v1(255.87,16.12) 255.45,15.7 255.45,15.02 255.6,14.87 255.6,14.41 255.26,14.07 254.88,14.07 253.85,15.1 252.03,15.1 251.32,14.39 248.42,14.39 246.42,16.39 244.77,16.39 244.15,15.77 243.18,15.77 242.42,15 241.68,15 240.72,15.96 238.9,15.96 238.69,16.18 237.75,16.18 236.61,17.32 233.71,17.32 233.48,17.55 229.29,17.55 229.2,17.46 223.08,17.46 221.65,18.89 218.29,18.89 217.94,19.24 217.94,20 217.12,20.82 214.15,20.82 213.39,20.06 212.8,20.06 v1(212.6,19.86)
  BOTTOM w0.076: 129.17,49.65 129.17,51.83 UC1.BA21
  BOTTOM w0.102: 129.17,49.65 129.17,49.51 130.61,47.25 130.61,42.1 131.99,40.72 v1(131.99,39.76)
HDA_SDIN0_R: length 2.8
  TOP w0.102: UA1.16 263.98,16.65 v2(262.93,15.6) RA9.2
HDA_SDOUT: length 26.5
  TOP w0.102: RC94.2 132.15,37.03 130.49,38.69 v1(130.49,40.33) 130.93,40.78 132.31,40.78 133.15,39.94 133.15,39.06 134.16,38.04 v2(134.24,38.04) 134.24,37.97 134.76,37.44 134.76,36.76 CC333.1 134.47,36.06 134.81,36.06 134.95,35.93 RC223.2 136.13,35.93 136.83,35.23 RC187.1
  BOTTOM w0.076: 128.95,48.95 128.76,49.25 128.74,49.33 128.71,49.68 128.71,49.72 128.68,50 128.68,50.32 UC1.BB22
  BOTTOM w0.102: v1(130.49,40.33) 130.15,40.68 130.15,46.59 128.95,48.95
HDA_SDOUT_R: length 156
  TOP w0.102: RC94.1 132.15,35.49 132.77,34.87 133.24,34.87 135.36,32.75 159.73,32.75 160.2,33.22 182.72,33.22 v2(184.62,35.12) 186.02,36.52 189.18,36.52 193.07,32.64 196.47,32.64 198.94,30.17 201.3,30.17 201.99,30.86 206.67,30.86 207.73,29.79 208.69,29.79 209.49,28.99 209.49,28.24 208.87,27.62 208.87,25.43 210.88,23.42 210.88,21.59 v1(211.38,21.08) ; v1(256.28,15.09) 257.21,16.02 259.14,16.02 260.2,14.96 262.84,14.96 263.66,15.77 263.71,15.77 264.38,16.44 UA1.17
  IN4 w0.089: v1(256.28,15.09) 256.28,16.33 256.09,16.52 255.57,16.52 255.21,16.16 255.21,15.65 255.2,15.65 255.2,15.64 254.82,15.26 254.31,15.26 254.03,15.53 251.85,15.53 251.14,14.82 248.6,14.82 246.6,16.82 244.59,16.82 243.97,16.2 242.8,16.2 242.13,16.87 241.35,16.87 240.87,16.39 239.71,16.39 237.49,18.61 228.81,18.61 228.15,17.95 223.19,17.95 221.83,19.32 218.55,19.32 218.37,19.5 218.37,20.18 217.3,21.25 213.97,21.25 213.21,20.49 211.97,20.49 v1(211.38,21.08)
HDA_SYNC: length 19.2
  TOP w0.102: v1(131.42,40.32) 131.42,38.45 132.77,37.09 132.77,35.97 133.43,35.31 v2(133.43,35.31) 133.43,35.31 133.65,35.31 134,34.96 RC92.2
  BOTTOM w0.076: UC1.BA22 128.68,51.23 128.71,51.1 128.84,50.42 128.84,50.3 128.88,49.7 128.89,49.68 129.07,49.28
  BOTTOM w0.102: 129.07,49.28 130.38,47.09 130.38,41.59 131.42,40.56 v1(131.42,40.32)
HDA_SYNC_R: length 149.9
  TOP w0.102: UA1.15 263.58,16.66 263.05,16.13 259.68,16.13 259.32,16.48 256.35,16.48 v1(255.91,16.92) ; RC92.1 136.35,32.98 159.63,32.98 160.13,33.47 182.31,33.47 185.59,36.75 189.34,36.75 193.17,32.91 196.93,32.91 v2(197.83,32.02) 198.07,31.77 201.05,31.77 201.16,31.67 201.16,31.29 201.26,31.19 201.56,31.19 201.66,31.29 201.66,31.67 201.76,31.77 202.07,31.77 202.17,31.67 202.17,31.29 202.27,31.19 202.58,31.19 202.68,31.29 202.68,31.67 202.78,31.77 206.07,31.77 207.82,30.02 208.84,30.02 209.72,29.14 209.72,28.15 209.1,27.52 209.1,25.53 209.43,25.2 209.43,25.19 211.1,23.52 211.1,23.15 211.21,23.05 211.57,23.05 211.68,22.95 211.68,22.65 211.57,22.55 211.21,22.55 211.1,22.44 211.1,21.99 v1(212.02,21.08)
  IN4 w0.089: v1(212.02,21.08) 212.39,20.7 213.12,20.7 213.88,21.47 217.39,21.47 218.7,20.16 222.3,20.16 223.87,18.59 226.88,18.59 227.13,18.84 237.57,18.84 239.8,16.61 240.78,16.61 241.44,17.27 246.46,17.27 248.69,15.04 251.05,15.04 251.76,15.75 254.12,15.75 254.4,15.47 254.72,15.47 254.75,15.5 254.75,15.5 254.99,15.73 254.99,15.74 254.99,15.74 254.99,16.25 255.66,16.92 v1(255.91,16.92)
HDD_A_EQ: length 2.4
  TOP w0.102: RN11.2 RN10.1 228.18,19.93 UN7.17
HDD_A_EQ2: length 2.4
  TOP w0.102: UN7.18 228.19,20.43 RN20.2 RN21.1
HDD_A_PRE: length 2.6
  TOP w0.102: RN6.2 RN7.2 221.97,20.43 222.47,19.93 UN7.9
HDD_B_EQ: length 3.4
  TOP w0.102: UN7.19 227.69,20.93 227.94,21.18 227.94,21.97 RN13.2 RN12.2
HDD_B_EQ2: length 3.4
  TOP w0.102: UN7.13 224.97,17.53 v2(225.42,17.08) 225.42,16.69 225.35,16.62 RN19.1 RN18.2
HDD_B_PRE: length 3.7
  TOP w0.102: RN9.2 RN8.1 221.92,21.78 221.92,21.12 222.61,20.43 UN7.8
HDD_DET#: length 251.1
  TOP w0.102: v1(157.48,69.88) 157.43,69.88 156.91,69.36 155.94,69.36 155.63,69.67 155.63,69.99 155.45,70.17 RPC4.3 154.83,70.17 154.28,70.71 152.79,70.71 151.98,69.9 151.63,69.9 151.37,69.64 150.94,69.64 150.77,69.47 146.66,69.47 v2(146.35,69.78) 146.05,70.07 v1(146.05,70.79) ; v1(214.48,10.41) 213.03,11.86 213.03,14.09 213.34,14.4 213.34,16.58 213.54,16.79 213.54,17.85 214.33,18.64 214.33,20.05 216,21.71 217.96,21.71 218.97,22.72 218.97,24.06 220.27,25.35 220.27,25.67 221.42,26.81 221.42,28.04 QN6.2 220.09,28.11 218.87,28.11 QN7.2
  IN1 w0.089: v1(251.9,5.25) 249.91,5.25 247.43,7.73 245.43,7.73 244.01,9.15 244.01,9.47 242.04,11.45 238.64,11.45 237,13.09 233.65,13.09 232.59,14.15 228.85,14.15 228.77,14.07 225.62,14.07 225.25,13.7 223.46,13.7 222.43,12.66 221.59,12.66 219.34,10.41 v1(214.48,10.41) 213.87,10.41 213.29,10.99 201.96,10.99 199.93,13.03 199.93,14.02 198.24,15.71 197.16,15.71 196.71,16.16 194.38,16.16 194.16,16.38 194.16,18.62 193.78,19.01 192.33,19.01 192.19,19.15 184.66,19.15 179.63,24.18 159.73,24.18 151.34,32.56 141.16,32.56 134.85,38.87 134.85,39.97 135.09,40.22 135.09,42.25 135.18,42.34 135.18,44.37 133.79,45.77 133.79,49.09 v1(133.3,49.58)
  IN2 w0.122: v1(133.3,49.58) 134.8,49.58 136.33,48.05 138.74,48.05 139.37,48.69 144.01,48.69 147.06,45.63 151.46,45.63 152.95,47.12 152.95,47.18 154.33,48.56 154.7,48.56 155.28,49.15 155.28,50.12 155.88,50.72 159.67,50.72 160.68,51.74 160.68,55.16 159.79,56.06 159.79,61.63 159.48,61.94 159.48,65.42 158.26,66.64 158.26,68.44 157.46,69.23 157.46,69.86 v1(157.48,69.88)
  BOTTOM w0.076: 142.95,72.06 142.68,72.06 141.25,70.63 141.25,70.13 140.83,69.71 140.49,69.71 140.33,69.75 140.33,69.75 140.2,69.75 139.98,69.68 139.83,69.68 UC1.H2
  BOTTOM w0.102: v1(146.05,70.79) 145.86,70.79 144.59,72.06 142.95,72.06 ; JSATA1.13 v1(251.9,5.25)
HDD_DEVSLP: length 174.8
  TOP w0.102: v1(219.41,23.29) 219.41,22.87 218.72,22.19 218.72,20.39 218.95,20.16 219.63,20.16 220.07,19.72 220.07,19.29 220.44,18.92 RN3.2 219.7,18.17 v2(219.47,18.17)
  IN4 w0.089: v1(143.39,69.87) 143.39,69.47 145.53,67.32 152.6,67.32 153.95,68.67 158.92,68.67 160,67.59 161.01,67.59 161.55,67.05 165.57,67.05 166.06,67.54 166.9,67.54 168.43,66.01 168.43,64.87 169.44,63.86 170.23,63.86 171.76,62.34 172.41,62.34 172.63,62.12 172.63,60.75 174.2,59.17 175.52,59.17 177.85,56.84 178.21,56.84 182.91,52.14 182.91,47.65 183.52,47.04 183.52,45.36 189.92,38.96 189.92,38.76 192.69,35.99 193.93,35.99 195.38,34.54 195.38,33.78 200.61,28.55 201.12,28.55 203.14,26.53 203.69,26.53 206.94,23.28 212.95,23.28 213.96,24.28 218.41,24.28 v1(219.41,23.29) 221.74,23.29 223.35,21.68 226.41,21.68 227.46,20.62 231.5,20.62 232.57,19.55 237.83,19.55 240.34,17.04 240.6,17.04 241.26,17.7 246.64,17.7 247.98,16.36 249.58,16.36 250.47,15.47 250.87,15.47 251.58,16.18 254,16.18 255.36,17.53 256.45,17.53 257.15,16.84 257.15,14.43 257.78,13.8 257.78,12.58 257.36,12.16 256.44,12.16 255.2,10.92 255.2,10.23 256.44,8.99 256.44,8.34 255.77,7.67 251.95,7.67 v1(251.18,8.43)
  BOTTOM w0.076: 142.44,70.07 141.36,68.98 140.77,68.98 UC1.J1
  BOTTOM w0.102: JSATA1.11 250.9,8.14 v1(251.18,8.43) ; 142.44,70.07 142.63,70.25 143.01,70.25 v1(143.39,69.87)
HDD_EN: length 139.4
  TOP w0.102: v1(231.07,19.76) 230.91,19.6 230.91,16.11 231.18,15.83 232.48,15.83 233.1,16.46 237.48,16.46 237.63,16.3 238.04,16.3 238.59,15.76 RN4.2 RN5.1 v2(241.34,17.19) 241.56,17.41 242.17,17.41 242.36,17.22 242.36,16.56 242.52,16.4 242.9,16.4 243.15,16.16 UZ23.3
  IN4 w0.089: v1(231.07,19.76) 230.64,19.33 226.76,19.33 226.59,19.15 223.62,19.15 221.41,21.36 218.11,21.36 216.67,22.79 213.73,22.79 213.36,22.42 208.68,22.42 207.78,21.51 202.62,21.51 200.17,23.96 200.17,25.49 198.99,26.66 198.99,28.25 195.12,32.13 193.7,32.13 187.2,38.63 187.2,39.11 181.03,45.28 181.03,48.36 179.58,49.81 179.58,51.88 177.52,53.93 174.06,53.93 173.36,53.23 173.36,52.75 172.9,52.29 172.18,52.29 170.77,53.71 166.99,53.71 165.66,55.04 163.99,55.04 163.2,55.83 163.2,56.28 162.33,57.15 160.38,57.15 159.86,57.67 155.82,57.67 155.31,58.17 155.31,59.22 154.52,60.01 154.52,60.98 154.28,61.22 153.24,61.22 152.93,61.52 152.23,61.52 152.02,61.31 151.01,61.31 150.73,61.59 145.62,61.59 144.96,60.93 v1(144.58,60.93)
  BOTTOM w0.076: 143.41,61.69 142.84,61.69 142.63,61.9 141.76,61.9 141.1,62.56 139.02,62.56 138.65,62.19 UC1.AB4
  BOTTOM w0.102: v1(144.58,60.93) 144.17,60.93 143.41,61.69 143.41,61.69
HDD_FALL_INT: length 139.1
  IN1 w0.089: v1(154.36,49.81) 155.11,49.81 156.34,48.57 157.42,48.57 162.39,43.61 164.09,43.61 164.79,42.91 169.57,42.91 170.14,42.34 177.37,42.34 181.89,37.82 184.36,37.82 188.85,33.32 195.46,33.32 196.17,32.61 196.63,32.61 199.24,29.99 200.99,29.99 201.48,29.51 202.16,29.51 204.57,27.1 206.34,27.1 207.15,26.28 209.18,26.28 210,25.46 210,24.14 211.08,23.06 211.08,21.76 211.24,21.6 212.64,21.6 212.88,21.83 215.61,21.83 216.11,22.33 216.76,22.33 218.73,24.29 220.31,24.29 220.54,24.06 222.42,24.06 222.65,24.29 224.3,24.29 224.49,24.48 229.05,24.48 229.98,23.55 231.38,23.55 232.36,24.53 238.46,24.53 v1(238.54,24.61)
  BOTTOM w0.076: UC1.AM5 137.94,57.18 138.56,56.56 140.35,56.56 140.59,56.32 140.59,56.24 141.02,55.81 143.08,55.81
  BOTTOM w0.102: v1(154.36,49.81) 153.95,50.22 153.95,51.26 153.53,51.67 153.53,52.14 152.98,52.7 152.98,54.87 RC370.1 152.09,55.46 151.84,55.21 150.42,55.21 149.94,54.73 147.95,54.73 147.48,55.2 145.64,55.2 145.03,55.81 143.08,55.81 ; v1(238.54,24.61) 237.77,23.85 237.77,20.39 238.78,19.39 238.78,16.59 242.43,12.94 242.43,12.94 v2(243.06,12.31) 244.37,11 LGA1.12
HDD_UN4_UN5_EN: length 31.1
  TOP w0.102: RN230.2 v1(239.74,26.13) ; v1(219.43,31.21) RN228.2 QN7.1 ; v1(241.89,25.09) 242.55,24.43 RN229.2
  IN4 w0.089: v1(219.43,31.21) 219.43,31.01 219.85,30.59 223.07,30.59 223.28,30.39 228.17,30.39 228.81,29.75 235.68,29.75 236.15,30.22 237.8,30.22 238.7,29.32 238.7,27.16 v1(239.74,26.13) 240.85,26.13 v1(241.89,25.09)
  BOTTOM w0.102: v1(241.89,25.09) v2(242.57,25.09)
HDD_UN4_UN5_EN_R: length 17.5
  TOP w0.102: UN4.3 245.4,23.68 245.19,23.9 244.91,23.9 244.81,24 244.02,24 RN229.1 v1(244.2,24.43) ; UN5.3 v1(233.28,22.33) ; v1(240.64,24.79) 240.41,25.02 RN230.1
  IN4 w0.089: v1(233.28,22.33) 234.82,23.87 239.73,23.87 v1(240.64,24.79)
  BOTTOM w0.102: v1(233.28,22.33) v2(232.65,22.33) ; v1(244.2,24.43) 241,24.43 v1(240.64,24.79)
HDD_UN7_EN: length 10.9
  TOP w0.102: RN227.1 220.68,25.75 222.58,27.66 v2(222.58,27.73) 222.58,29.18 221.76,30 220.77,30 220.63,30.15 220.63,31.42 RN226.2 220.65,31.77 221.37,31.06 QN6.1
HDD_UN7_EN_R: length 6.1
  TOP w0.102: UN7.7 222.5,20.93 222.18,21.26 222.18,21.64 222.56,22.02 222.56,22.42 221.92,23.06 221.92,23.52 221.77,23.67 221.06,23.67 RN227.2 v2(219.68,24.05)
HDMI_CEC: length 8.2
  TOP w0.102: RV19.1 15.47,50.35 v2(14.45,51.37) 12.91,52.9 12.02,52.9 11.83,52.71 11.83,50.43 JHDMI1.13
HDMI_CLKN: length 3.2
  TOP w0.094: RV17.1 19.57,48.78 19.18,48.78 v1(18.98,48.98)
  BOTTOM w0.094: RV34.1 LV12.1 18.51,48.79 18.79,48.79 v1(18.98,48.98) 19.19,48.77 19.37,48.77 CV38.1
HDMI_CLKP: length 3.2
  TOP w0.094: v1(18.98,48.4) 19.18,48.6 19.57,48.6 RV16.1
  BOTTOM w0.094: RV33.1 18.33,48.41 LV12.2 18.52,48.6 18.77,48.6 v1(18.98,48.4) 19.17,48.59 19.38,48.59 CV37.1
HDMI_CTRL_CLK: length 21.5
  BOTTOM w0.102: JHDMI1.15 11.74,51.34 11.74,53.77 14.43,56.46 v2(15.22,56.46) 19.37,56.46 21.4,54.43 22.13,54.43 23.92,52.64 23.92,50.78 RV22.1 23.35,50.21 QV3.6
HDMI_CTRL_DATA: length 8.7
  BOTTOM w0.102: QV3.3 19.85,51.51 RV23.1 19.12,50.78 17.9,50.78 17.68,51 v2(14.72,51) 13.52,51 13.37,51.15 JHDMI1.16
HDMI_HPD: length 9.2
  TOP w0.102: JHDMI1.19 11.53,53.13 13.16,53.13 14.75,51.55 QV5.1 16.99,50.87 17.92,50.87 v2(18.09,51.04) RV21.1
HDMI_L_CLKN: length 5.3
  BOTTOM w0.094: JHDMI1.12 13.01,48.74 13.76,48.74 13.8,48.78 v4(14.77,48.78) 15.69,48.78 RV35.1 16.42,48.78 16.9,48.78 LV12.4 17.25,49.13 RV34.2
HDMI_L_CLKP: length 5.3
  BOTTOM w0.094: JHDMI1.10 13.01,48.56 13.84,48.56 13.88,48.6 14.44,48.6 14.47,48.56 15.07,48.56 15.11,48.6 15.69,48.6 RV35.2 16.42,48.6 16.9,48.6 LV12.3 17.25,48.25 RV33.2
HDMI_L_TX_N0: length 10.9
  BOTTOM w0.094: RV31.2 LV9.4 16.9,45.22 16.42,45.22 RV32.1 15.69,45.22 14.95,45.22 14.69,44.97 14.65,44.97 14.22,44.55 14.22,44.5 13.2,43.48 12.47,43.48 12.03,43.92 12.03,44.47 11.92,44.57 11.92,47.06 11.74,47.24 11.46,47.24 JHDMI1.9
HDMI_L_TX_N1: length 5.8
  BOTTOM w0.094: RV28.2 LV6.4 16.9,47 16.42,47 RV29.1 15.69,47 15.02,47 14.76,46.74 14.71,46.74 14.29,46.31 14.29,46.27 13.76,45.74 13.01,45.74 JHDMI1.6
HDMI_L_TX_N2: length 8.1
  BOTTOM w0.094: JHDMI1.3 11.64,44.06 11.64,43.41 12.32,42.72 13.92,42.72 14.26,43.06 14.26,43.11 14.68,43.53 14.73,43.53 14.94,43.75 RV26.1 16.42,43.38 16.9,43.38 LV3.4 17.08,43.57 RV25.2
HDMI_L_TX_P0: length 10.9
  BOTTOM w0.094: RV30.2 17.08,44.86 LV9.3 16.9,45.04 16.42,45.04 RV32.2 15.69,45.04 15.02,45.04 v4(14.59,44.6) 13.28,43.3 12.39,43.3 11.84,43.84 11.84,44.4 11.74,44.5 11.74,46.98 11.66,47.05 11.46,47.05 JHDMI1.7
HDMI_L_TX_P1: length 5.8
  BOTTOM w0.094: RV27.2 17.08,46.63 LV6.3 16.9,46.82 16.42,46.82 RV29.2 15.69,46.82 15.1,46.82 v4(14.65,46.37) 13.84,45.56 13.01,45.56 JHDMI1.4
HDMI_L_TX_P2: length 8.1
  BOTTOM w0.094: RV24.2 17.08,43.01 LV3.3 16.9,43.2 16.42,43.2 RV26.2 15.72,42.83 15.57,42.99 15.57,43.47 15.48,43.56 15.02,43.56 v4(14.62,43.16) 13.99,42.53 12.25,42.53 11.45,43.33 11.45,43.48 11.28,43.65 JHDMI1.1
HDMI_OB: length 9.6
  TOP w0.102: v2(19.59,41.73) 19.64,41.78 19.77,41.78 RV10.2
  TOP w0.508: RV10.2 RV11.2 RV14.2 RV15.2 RV12.2 RV13.2 RV16.2 RV17.2 20.83,49.57 QV4.1
HDMI_TX_N0: length 3.2
  TOP w0.094: v1(18.98,45.42) 19.18,45.22 19.57,45.22 RV15.1
  BOTTOM w0.094: CV36.2 19.37,45.22 19.19,45.22 v1(18.98,45.42) 18.79,45.23 18.51,45.23 LV9.1 RV31.1
HDMI_TX_N1: length 3.2
  TOP w0.094: v1(18.98,47.2) 19.18,47 19.57,47 RV13.1
  BOTTOM w0.094: RV28.1 LV6.1 18.51,47.01 18.79,47.01 v1(18.98,47.2) 19.19,46.99 19.37,46.99 CV34.2
HDMI_TX_N2: length 3.2
  TOP w0.094: v1(18.98,43.58) 19.18,43.38 19.57,43.38 RV11.1
  BOTTOM w0.094: CV32.2 19.37,43.37 19.19,43.37 v1(18.98,43.58) 18.79,43.39 18.51,43.39 LV3.1 18.33,43.57 RV25.1
HDMI_TX_P0: length 3.2
  TOP w0.094: RV14.1 19.57,45.04 19.18,45.04 v1(18.98,44.84)
  BOTTOM w0.094: RV30.1 18.33,44.86 LV9.2 18.52,45.05 18.77,45.05 v1(18.98,44.84) 19.17,45.03 19.38,45.03 CV35.2
HDMI_TX_P1: length 3.2
  TOP w0.094: RV12.1 19.57,46.82 19.18,46.82 v1(18.98,46.62)
  BOTTOM w0.094: RV27.1 18.33,46.63 LV6.2 18.52,46.83 18.77,46.83 v1(18.98,46.62) 19.17,46.81 19.38,46.81 CV33.2
HDMI_TX_P2: length 3.2
  TOP w0.094: RV10.1 19.57,43.2 19.18,43.2 v1(18.98,43)
  BOTTOM w0.094: RV24.1 18.33,43.01 LV3.2 18.52,43.21 18.77,43.21 v1(18.98,43) 19.17,43.19 19.38,43.19 CV31.2
HOST_DEBUG_TX: length 84.1
  TOP w0.102: RE73.2 230.89,11.3 v3(230.43,11.76) 230.43,12.9 RE306.2 230.85,13.32 230.85,13.45 230.99,13.59 230.99,15.25 231.35,15.6 232.57,15.6 233.02,16.05 v1(233.85,16.05) ; RZ132.1 v1(275.96,51.75) ; UE1.G11 267.26,49.33 v1(267.65,49.72)
  IN1 w0.089: v1(267.65,49.72) 268.46,50.53 271.68,50.53 273.17,49.04 273.56,49.04 275.96,51.44 v1(275.96,51.75)
  IN2 w0.122: v1(267.65,49.72) 268.34,49.03 268.34,46.59 267.97,46.22 267.97,43.6 267.73,43.36 267.73,42.97 267.64,42.87 267.64,40.81 266.5,39.67 266.5,38.2 264.67,36.37 264.09,36.37 261.42,33.7 259.52,33.7 255.99,30.17 255.99,27.73 255.74,27.48 255.74,24.05 253.63,21.94 253.63,20.85 252.53,19.76 250.82,19.76 250.23,19.17 240.23,19.17 239.4,18.34 239.4,16.2 238.03,14.83 234.88,14.83 233.9,15.81 233.9,16 v1(233.85,16.05)
  BOTTOM w0.102: JDEG1.8 233.91,13.64 233.85,13.7 233.85,16.05 v1(233.85,16.05)
HOST_SD_WP#: length 138.2
  TOP w0.102: v1(94.77,99.54) 95.48,99.54 95.94,99.08 95.94,97.15 94.62,95.83 94.26,95.83 v2(93.25,94.81) 91.57,93.13 QR1.2
  IN2 w0.122: v1(94.77,99.54) 95.22,99.1 98.46,99.1 98.85,98.71 103.07,98.71 103.86,97.92 108.7,97.92 108.99,98.22 110.06,98.22 110.8,97.48 110.8,94.41 114.69,90.52 120.5,90.52 121.72,89.3 134.59,89.3 137.27,86.63 143.66,86.63 143.83,86.8 147.95,86.8 149.48,85.26 149.48,81.62 147.29,79.43 147.29,77.87 145.42,76 145.42,72.58 148.29,69.71 148.29,67.54 146.51,65.76 146.51,62.12 145.95,61.56 145.95,59.51 146.32,59.14 146.32,58.14 144.66,56.49 v1(144.45,56.49) 144.04,56.9 141.44,56.9 140.9,57.45 140.01,57.45 139.12,58.34 138.87,58.34 138.74,58.47 137.85,58.47 137.74,58.36 136.18,58.36 135.1,59.43 v1(132.8,59.43)
  IN4 w0.089: v1(152.54,60.83) 152.14,60.42 151.75,60.42 151.31,60.87 150.84,60.87 150.55,61.16 148.85,61.16 148.66,60.97 148.66,60.05 147.8,59.2 147.25,59.2 146.31,58.26 146.31,57.41 145.39,56.49 v1(144.45,56.49)
  BOTTOM w0.076: UC1.W10 134.97,63.84 134.5,63.84 134.29,63.64 134.29,63.42 133.66,62.78 133.66,61.26 132.9,60.5 132.9,59.53 v1(132.8,59.43)
  BOTTOM w0.102: RC292.1 152.54,60.23 v1(152.54,60.83)
HP_OUT_L: length 12.9
  TOP w0.203: RA7.2 270.18,16.23 270.16,16.23 270.01,16.38 270.01,16.4 269.97,16.44 269.97,16.61 v1(269.77,16.81) 269.68,16.9 v2(269.24,16.9) 269.02,17.13 269.02,18.08 268.45,18.65 UA1.27
  TOP w0.381: CA43.2 272.42,21.76 v1(271.96,21.31) ; CA74.1 272.14,15.29 270.95,15.29 270.54,15.69 RA7.2
  IN1 w0.381: v1(269.77,16.81) 270.06,17.1 270.06,19 271.31,20.25 271.31,20.86 271.76,21.31 v1(271.96,21.31)
HP_OUT_R: length 16.4
  TOP w0.203: v1(270.01,15.29) 270.01,15.48 269.94,15.54 269.94,15.8 269.58,16.16 269.31,16.16 268.71,16.76 268.71,17.96 268.42,18.25 UA1.26
  TOP w0.381: v1(270.01,15.29) 270.01,14.78 RA8.2 ; v1(271.96,20.49) 272.04,20.57 CA44.2 ; CA73.1 274.22,15.11 v1(273.87,15.46)
  IN1 w0.381: v1(273.87,15.46) 271.5,15.46 271.33,15.29 v1(270.01,15.29) 270.01,15.95 270.88,16.82 270.88,18.83 271.96,19.91 v1(271.96,20.49)
HSYNC_CONN: length 7.5
  TOP w0.102: JCRT1.13 292.07,52.2 v2(291.27,53.01) 289.49,53.01 CV133.1 RV122.1 287.38,54.23 286.68,54.23 RV650.2
HSYNC_CRT: length 4.8
  TOP w0.102: UV6.19 284.37,52.12 284.61,52.36 284.61,53.07 RV650.1 285.43,53.89 285.43,54.58 285.11,54.9 v2(284.93,54.9)
HV_GATE1_A: length 11.3
  TOP w0.076: UT5.B9 29.2,60.31 29.45,60.56 29.83,60.56 29.93,60.65 30.62,60.65
  TOP w0.102: 30.62,60.65 30.84,60.65 32.54,58.95 32.54,56.61 31.2,55.27 31.2,54.73 30.85,54.39 v2(30.85,53.55) 30.76,53.46 RT64.1
HV_GATE2_A: length 9
  TOP w0.076: 30.62,60.42 29.95,60.42 29.84,60.31 UT5.A9
  TOP w0.102: 30.62,60.42 30.74,60.42 32.24,58.92 32.24,56.7 30.87,55.33 v2(30.87,54.87) 30.34,54.35 RT65.1
HW_ACAVIN_NB: length 389.4
  TOP w0.076: 263.45,42.85 263.55,42.95 263.55,43.76 263.22,44.09 UE1.N6
  TOP w0.102: v1(47.6,59.69) 48.07,59.22 PR1258.1 ; 263.45,42.85 263.45,42.62 263.44,42.6 263.44,42.33 263.45,42.31 263.45,40.66 263.28,40.48 261.75,40.48 261.45,40.79 v1(260.84,40.79) ; PR941.1 21.75,51.95 22.06,52.27 22.44,52.27 22.82,51.89 23.54,51.89 24.15,52.5 29.01,52.5 29.34,52.83 32.49,52.83 34.4,50.92 34.4,49.37 35.81,47.96 36.84,47.96 37.21,47.6 37.58,47.6 38.23,46.95 38.23,46.95 38.36,46.82 38.36,46.82 38.51,46.67 38.51,44.41 37.28,43.18 37.28,40.78 37.64,40.41 37.64,38.34 37.9,38.08 44.12,38.08 44.62,37.59 46.26,37.59 47.48,36.37 50.09,36.37 v1(50.37,36.65) 51.11,37.38 51.11,39.16 51.4,39.46 v2(51.4,44.04) 51.4,44.84 45.95,50.29 45.95,51.18 45.11,52.02 PR1241.1 ; PU1201.1 58.31,78.2 PC1207.1 58.02,78.73 PR1203.2 57.99,79.61 PR1206.2 57.98,79.69 58.45,80.16 58.45,81.35 57.97,81.83 55.81,81.83 v1(55.3,81.33)
  IN2 w0.122: v1(50.37,36.65) 50.93,36.65 60.86,26.71 100.03,26.71 102.08,28.76 134.54,28.76 141.21,22.09 155.42,22.09 156.89,23.55 167.56,23.55 169.75,21.36 174.15,21.36 174.93,22.14 188.47,22.14 190.25,23.92 196.89,23.92 197.31,23.5 199.98,23.5 200.28,23.2 204.36,23.2 204.53,23.03 212.62,23.03 214.28,21.37 216.83,21.37 218.24,22.78 220.73,22.78 221.7,21.81 223.01,21.81 223.03,21.83 226.81,21.83 227.27,21.37 231.58,21.37 234.48,24.27 237.61,24.27 238.7,25.36 239.82,25.36 240.21,25.75 242,25.75 242.3,25.45 244.99,25.45 245.26,25.18 245.95,25.18 246.54,25.76 246.54,26.65 247.39,27.5 247.39,30.78 247.08,31.09 247.08,32.9 249.91,35.74 250.84,35.74 253.55,38.46 253.55,38.66 255.81,40.92 257.03,40.92 257.28,41.17 260.46,41.17 v1(260.84,40.79)
  IN3 w0.122: v1(47.6,59.69) 47.6,58.52 47.08,58 47.08,49.44 51.11,45.41 51.11,39.04 50.37,38.3 v1(50.37,36.65)
  BOTTOM w0.102: PR21.1 53.52,87.93 53.78,88.18 55.17,88.18 56.09,87.27 56.09,82.11 v1(55.3,81.33) 53.78,81.33 53.01,80.56 51.87,80.56 51.11,79.8 51.11,77.52 52.25,76.37 52.25,73.11 52.83,72.54 57.15,72.54 58.2,71.5 58.2,67.59 57.08,66.47 57.08,65.76 56.48,65.16 50.7,65.16 48.06,62.52 48.06,60.14 v1(47.6,59.69)
I2C1_SCK_TP: length 99.8
  TOP w0.102: RZ21.2 206.3,24 206.4,23.9 RZ29.1 206.83,23.9 207.07,23.66 v1(207.07,22.4)
  IN4 w0.076: 139.47,65.03 139.44,65.03 139.41,65.07 138.86,65.07 138.36,65.57 137.42,65.57 137.17,65.82 136.09,65.82 v1(135.51,65.24)
  IN4 w0.089: v1(207.07,22.4) 206.98,22.49 206.65,22.49 206.05,23.08 204.52,23.08 203.09,24.52 203.09,25.66 200.94,27.81 200.74,27.81 199.95,28.59 195.33,33.22 194,33.22 188.57,38.65 188.57,39.07 181.99,45.65 181.99,51.84 179.03,54.8 174.87,54.8 174.72,54.95 171.09,54.95 170.88,55.16 166.79,55.16 163.71,58.24 162,58.24 161.63,58.61 160.54,58.61 159.94,59.21 157.31,59.21 156.7,59.82 156.7,60.09 156.3,60.49 156.04,60.49 155.45,61.07 155.45,61.34 154.69,62.1 154.15,62.1 153.27,62.98 151.24,62.98 151.03,62.77 150.32,62.77 149.28,63.81 140.89,63.81 139.67,65.03 139.47,65.03
  BOTTOM w0.076: UC1.U9 135.51,65.02 v1(135.51,65.24)
  BOTTOM w0.102: v1(207.07,22.4) 207.07,22.96 v2(206.6,23.42)
I2C1_SCK_TP_R: length 17
  TOP w0.102: v1(205.82,26.69) 205.82,24.09 206.04,23.87 206.04,23.17 206.23,22.98 RZ29.2 206.49,22.55 206.43,22.49 RZ117.2 208.15,20.02 JKBTP1.19 ; v3(200.51,28.67) 200.51,28.42 201.31,27.63 201.31,27.42 RZ347.1 201.65,26.49 v1(201.5,26.34)
  IN2 w0.122: v1(201.5,26.34) 203.2,26.34 203.59,25.95 205.3,25.95 205.82,26.48 v1(205.82,26.69)
I2C1_SDA_TP: length 97
  TOP w0.102: RZ20.2 RZ26.1 205.57,23.9 205.77,23.69 205.77,22.42 v1(205.8,22.4)
  IN4 w0.076: 139.52,64.8 137.96,64.8 137.1,65.66 136.61,65.66 136.11,65.15 v1(136.1,65.15)
  IN4 w0.089: 139.52,64.8 140.78,63.53 149.25,63.53 150.23,62.56 151.12,62.56 151.33,62.77 153.18,62.77 154.07,61.88 154.6,61.88 155.24,61.25 155.24,60.98 155.95,60.27 156.21,60.27 156.49,60 156.49,59.73 157.22,58.99 159.85,58.99 160.45,58.4 161.54,58.4 162.13,57.8 162.6,57.8 163.2,57.2 164.45,57.2 167.29,54.36 171.39,54.36 171.77,54.73 174.63,54.73 174.78,54.59 178.94,54.59 181.76,51.76 181.76,45.57 188.36,38.97 188.36,38.53 193.89,33 195.18,33 200.59,27.59 200.85,27.59 202.87,25.57 202.87,24.43 204.47,22.83 205.36,22.83 v1(205.8,22.4)
  BOTTOM w0.076: v1(136.1,65.15) 136.11,65.15 136.57,64.69 UC1.U8
I2C1_SDA_TP_R: length 11.7
  TOP w0.102: JKBTP1.18 207.65,19.25 207.32,19.58 206.48,19.58 206.11,19.95 206.11,20.36 205.9,20.57 205.9,21.28 RZ116.2 205.31,21.87 RZ26.2 205.02,22.98 204.86,23.15 204.86,25.7 204.68,25.88 204.68,26.45 204.6,26.53 RZ346.1 205.49,27.07 v3(205.78,27.36)
I_ADP: length 280.6
  TOP w0.076: 268.01,54.73 267.67,54.4 267.67,53.79 UE1.B11
  TOP w0.102: v1(268.82,55.32) 268.59,55.32 268.01,54.73 ; PR935.2 33.24,49.38 33.24,48.73 33.87,48.1 v2(33.97,48.1) 34.3,48.1 v1(34.51,48.32)
  IN2 w0.122: v1(268.82,55.32) 268.23,54.73 262.61,54.73 261.85,55.5 260.71,55.5 259.62,56.59 255.68,56.59 255.44,56.83 254.07,56.83 251.43,54.19 251.21,54.19 250.17,53.15 250.17,50.54 250.47,50.24 250.47,47.29 249.25,46.07 249.25,44.99 247.67,43.41 247.13,43.41 245.51,41.78 245.51,41.1 244.83,40.43 244.83,40.02 243.74,38.93 243.74,37.52 243.16,36.94 241.85,36.94 235.83,30.92 232.63,30.92 232.31,31.24 227.98,31.24 226.46,29.71 225.1,29.71 224.76,30.06 222.84,30.06 221.54,28.76 217.78,28.76 216.92,29.63 210.74,29.63 210,30.36 203.52,30.36 202.3,31.58 185.62,31.58 182.12,28.08 155.39,28.08 153.75,26.44 143.24,26.44 136.56,33.12 98.64,33.12 96.55,31.03 73.05,31.03 70.48,33.61 65.32,33.61 53.3,45.63 52.32,45.63 51.47,46.48 46.18,46.48 45.83,46.83 43.16,46.83 42.85,46.53 40.9,46.53 38.8,48.64 38.8,51.23 37.72,52.3 36.84,52.3 36.63,52.1 35.07,52.1 34.22,51.24 34.22,49.75 34.51,49.46 v1(34.51,48.32)
I_BATT: length 261.2
  TOP w0.102: PR947.2 32.76,48.85 33.2,48.41 33.2,48.3 33.74,47.76 35.17,47.76 35.42,47.51 36.65,47.51 37.02,47.14 37.39,47.14 38.04,46.49 38.04,44.58 36.53,43.07 36.52,43.07 36.52,42.79 35.92,42.19 35.92,41.21 37.19,39.94 37.19,38.15 37.89,37.45 v2(40.25,37.45) 40.82,37.45 41,37.63 43.88,37.63 44.37,37.13 46.03,37.13 47.32,35.84 50.78,35.84 52,37.05 v1(52,38.91) ; RE64.2 255.39,43.98 v1(254.94,43.53)
  IN2 w0.122: v1(52,38.91) 55.4,38.91 63.91,30.4 69.07,30.4 71.23,28.24 97.94,28.24 99.83,30.12 135.13,30.12 141.76,23.49 154.79,23.49 156.56,25.26 183.8,25.26 186.02,27.48 192.61,27.48 194.01,26.08 197.41,26.08 198.1,26.77 204.73,26.77 205.11,27.15 206.31,27.15 206.8,26.66 206.8,26.66 206.89,26.56 206.89,26.34 208.08,25.14 213.34,25.14 214.18,24.3 216.56,24.3 217.02,24.76 222,24.76 222.2,24.56 227,24.56 228.05,23.52 231.95,23.52 234.89,26.45 237.16,26.45 238.07,27.36 238.43,27.36 239.55,28.49 239.55,30.03 242.68,33.16 245.53,33.16 249.38,37 250.32,37 252.29,38.97 252.29,39.2 254.05,40.96 254.05,42.64 v1(254.94,43.53)
I_BATT_R: length 7.9
  TOP w0.076: 257.36,44.84 258.46,44.84 258.91,45.29 258.91,45.46 259.09,45.64 259.35,45.64 259.36,45.64 259.39,45.64 259.64,45.89 259.64,46.27 259.81,46.44 261.08,46.44 261.31,46.67 261.31,47.42 UE1.J4
  TOP w0.102: RE64.1 CE3.1 257.36,44.84
I_SYS: length 271.8
  TOP w0.102: PR620.1 64.66,63.77 v1(64.66,64.08) ; RE312.2 v2(252.3,50.47) 252.15,50.47 251.64,49.96 251.64,48.94 250.8,48.1 247.51,48.1 v1(247.27,48.34)
  IN1 w0.089: v1(33.91,47.17) 33.91,47.14 34.38,46.68 36.85,46.68 37.14,46.96 38.49,46.96 39.07,47.54 39.68,47.54 40.82,46.4 42.22,46.4 42.7,46.88 45.42,46.88 46.13,46.17 51.69,46.17 52.84,45.03 58.83,45.03 v1(59.62,44.24)
  IN2 w0.122: v1(64.66,64.08) 64.22,64.08 61.24,61.11 61.24,60.45 59.49,58.7 59.49,55.42 60,54.91 60,51.86 58.63,50.49 58.63,45.23 v1(59.62,44.24) 59.62,43.35 64.95,38.02 71.99,38.02 74.15,35.87 137.34,35.87 144.2,29 152.35,29 154.35,31 173.69,31 174.28,30.41 179.28,30.41 182.79,33.91 194.97,33.91 195.35,34.3 205.56,34.3 206.16,33.7 210.91,33.7 212.6,32 221.08,32 221.4,32.32 222.93,32.32 223.71,31.53 226.48,31.53 227.77,32.81 232,32.81 233.63,34.44 235.55,34.44 235.66,34.56 235.7,34.56 239.11,37.97 240.87,37.97 243.7,40.8 243.7,41.88 243.92,42.1 243.92,43.64 244.66,44.38 245.04,44.38 245.66,44.99 247.02,44.99 248.03,46 248.03,46.74 247.27,47.49 v1(247.27,48.34)
  BOTTOM w0.102: v1(33.91,47.17) 33.91,47.3 33.56,47.65 33.28,47.65 PR936.2
I_SYS_R: length 14.3
  TOP w0.102: UE1.J5 v1(262.03,48.13) ; CE4.1 RE313.1 RE312.1 253.67,49.83 v1(253.34,49.83)
  IN1 w0.089: v1(262.03,48.13) 261.23,47.33 259.86,47.33 259.08,48.1 256.54,48.1 255.07,49.58 253.6,49.58 v1(253.34,49.83)
  BOTTOM w0.102: v1(253.34,49.83) v2(254.03,49.83)
IA1N: length 12.3
  IN4 w0.254: v1(79.81,65.01) 81.36,65.01 82.38,66.02 82.38,69.95 82.83,70.4 v1(82.83,70.61)
  BOTTOM w0.254: v1(82.83,70.61) 82.88,70.66 PL610.2 ; PR666.1 78.05,63.22 PR677.1 78.67,63.23 79.56,64.12 79.56,64.56 79.81,64.82 v1(79.81,65.01)
IA1P: length 10
  TOP w0.102: v2(79.72,65.61) 79.29,65.18 v1(79.24,65.18)
  IN4 w0.254: v1(81.81,68.4) 82,68.21 82,66.21 81.35,65.57 79.62,65.57 v1(79.24,65.18)
  BOTTOM w0.254: PL610.3 82.88,67.43 81.92,68.4 v1(81.81,68.4) ; v1(79.24,65.18) 79.1,65.32 PR667.2 78.57,64.75 78.34,64.52 PR668.1
IA2N: length 9.6
  BOTTOM w0.102: v2(89.27,78.91) 88.91,78.91 88.74,78.74 87.72,78.74 PR673.1
  BOTTOM w0.254: PR673.1 PR670.2 87.23,79.23 83.43,79.23 82.92,78.72 PL613.2
IA2P: length 8.8
  BOTTOM w0.102: PR674.2 88.46,81.34 v2(88.75,81.63)
  BOTTOM w0.254: PL613.3 82.92,79.87 83.18,79.61 85.72,79.61 86.42,80.31 PR675.1 PR674.2
IA_SNUB1: length 1.5
  TOP w0.102: PR663.2 v2(77.31,65.32)
IA_SNUB2: length 1.6
  TOP w0.102: PR676.2 v2(80.73,83.31)
IA_SW1: length 0.8
  BOTTOM w0.102: 85.08,63.39 v2(85.87,63.39)
  vias: v1(81.37,64.41) v1(81.96,64.41)
IA_SW2:
  vias: v1(85.04,81.93) v1(85.04,81.33) v2(85.02,82.51)
IFDET_SATA_PCIE#: length 24.3
  TOP w0.102: QN4.6 225.49,33.96 226.42,34.88 227.22,34.88 227.59,34.51 RN192.1 229.27,34.34 v2(229.28,34.32) 231.82,34.32 234.24,31.9 RN171.2 234.24,30.91 233.99,30.65 232.08,30.65 v1(231.8,30.37) ; v1(228.88,24.98) 228.88,25.55 229.21,25.88 RN189.1 RN186.1
  BOTTOM w0.102: v1(231.8,30.37) 231.8,27.9 v1(228.88,24.98)
ILIM_SEL: length 2.9
  TOP w0.102: RI13.1 276.96,32.89 v2(277.32,32.53)
  TOP w0.254: RI13.1 275.87,32.36 275.87,31.71 275.91,31.67 UI3.4
ILMT_+1VALWP: length 2.8
  TOP w0.102: v1(163.2,105.24) 162.82,105.24 v2(162.53,104.95)
  TOP w0.254: PR310.1 PR307.2 163.44,105 v1(163.2,105.24)
ILMT_DDR: length 4.3
  BOTTOM w0.102: v2(59.28,63.45) 58.8,62.97 PR205.1
  BOTTOM w0.254: PU200.17 56.33,61.54 56.57,61.78 56.57,62.1 57.45,62.98 PR207.2 58.34,62.98 PR205.1
IMON_GT: length 3.5
  TOP w0.203: v1(72.17,66.14) 71.83,66.14 71.56,66.41 PU602.14
  BOTTOM w0.254: v1(72.17,66.14) 71.92,66.38 PR629.2 71.18,65.77 PC625.2
IMON_VSA: length 4.9
  TOP w0.203: v1(69.68,70.71) 69.68,70.74 69.37,70.43 PU602.23
  BOTTOM w0.102: v2(70.92,71.48) 69.88,71.48 69.68,71.28 v1(69.68,70.71)
  BOTTOM w0.203: v1(69.68,70.71) 69.68,70.71 69.58,70.61 PC643.1 69.59,70.08 PR651.1
IMVP_VR_ON: length 311.4
  TOP w0.102: RE304.1 275.99,34.4 UE3.4 275.65,35.3 275.65,35.78 274.99,36.44 274.99,37.34 v1(275.26,37.61) ; v1(275.39,43.3) 275.21,43.48 UE4.2
  IN1 w0.089: v1(64.22,62.85) 63.01,61.64 61.14,61.64 60.94,61.44 60.94,60.42 59.04,58.53 59.04,54.4 58.74,54.1 58.74,51.56 58.65,51.46 58.65,47.01 61.02,44.64 61.02,36.75 v1(55.55,31.29)
  IN2 w0.122: v1(275.26,37.61) 275.26,37.64 274.12,36.5 274.12,34.04 271.26,31.19 268.23,31.19 265.92,28.88 264.44,28.88 263.45,27.89 263.45,27.35 261.29,25.19 261.29,23.62 261.64,23.27 261.64,19.99 257.38,15.73 257.38,14.89 256.66,14.18 256.19,14.18 255.6,13.58 253.69,13.58 252.61,12.5 252.07,12.5 250.48,12.5 249.41,13.57 248.12,13.57 248.02,13.47 244.36,13.47 243.11,12.21 243.11,11.83 241.74,10.46 231.72,10.46 230.35,11.82 230.35,13.62 229.83,14.15 229.44,14.15 228.94,14.65 228.65,14.94 219.4,14.94 219.09,14.63 216.92,14.63 215.99,13.71 207.44,13.71 205.93,15.21 205.93,16.56 207.15,17.78 207.15,21.09 206.6,21.65 205.27,21.65 203.97,22.95 200.16,22.95 199.86,23.25 197.15,23.25 196.72,23.67 190.41,23.67 188.51,21.78 183.5,21.78 182.77,21.05 156.27,21.05 155.48,21.84 141.1,21.84 134.43,28.51 102.18,28.51 100.13,26.46 60.76,26.46 55.94,31.29 v1(55.55,31.29)
  IN3 w0.122: v1(275.39,43.3) 276.7,42 276.7,40.63 275.26,39.2 v1(275.26,37.61)
  BOTTOM w0.102: v1(64.22,62.85) 64.1,62.96 64.1,64.31 PR616.1 63.72,64.69 v2(62.49,64.69)
