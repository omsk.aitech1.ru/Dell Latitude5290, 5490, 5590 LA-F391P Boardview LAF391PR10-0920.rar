# Allegro board LAF391PR10-0920.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+2.5V_MEM on TOP (solid shape): 215.47,17.58 215.47,16.75 215.28,16.56 214,16.56 213.73,16.84 213.73,17.46 213.91,17.64 215.41,17.64
+2.5V_MEM on TOP (solid shape): 196.88,24.96 196.88,22.16 196.35,21.62 194.76,21.62 194.12,22.26 192.09,22.26 190.68,23.67 190.68,26.08 190.85,26.25 195.6,26.25
+2.5V_MEM on TOP (solid shape): outline of 135 points within 115.33,14.86 119.14,19.83
+2.5V_MEM on BOTTOM (solid shape): outline of 241 points within 195.59,16.85 201.07,23.86
+2.5V_MEM on IN2 (solid shape): 118.12,19.74 118.12,18.04 117.9,17.81 116.52,17.81 116.39,17.94 116.39,19.1 117.16,19.87 118,19.87
+2.5V_MEM on IN2 (solid shape): 196.8,22.77 196.8,21.89 195.89,20.98 195.25,20.98 195.05,21.18 195.05,21.99 196.14,23.08 196.48,23.08
+2.5V_MEM on IN4 (solid shape): outline of 1052 points within 198.19,13.31 215.6,20.26
+2.5V_VIN on TOP (solid shape): 221.86,15.68 221.86,14.1 221.75,13.99 219.36,13.99 219.26,14.09 219.26,15.43 219.68,15.85 221.69,15.85
+3.3V_1.8V_ESPI on TOP (solid shape): outline of 126 points within 153.84,47.95 155.88,51.33
+3.3V_1.8V_PGPPA on TOP (solid shape): 156.22,52.42 157.15,52.42 157.27,52.31 157.27,51.04 157.08,50.85 156.57,50.85 156.03,51.39 156.03,51.48 155.93,51.48 155.91,51.51 155.63,51.51 155.62,51.52 155.62,52.04 155.18,52.04 155.18,51.48 154.83,51.48 154.76,51.51 154.73,51.59 154.58,51.91 154.24,51.97 154.15,51.99 154.11,52.07 154.11,53.23 154.21,53.34 155.31,53.34
+3.3V_1.8V_PGPPA on BOTTOM (solid shape): 155.5,57.97 155.5,57.62 155.11,57.23 155.11,54.99 155.88,54.23 155.88,52.39 155.58,52.08 154.5,52.08 154.18,52.4 154.18,52.41 154.18,55.91 154.43,55.95 154.6,56.14 154.63,56.28 154.6,56.43 154.6,56.55 154.74,56.69 154.74,56.75 154.77,56.89 154.74,57.03 154.74,57.34 154.77,57.48 154.74,57.61 154.74,57.83 154.73,57.84 154.73,57.97 154.83,58.07 155.4,58.07
+3.3V_1.8V_PGPPA on IN3 (solid shape): outline of 1049 points within 132.64,49.92 155.76,57.84
+3.3V_1.8V_PGPPG on TOP (solid shape): 135.31,63.8 135.31,63.36 135.25,63.29 134.9,63.29 134.8,63.31 134.71,63.29 134.61,63.29 134.42,63.1 134.42,62.59 133.85,62.02 133.32,62.02 132.92,61.62 132.7,61.62 132.64,61.67 132.04,61.67 131.94,61.77 131.94,62.15 132.14,62.34 132.64,62.34 132.96,62.66 133.34,62.66 133.66,62.98 133.66,63.61 133.72,63.67 134.48,63.67 134.68,63.86 135.25,63.86
+3.3V_1.8V_PGPPG on IN2 (solid shape): outline of 473 points within 131.95,60.17 141.53,62.62
+3.3V_ALW on TOP (solid shape): 253.7,55.14 253.7,53.92 253.51,53.73 252.53,53.73 252.35,53.91 252.35,55.21 252.65,55.5 253.34,55.5
+3.3V_ALW on TOP (solid shape): 237.62,12.55 237.62,11.1 237.54,11.02 235.52,11.02 235.2,11.34 235.2,12.79 235.43,13.02 237.15,13.02
+3.3V_ALW on TOP (solid shape): 178.09,60.82 178.3,60.82 178.4,60.72 178.4,60.16 178.25,60 176.6,60 176.46,60.15 176.46,61.05 176.54,61.13 177.78,61.13
+3.3V_ALW on TOP (solid shape): 259.82,41.42 259.82,40.94 259.53,40.65 258.78,40.65 258.6,40.48 258.6,40.12 258.5,40.02 257.7,40.02 257.48,40.24 257.48,41.43 257.59,41.54 259.71,41.54
+3.3V_ALW on TOP (solid shape): 216.48,35.34 216.48,34.34 216.35,34.21 214.56,34.21 214.51,34.26 214.51,34.82 214.22,35.1 214.22,35.47 214.28,35.54 216.29,35.54
+3.3V_ALW on TOP (solid shape): 231.55,40.27 231.55,39.19 231.2,38.84 231.2,38.5 231.07,38.37 230.23,38.37 229.86,38.74 229.83,38.81 229.79,38.86 229.79,40.08 230.05,40.34 231.48,40.34
+3.3V_ALW on TOP (solid shape): 220.82,17.67 220.82,17.67 221.56,17.67 221.67,17.57 221.67,17.32 221.67,17.31 221.67,16.18 221.54,16.05 220.94,16.05 220.94,16.56 220.5,16.56 220.5,16.05 219.55,16.05 219.5,16.1 219.5,17.56 219.91,17.96 220.52,17.96
+3.3V_ALW on TOP (solid shape): 270.76,35.28 270.76,35.27 271.16,34.86 271.16,34.22 271.05,34.11 270.73,34.11 270.73,34.11 269.95,34.11 269.88,34.18 268.98,34.18 268.74,34.43 268.74,35.33 268.89,35.48 270.56,35.48
+3.3V_ALW on TOP (solid shape): 178.27,64.72 178.27,63.34 178.02,63.09 178.02,62.82 177.84,62.64 177.38,62.64 177.2,62.47 176.55,62.47 176.46,62.56 176.46,63.29 176.21,63.54 176.21,64.66 176.43,64.88 178.12,64.88
+3.3V_ALW on TOP (solid shape): 155.97,30.61 155.97,28.42 155.84,28.29 155.14,28.29 155.03,28.41 155.03,29.13 154.7,29.46 153.91,29.46 152.74,30.63 148.87,30.63 148.69,30.45 148.69,29.53 148.52,29.36 147.72,29.36 147.5,29.57 147.5,30.96 147.73,31.18 155.39,31.18
+3.3V_ALW on TOP (solid shape): 267.14,63.99 267.14,63.61 267.4,63.35 268.3,63.35 268.94,62.72 268.94,61.92 268.84,61.82 267.11,61.82 266.87,61.82 266.87,62.38 266.87,62.38 266.39,62.38 266.39,62.38 266.39,61.82 266.38,61.82 265.92,61.82 265.92,63.28 266.31,63.67 266.31,63.99 266.37,64.05 267.07,64.05
+3.3V_ALW on TOP (solid shape): 259.02,13.6 259.02,12.89 258.96,12.83 258.46,12.83 258.37,12.92 258.37,13.24 258.25,13.36 257.49,13.36 257.43,13.31 257.43,13.21 257.31,13.08 257.28,13.09 256.98,13.04 256.8,12.79 256.8,12.77 256.45,12.42 256.45,11.79 256.61,11.63 257.24,11.63 257.37,11.49 257.37,10.47 257.26,10.36 257.26,9.09 257.26,8.38 257.06,8.17 256.14,8.17 255.95,8.37 255.95,8.49 256,8.68 255.95,8.87 255.95,10.32 255.95,10.32 255.95,10.57 255.97,10.62 256.02,10.65 256.04,10.64 256.56,11.06 255.94,11.28 255.83,11.26 255.77,11.36 255.77,12.29 255.77,12.3 255.77,13.15 255.71,13.22 255.71,13.57 255.74,13.6 256.2,13.6 256.27,13.67 256.64,13.67 257.1,13.49 257.35,13.91 257.38,13.99 257.45,14.03 258.59,14.03
+3.3V_ALW on TOP (solid shape): outline of 179 points within 232.85,38.4 242.42,49.58
+3.3V_ALW on BOTTOM (solid shape): 162.89,104.26 164.24,104.26 164.33,104.17 164.33,103.35 164.26,103.28 162.86,103.28 161.87,104.27 161.87,104.37 161.95,104.45 162.7,104.45
+3.3V_ALW on BOTTOM (solid shape): 128.2,101.52 130.17,101.52 130.23,101.58 130.23,102.09 131.37,102.09 131.56,101.9 131.56,97.96 130.99,97.39 124.2,97.39 123.94,97.65 123.94,100.63 125.4,102.09 128.2,102.09
+3.3V_ALW on BOTTOM (solid shape): 177.88,107.39 178.39,107.39 178.39,107.92 178.62,107.92 178.67,107.87 178.67,106.75 178.67,105.66 178.58,105.58 177.19,105.58 176.99,105.78 176.99,107.29 177.63,107.92 177.88,107.92
+3.3V_ALW on TOP: 165.03,56.18 163.63,56.18 163.38,55.93 163.38,54.35 163.58,54.15 165.03,54.15 165.28,54.4 165.28,55.93
+3.3V_ALW on TOP: 251.95,46.53 251.95,47.1 252.14,47.29 253.17,47.29 253.29,47.16 253.29,45.58 253.17,45.45 253.03,45.45 252.97,45.39 252.66,45.39 252.53,45.51 252.53,45.96 252.4,46.08 252.39,46.08
+3.3V_ALW on TOP: 73.53,91.42 74.03,91.42 74.22,91.23 74.22,88.29 73.76,87.83 72.65,87.83 72.65,87.83 72.57,87.91 72.11,87.91 71.9,88.12 71.9,91.07 72.2,91.37 72.26,91.37 72.44,91.37 72.55,91.38 72.66,91.42 72.67,91.42 72.78,91.42 72.79,91.39 73.16,91.11 73.52,91.39
+3.3V_ALW on BOTTOM: 268.53,39.16 268.66,39.04 269.49,39.04 269.55,39.1 269.55,39.8 269.68,39.92 270.44,39.92 270.57,40.05 270.57,40.5 270.63,40.56 271.01,40.56 271.07,40.5 271.07,38.78 270.76,38.46 267.96,38.46 267.83,38.59 267.83,39.42 267.71,39.54 266.37,39.54 266.12,39.8 266.12,40.56 266.25,40.69 268.03,40.69 268.53,40.18
+3.3V_ALW on IN3: 46.88,58.3 44.4,58.3 43.24,57.13 42.79,57.13 42.66,57.26 42.66,57.7 43.36,58.4 43.36,59.23 44.73,60.59 45.89,60.59 46.92,61.62 53.2,61.62 54.81,63.23 57.21,63.23 57.9,63.93 57.9,64.5 58.17,64.77 58.48,64.77 58.61,64.63 58.6,64.63 58.6,63.23 55.49,60.12 48.7,60.12
+3.3V_ALW on VCC: outline of 156 points within 38.54,9.87 285.55,103.04
+3.3V_ALW on IN4: outline of 151 points within 124.26,91.28 177.91,107.58
+3.3V_ALW_DSW on TOP (solid shape): 148.26,57.7 148.26,57.2 148.14,57.07 147.89,57.07 147.61,56.79 147.61,56.29 147.57,56.24 147.24,56.24 146.64,55.65 143.46,55.65 142.84,56.27 142.84,56.5 144.07,56.5 144.07,56.44 144.08,56.39 144.1,56.34 144.13,56.29 144.16,56.24 144.2,56.2 144.24,56.17 144.29,56.14 144.34,56.12 144.4,56.11 144.45,56.1 144.51,56.11 144.56,56.12 144.62,56.14 144.67,56.17 144.71,56.2 144.75,56.24 144.78,56.29 144.81,56.34 144.82,56.39 144.83,56.44 144.84,56.5 144.83,56.56 144.82,56.61 144.79,56.66 144.77,56.71 144.73,56.75 144.69,56.79 144.64,56.82 144.59,56.84 144.54,56.86 144.48,56.87 144.43,56.87 144.37,56.86 144.32,56.84 144.27,56.82 144.22,56.79 144.18,56.75 144.14,56.71 144.11,56.66 144.09,56.61 144.08,56.56 144.07,56.5 142.84,56.5 142.84,57.18 142.93,57.27 145.55,57.27 146.11,57.83 148.14,57.83
+3.3V_ALW_DSW on IN2 (solid shape): outline of 466 points within 129.98,42.26 135.56,59.57
+3.3V_ALW_DSW on IN4: outline of 120 points within 130.57,55.55 144.06,62.23
+3.3V_ALW_PCH on TOP (solid shape): 129.89,64.54 129.89,64.16 130,64.06 130,63.27 129.98,63.25 129.49,63.25 129.46,63.27 129.36,63.27 129.29,63.35 129.29,64.54 129.41,64.67 129.77,64.67
+3.3V_ALW_PCH on TOP (solid shape): 127.56,60.5 128.13,60.5 128.2,60.44 128.2,59.8 128.32,59.68 128.32,59.61 128.39,59.61 128.45,59.55 128.45,59.29 128.34,59.18 128.13,59.18 128.13,59.17 128.07,59.17 128,59.2 127.93,59.2 127.91,59.2 127.56,59.55 127.56,59.8 127.44,59.93 126.8,59.93 126.67,60.05 126.67,60.5 126.74,60.56 127.5,60.56
+3.3V_ALW_PCH on TOP (solid shape): 153.01,55.14 153.01,55.08 153.06,55.03 153.56,55.03 154,54.58 154,54.52 154.33,54.19 155.78,54.19 156.13,53.84 156.42,53.84 156.54,53.72 156.54,53.42 156.69,53.27 157.27,53.27 157.4,53.15 157.72,53.15 158.04,52.83 158.04,52.5 158.04,52.48 158.14,52.11 158.5,52.01 158.53,52.02 158.65,51.9 158.65,51.89 158.68,51.86 158.67,51.72 158.71,51.58 158.71,49.75 158.37,49.41 158.37,46.22 157.57,45.42 156.18,45.42 155.98,45.62 155.98,46.95 156.49,47.46 156.49,47.63 156.57,47.74 156.61,47.87 156.94,48.19 156.94,49.99 157.41,50.46 157.41,52.37 157.23,52.55 156.28,52.55 155.36,53.46 155.35,53.46 155.27,53.54 153.79,53.54 153.7,53.63 153.7,53.98 153.69,54 153.69,54.09 152.87,54.09 152.66,54.09 152.58,54.16 152.58,54.89 152.46,55.01 151.92,55.01 151.77,55.16 151.77,55.61 151.92,55.76 152.39,55.76
+3.3V_ALW_PCH on TOP (solid shape): outline of 167 points within 171,55.44 176.28,58.97
+3.3V_ALW_PCH on TOP (solid shape): outline of 169 points within 135.69,57.5 151.55,64.62
+3.3V_ALW_PCH on BOTTOM (solid shape): 144.17,81.48 144.17,80.98 143.48,80.29 141.68,80.29 141.61,80.37 141.61,80.89 141.68,80.96 141.7,80.97 142.47,80.97 143.14,81.64 144.02,81.64
+3.3V_ALW_PCH on BOTTOM (solid shape): 174.14,63.98 174.14,63.87 173.58,63.1 173.66,62.91 173.67,62.89 173.69,62.84 173.72,62.81 173.75,62.77 173.79,62.74 173.84,62.73 173.89,62.71 173.93,62.71 174.64,62 174.64,60.81 175.01,60.44 177.1,60.44 177.21,60.33 177.21,57.68 176.35,56.82 175.36,56.82 175.19,56.98 175.19,58.58 173.98,59.79 173.57,59.79 173.14,60.21 173.14,61.11 173.24,61.21 173.56,61.66 173.46,61.75 173.46,61.87 173.69,61.87 173.69,61.81 173.7,61.76 173.72,61.71 173.75,61.66 173.79,61.62 173.83,61.58 173.87,61.54 173.92,61.52 173.97,61.5 174.03,61.49 174.08,61.49 174.14,61.49 174.19,61.51 174.25,61.53 174.29,61.56 174.34,61.6 174.37,61.64 174.4,61.68 174.43,61.73 174.44,61.79 174.45,61.84 174.45,61.9 174.44,61.95 174.43,62.01 174.4,62.06 174.37,62.1 174.34,62.15 174.29,62.18 174.25,62.21 174.19,62.23 174.14,62.25 174.08,62.25 174.03,62.25 173.97,62.24 173.92,62.22 173.87,62.2 173.83,62.16 173.79,62.13 173.75,62.08 173.72,62.03 173.7,61.98 173.69,61.93 173.69,61.87 173.46,61.87 173.46,61.89 173.25,62.04 173.25,63.16 173.89,64.09 174.03,64.09
+3.3V_ALW_PCH on IN3 (solid shape): outline of 971 points within 127.94,44.33 157.61,59.61
+3.3V_ALW_PCH on IN4 (solid shape): outline of 425 points within 125.11,57.35 131.37,65.58
+3.3V_ALW_PCH on IN2: 157.59,52.56 156.16,52.56 154.85,53.87 154.85,55.25 155.51,55.91 155.51,56.06 155.53,56.08 155.53,59.77 155.1,60.21 155.1,61.33 154.85,61.58 154.85,61.6 152.94,63.51 152.94,64.61 153.57,65.25 153.57,65.63 154.98,67.03 155.37,67.03 156.24,66.17 156.24,64.99 156.93,64.31 156.93,63.77 156.91,63.41 157.21,63.2 157.25,63.19 157.25,61.5 157.25,61.5 157.22,61.35 157.25,61.2 157.25,61.19 157.25,59.98 157.25,59.97 157.22,59.83 157.25,59.68 157.25,59.67 157.25,58.46 157.25,58.45 157.22,58.3 157.25,58.16 157.25,58.15 157.25,55.54 157.24,55.53 157.2,55.36 157.24,55.19 157.25,55.17 157.25,54.72 158.17,53.8 158.17,53.13
+3.3V_ALW_PCH on IN4: outline of 100 points within 152.82,56.43 176.46,67.22
+3.3V_ALW_PCH_UZ3 on TOP: 174,57.69 173.87,57.82 173.87,58.88 172.93,59.82 172.93,60.22 173.03,60.31 173.41,60.31 173.5,60.41 173.5,60.62 173.71,60.83 173.73,60.83 174.04,61.14 175.16,61.14 175.24,61.05 175.24,60.37 175.28,60.33 175.28,57.81 175.17,57.69 174.83,57.69 174.83,58.25 174.4,58.25 174.4,57.69
+3.3V_ALW_UE1 on TOP (solid shape): 266.72,62.22 266.72,61.67 266.72,61.67 267.41,61.67 267.6,61.48 267.6,59.75 267.48,59.64 266.45,59.64 266.45,59.63 265.86,59.63 265.75,59.74 265.75,60.28 265.92,60.45 266.03,60.47 266.07,60.5 266.28,60.75 266.25,61.07 266.25,61.08 266.25,61.25 266.12,61.38 266.12,61.66 266.13,61.67 266.53,61.67 266.54,61.67 266.54,62.22 266.54,62.23 266.71,62.23
+3.3V_ALW_UE1 on VCC: 257.28,44.83 256.54,45.57 256.54,51.02 266.3,60.78 266.62,60.78 266.73,60.67 266.73,45.41 266.14,44.83
+3.3V_ALW_UZ12 on TOP (solid shape): 163.91,53.46 164.34,53.46 164.34,53.98 165.32,53.98 165.55,53.76 165.55,52.78 164.9,52.13 163.42,52.13 163.14,52.41 163.14,53.84 163.28,53.98 163.91,53.98
+3.3V_ALW_UZ12 on TOP: 153.13,56.65 153.13,57.22 153.48,57.57 153.47,57.58 153.47,57.91 153.55,57.98 153.9,57.98 154.13,57.76 155.87,57.76 156,57.63 156,56.82 155.76,56.57 155.76,56.56 153.22,56.56
+3.3V_ALW_UZ12 on IN4: 160.63,51.91 159.6,52.94 158.74,52.94 158.04,53.64 158.04,55.42 157.66,55.8 156.27,55.8 155.5,55.04 154.23,55.04 154.22,55.03 153.6,55.66 153.6,57.45 153.98,57.83 154.61,57.83 155.5,56.94 159.19,56.94 160.71,55.42 161.3,55.42 161.41,55.31 161.41,55.29 162.02,54.67 164.77,54.67 165.67,53.77 165.67,52.13 165.45,51.91
+3.3V_ALWP on TOP (solid shape): 130.48,109.33 130.48,104.38 130.36,104.25 129.02,104.25 128.96,104.31 128.96,109.33 129.02,109.39 130.42,109.39
+3.3V_ALWP on BOTTOM (solid shape): 132.39,110.03 133.91,110.03 134.42,109.52 134.42,102.79 133.91,102.28 127.5,102.28 127.37,102.41 127.37,103.93 127.56,104.12 128.77,104.12 128.96,104.31 128.96,110.16 129.21,110.41 132.01,110.41
+3.3V_CAM on TOP (solid shape): 66.71,100.63 66.71,99.95 66.45,99.59 66.71,99.23 66.71,98.6 66.33,98.21 66.33,97.13 66.45,97.01 66.45,96.3 66.02,95.86 65.15,95.86 64.73,96.28 64.73,96.73 65.4,97.41 65.4,98.52 65.41,98.53 65.41,100.83 65.59,101.02 66.33,101.02
+3.3V_CPS on TOP (solid shape): 28.68,71.27 28.68,69.84 28.59,69.75 28.04,69.75 27.96,69.83 27.96,71.13 28.27,71.45 28.51,71.45
+3.3V_CPS on TOP (solid shape): 24.65,80.71 25.24,80.71 25.26,80.69 25.26,80.23 25.42,80.07 25.42,79.42 25.25,79.25 23.57,79.25 23.14,79.68 23.14,80.67 23.25,80.78 24.58,80.78
+3.3V_CPS on IN2 (solid shape): outline of 1053 points within 22.57,69.85 31.75,80.83
+3.3V_HDD on TOP (solid shape): 228.47,24.31 228.47,23.87 228.31,23.72 228.07,23.72 227.78,23.43 227.78,22.06 227.77,22.04 227.77,21.48 227.55,21.26 226.47,21.26 226.38,21.35 226.38,22.71 226.99,23.32 226.99,24.2 227.21,24.41 228.36,24.41
+3.3V_HDD on TOP (solid shape): 221.62,19.93 221.7,19.89 221.71,19.79 221.95,19.28 222.44,19.56 222.44,19.6 223.47,19.6 223.56,19.51 223.56,19.17 223.43,19.04 222.87,19.04 222.05,18.22 221.65,18.22 221.32,17.89 220.88,17.89 220.6,18.16 220.6,18.36 220.74,18.5 220.82,18.5 220.82,18.58 221.05,18.81 221.05,19.86 221.13,19.93
+3.3V_HDD on TOP (solid shape): outline of 158 points within 245.43,7.86 249.86,13.47
+3.3V_HDD on BOTTOM (solid shape): 250.54,8.71 250.54,6.55 250.47,6.48 249.85,6.48 249.76,6.56 249.76,8.09 249.67,8.17 249.01,8.17 248.8,8.39 248.8,8.91 248.95,9.06 250.18,9.06
+3.3V_HDD on IN3 (solid shape): outline of 864 points within 219.11,10.75 233.95,24.3
+3.3V_HDD on IN4 (solid shape): outline of 334 points within 231.38,6.68 250.52,13.25
+3.3V_HDD_M2 on BOTTOM (solid shape): 260.84,3.2 263.88,3.2 263.92,3.16 263.92,2.3 264.01,2.2 264.01,1.81 263.8,1.6 259.92,1.6 259.63,1.89 259.63,3.11 259.78,3.26 260.77,3.26
+3.3V_HDD_M2 on BOTTOM (solid shape): 247.12,13.68 247.86,13.68 247.86,14.32 248.31,14.32 248.31,13.68 249.69,13.68 249.71,13.66 249.71,12.53 250.49,11.76 251.17,11.76 251.24,11.68 251.24,11.13 251.21,11.1 249.44,11.1 249.2,10.87 247.11,10.87 246.94,11.04 246.94,12.15 246.94,12.19 246.94,12.34 246.83,12.46 246.77,12.51 246.59,12.69 246.59,14.35 247.12,14.35
+3.3V_HDD_M2 on BOTTOM (solid shape): 281,4.82 281.04,4.78 281.05,4.73 281.21,4.27 281.62,3.98 281.65,3.97 281.65,1.94 281.39,1.67 280.27,1.67 280.19,1.75 280.19,3.2 279.96,3.43 279.1,3.43 279.03,3.5 279.03,3.55 279.03,3.56 279.07,3.81 278.93,4.03 278.72,4.11 278.5,4.06 278.47,4.04 278.37,3.94 278.32,3.81 278.35,3.57 278.51,3.4 278.51,1.77 278.44,1.71 277.34,1.71 277.22,1.77 277.09,1.79 276.97,1.77 276.85,1.71 276.67,1.71 276.63,1.74 276.63,1.85 276.63,3.1 276.63,3.11 276.63,5.24 277.03,5.63 280.18,5.63
+3.3V_HDD_M2 on IN3 (solid shape): outline of 1849 points within 247.15,1.94 277.37,13.59
+3.3V_LAN on TOP (solid shape): 265.48,65.76 265.48,64.86 265.31,64.69 264.3,64.69 264.18,64.81 264.18,65.81 264.29,65.92 265.31,65.92
+3.3V_LAN on TOP (solid shape): 235.13,45.55 235.13,44.59 235.01,44.47 234.61,44.47 234.59,44.45 234.59,43.91 234.58,43.9 234.42,43.9 234.41,43.91 234.41,44.45 234.39,44.46 233.92,44.46 233.77,44.62 233.77,45.05 233.81,45.23 233.77,45.42 233.77,45.47 233.97,45.68 235,45.68
+3.3V_LAN on IN3 (solid shape): outline of 188 points within 233.14,45.06 255.08,61.2
+3.3V_LAN on IN3: 264.22,65.83 265.49,65.83 266.12,65.2 266.12,64.69 264.85,64.69 264.09,65.45 264.09,65.71
+3.3V_LAN_OUT on TOP (solid shape): 263.96,67.58 263.96,65.94 263.89,65.88 263.63,65.88 263.52,65.77 263.52,64.93 263.45,64.86 262.7,64.86 262.46,65.1 262.46,67.58 262.6,67.72 263.82,67.72
+3.3V_LAN_OUT on IN1 (solid shape): outline of 660 points within 252.7,65.41 263.92,77.93
+3.3V_LAN_UZ2 on TOP (solid shape): 235.01,44.32 235.01,41.79 234.76,41.54 232.97,41.54 232.88,41.64 232.88,42.64 233.35,43.11 233.35,44.23 233.45,44.33 234.25,44.33 234.26,44.32 234.26,43.79 234.28,43.77 234.72,43.77 234.73,43.78 234.73,44.32 234.75,44.33 234.99,44.33
+3.3V_M_TPM on TOP: 156.68,53.61 156.65,53.64 156.65,54.91 156.77,55.04 157.59,55.04 157.97,54.66 158.42,54.66 158.55,54.53 158.55,54.02 158.42,53.89 157.54,53.89 157.25,53.61
+3.3V_MMI_AUX on TOP: 82.48,93.77 82.61,93.65 83.88,93.65 84,93.52 84,92.63 84.13,92.5 84.89,92.5 85.02,92.63 85.02,94.03 83.24,95.8 81.72,95.8 81.46,95.55 81.46,93.9 81.59,93.77
+3.3V_MMI_AUX on BOTTOM: 82.86,94.89 82.86,94.66 82.48,94.28 82.48,94.03 82.96,93.54 83.52,93.54 83.65,93.42 83.65,92.1 83.8,91.94 84.28,91.94 84.36,92.02 84.36,93.47 84.35,93.48 85.15,94.28 85.15,94.87 85.04,94.97 82.94,94.97
+3.3V_MMI_IN on TOP: 83.11,93.52 82.73,93.52 82.61,93.39 82.61,92.76 82.48,92.63 80.83,92.63 80.45,92.25 77.78,92.25 76.26,90.72 75.37,90.72 75.24,90.6 74.6,90.6 74.35,90.34 74.35,90.09 75.11,89.33 75.11,89.2 75.37,88.95 76,88.95 76.26,88.69 76.26,88.31 76,88.06 76,87.42 76.13,87.3 81.59,87.3 83.11,88.82 83.11,89.71 82.73,89.71 82.61,89.84 82.61,91.23 83.11,91.23 83.11,91.49 83.24,91.61 83.24,93.39
+3.3V_MMI_IN on BOTTOM: 76.13,92.88 75.62,92.88 75.11,93.39 74.35,93.39 73.59,92.63 73.59,90.6 73.72,90.47 73.72,89.07 73.97,88.82 75.24,88.82 75.62,89.2 75.62,89.96 75.37,90.22 75.11,90.22 74.96,90.37 74.96,91.21 74.71,91.46 74.71,92.22 74.86,92.38 76.13,92.38 76.26,92.5 76.26,92.76
+3.3V_PGPPB on IN4: 132.57,56.79 132.43,56.93 132.43,56.95 132.26,57.27 131.9,57.34 131.88,57.33 131.5,57.7 131.5,57.76 131.25,58.01 131.25,58.39 131.25,58.48 131.31,58.54 131.82,58.54 131.82,58.49 132.15,58.18 132.48,58.49 132.48,58.54 132.58,58.54 132.6,58.52 132.73,58.38 132.92,58.35 133.13,58.39 133.27,58.54 133.51,58.54 133.59,58.53 133.66,58.53 133.74,58.53 133.82,58.54 134.04,58.54 134.05,58.54 134.14,58.51 134.24,58.5 134.34,58.51 134.44,58.54 135.73,58.54 136.58,57.69 136.58,57.51 136.53,57.51 136.31,57.36 136.26,57.1 136.25,57.01 136.26,56.92 136.24,56.83 136.16,56.79 136.1,56.79 136.02,56.83 136,56.9 135.72,57.26 135.35,57.02 135.33,56.96 135.33,56.9 135.3,56.82 135.23,56.79 135.19,56.79 135.11,56.83 135.09,56.92 134.77,57.33 134.45,56.92 134.43,56.83 134.35,56.79 134.13,56.79 134.03,56.86 134.06,56.97 133.83,57.54 133.61,56.97 133.63,56.86 133.54,56.79
+3.3V_PGPPC on TOP (solid shape): 131.82,63.86 131.82,63.23 131.94,63.1 132.39,63.1 132.45,63.04 132.45,62.53 132.39,62.47 131.42,62.47 131.25,62.64 131.25,63.1 131.12,63.23 131.12,63.86 131.25,63.99 131.69,63.99
+3.3V_PGPPC on BOTTOM (solid shape): 132.16,63.3 132.16,63.19 132.2,63.15 132.2,63.14 132.26,63.01 132.38,62.92 132.41,62.91 132.41,62.64 132.38,62.61 132.32,62.58 132.27,62.53 132.03,62.53 131.91,62.61 131.77,62.62 131.72,62.61 131.67,62.61 131.6,62.53 131.38,62.53 131.33,62.58 131.27,62.61 131.22,62.66 131.22,62.9 131.25,62.91 131.37,62.99 131.44,63.11 131.45,63.12 131.47,63.14 131.47,63.3 131.55,63.37 132.08,63.37
+3.3V_PGPPC on IN2 (solid shape): outline of 1182 points within 126.7,49.33 132.51,63.45
+3.3V_PGPPD on TOP (solid shape): 149.3,61.69 149.3,61.68 149.41,61.57 149.41,60.88 149.34,60.76 149.32,60.62 149.32,60.55 149.35,60.47 149.36,60.44 149.31,60.39 148.8,60.39 148.69,60.49 148.69,61.09 148.6,61.19 148.6,61.73 148.67,61.8 149.19,61.8
+3.3V_PGPPE on TOP (solid shape): 148.4,61.74 148.4,61.13 148.54,60.99 148.54,60.22 148.42,60.1 147.84,60.1 147.66,60.28 147.66,61.73 147.73,61.79 148.35,61.79
+3.3V_PGPPE on TOP (solid shape): 131.39,65.31 131.39,64.72 131.44,64.68 131.56,64.68 131.75,64.49 131.75,64.34 131.62,64.21 130.79,64.21 130.67,64.33 130.67,65.29 130.81,65.43 131.27,65.43
+3.3V_PGPPE on BOTTOM (solid shape): 132,64.97 132,64.77 131.77,64.54 131.77,64.36 131.66,64.25 131.62,64.21 131.42,64.21 131.34,64.29 131.26,64.29 131.17,64.3 131.06,64.29 131,64.24 130.97,64.21 130.73,64.21 130.69,64.25 130.64,64.28 130.61,64.31 130.61,64.54 130.76,64.69 130.95,64.69 131.21,64.58 131.43,64.75 131.44,64.76 131.72,65.05 131.93,65.05
+3.3V_PGPPE on IN4 (solid shape): outline of 546 points within 130.63,58.08 148.49,64.84
+3.3V_RUN on TOP (solid shape): 20.76,78.02 20.76,76.82 20.5,76.56 19.3,76.56 19.17,76.69 19.17,77.83 19.49,78.15 20.63,78.15
+3.3V_RUN on TOP (solid shape): 69.13,109.85 70.69,109.85 70.88,109.66 70.88,108.58 70.67,108.38 70.31,108.38 69.9,108.78 67.77,108.78 67.1,109.46 67.1,110.21 67.39,110.5 68.48,110.5
+3.3V_RUN on TOP (solid shape): 200.71,27.71 200.98,27.71 201.13,27.56 201.13,26.53 200.96,26.36 200.09,26.36 200.09,26.92 199.61,26.92 199.61,26.36 197.17,26.36 196.98,26.55 196.98,27.59 197.11,27.72 200.69,27.72
+3.3V_RUN on TOP (solid shape): 244.91,38.65 244.91,37.45 244.78,37.32 244.13,37.32 243.26,36.45 242.97,36.45 242.97,37.02 242.51,37.02 242.51,36.45 242.2,36.45 241.86,36.78 241.86,38.15 241.93,38.21 242.39,38.21 243.09,38.91 244.66,38.91
+3.3V_RUN on TOP (solid shape): 139.63,42.08 139.63,41.38 139.52,41.27 139.52,39.9 139.37,39.75 139.37,39.75 138.79,39.75 138.66,39.62 138.66,38.18 138.51,38.02 138.05,38.02 137.85,38.22 137.85,41.96 138.1,42.21 139.5,42.21
+3.3V_RUN on TOP (solid shape): 238.3,19.9 239.04,19.9 239.38,20.24 240.06,20.24 240.14,20.16 240.14,19.62 240.42,19.34 240.42,18.8 240.64,18.58 240.64,18.21 240.51,18.08 239.07,18.08 238.93,18.22 238.93,18.69 238.71,18.91 238.17,18.91 237.57,19.52 237.36,19.52 237.26,19.62 237.26,20.41 237.33,20.48 237.71,20.48
+3.3V_RUN on TOP (solid shape): 156.64,71.38 156.75,70.91 157.23,70.92 157.23,70.17 157.14,70.05 157.1,69.91 157.1,69.86 157.11,69.81 156.85,69.55 156,69.55 155.96,69.59 155.96,71.28 156.06,71.38 156.5,71.38
+3.3V_RUN on TOP (solid shape): 120.28,19.22 120.29,19.2 120.32,18.79 120.4,18.39 120.4,12.45 120.3,11.88 120.28,11.3 120.25,11.23 120.18,11.2 119.37,11.2 118.89,11.69 118.89,12.32 118.99,12.42 119.42,12.42 119.75,12.75 119.75,14.3 119.55,14.51 118.89,14.51 118.81,14.58 118.81,15.9 119.4,16.49 119.4,18.52 119.35,18.57 119.35,19.2 119.39,19.24 120.26,19.24
+3.3V_RUN on TOP (solid shape): 232.49,25.24 232.49,25.14 232.62,24.69 233.08,24.7 233.42,24.7 233.47,24.76 234.81,24.76 235.01,24.55 235.01,23.74 234.96,23.68 233.31,23.68 232.81,24.18 232.13,24.18 232,24.31 232,24.81 232.05,25 232,25.19 232,25.21 232.1,25.32 232.42,25.32
+3.3V_RUN on TOP (solid shape): 168.55,74.32 170.77,74.32 175.88,69.21 175.88,67.86 175.44,67.43 174.49,67.43 174.49,67.98 173.79,67.98 173.79,67.43 173.29,67.43 173.29,67.98 172.59,67.98 172.59,67.43 170.76,67.43 166.94,71.25 162.64,71.25 162.63,71.26 162.37,71.26 162.02,71.61 161.95,71.61 161.93,71.62 161.69,71.71 161.44,71.61 161.18,71.61 160.94,71.7 160.69,71.61 160.3,71.61 159.97,71.94 159.97,74.19 160.1,74.32 160.78,74.32
+3.3V_RUN on TOP (solid shape): 254.3,13.44 254.3,12.79 254.13,12.58 254.15,12.31 254.16,12.3 254.16,11.76 254.62,11.3 254.62,10.51 254.74,10.39 254.74,9.51 254.69,9.45 254.56,9.45 254.43,9.58 254.43,10.31 254.32,10.42 254.28,10.46 254.03,10.71 254.1,10.89 254.08,11.08 253.98,11.27 253.77,11.32 253.68,11.32 253.59,11.3 253.54,11.3 253.45,11.39 253.45,13.39 253.59,13.52 254.22,13.52
+3.3V_RUN on TOP (solid shape): 155.72,68.67 155.72,67.83 155.16,67.27 154.25,67.27 153.71,66.73 152.92,66.73 152.15,65.96 152.09,65.76 152.15,65.55 152.15,65.21 152.1,65.16 151.67,65.16 151.67,66.15 151.5,66.32 149.71,66.32 149.22,66.8 148.03,66.8 147.91,66.69 147.91,66.13 147.88,66.1 147.29,66.1 147.28,66.12 147.28,67.49 147.42,67.63 148.75,67.63 148.75,67.63 148.8,67.63 148.81,67.62 148.97,67.59 149.14,67.62 149.15,67.63 149.67,67.63 149.9,67.55 150.12,67.63 150.6,67.63 150.95,67.98 153.13,67.98 153.9,68.75 155.63,68.75
+3.3V_RUN on TOP (solid shape): outline of 98 points within 150.58,55.53 153.75,59.61
+3.3V_RUN on BOTTOM (solid shape): 244.81,37.38 245.73,37.38 248.34,34.78 249.38,34.78 249.53,34.63 249.53,34.09 249.42,33.98 247.29,33.98 246.81,34.45 246.69,34.45 246.58,34.56 243.8,34.56 241.61,36.75 245.16,36.75 245.17,36.69 245.18,36.64 245.2,36.59 245.23,36.54 245.26,36.5 245.3,36.46 245.35,36.42 245.4,36.4 245.45,36.38 245.5,36.37 245.56,36.37 245.62,36.37 245.67,36.39 245.72,36.41 245.77,36.44 245.81,36.47 245.85,36.52 245.88,36.56 245.9,36.61 245.92,36.67 245.93,36.72 245.93,36.78 245.92,36.83 245.9,36.89 245.88,36.94 245.85,36.98 245.81,37.03 245.77,37.06 245.72,37.09 245.67,37.11 245.62,37.13 245.56,37.13 245.5,37.13 245.45,37.12 245.4,37.1 245.35,37.08 245.3,37.04 245.26,37 245.23,36.96 245.2,36.91 245.18,36.86 245.17,36.81 245.16,36.75 241.61,36.75 241.48,36.88 241.48,37.89 241.74,38.15 244.05,38.15
+3.3V_RUN on BOTTOM (solid shape): 154.48,59.95 154.23,59.7 154.21,59.7 153.97,59.59 153.85,59.36 153.34,58.99 153.86,58.65 153.86,57.14 153.69,56.96 153.69,56.19 153.59,56.1 152.1,56.1 152.01,56.19 152.01,57.81 152.01,58.45 152.01,58.45 152.01,58.54 152.06,58.63 152.16,58.63 152.29,58.6 152.43,58.61 152.82,59 152.41,59.37 152.39,59.44 152.42,59.5 152.51,59.58 153.18,59.58 153.27,59.67 153.27,60.32 153.13,60.46 153.13,60.93 153.29,61.1 153.5,61.1 153.5,61.1 153.57,61.1 153.65,61.18 153.65,61.67 153.77,61.79 154.48,61.79
+3.3V_RUN on IN1 (solid shape): outline of 120 points within 17.26,49.68 21.06,55.16
+3.3V_RUN on IN2 (solid shape): outline of 249 points within 196.72,18.52 203.8,22.83
+3.3V_RUN on IN3 (solid shape): outline of 269 points within 242.18,14.17 248.47,22.04
+3.3V_RUN on IN4 (solid shape): 246.63,14.84 246.71,14.84 247.41,14.13 247.41,13.78 247.22,13.58 247.07,13.58 247.07,13.59 246.67,13.59 246.34,13.92 244.84,13.92 244.66,14.1 244.66,14.63 244.67,14.64 244.67,14.92 245.04,15.29 246.18,15.29
+3.3V_RUN on IN4 (solid shape): outline of 587 points within 62.67,90.34 72.19,110.33
+3.3V_RUN on TOP: 157.15,86.79 156.39,86.79 156.14,86.53 156.14,83.1 156.39,82.85 157.15,82.85 157.41,83.1 157.41,86.53
+3.3V_RUN on TOP: 86.42,93.39 85.4,93.39 85.27,93.26 85.27,92.38 84.64,91.74 83.62,91.74 83.37,91.49 83.37,89.45 83.62,89.2 86.29,89.2 86.54,89.45 86.54,93.26
+3.3V_RUN on TOP: 246.41,13.05 246.41,13.61 245.23,13.61 244.55,14.28 244.55,16.78 244.88,17.11 246.61,17.11 247.07,17.57 247.53,17.57 247.83,17.88 247.83,18.46 247.96,18.59 248.59,18.59 248.72,18.46 248.72,16.94 248.47,16.69 247.92,16.69 247.83,16.6 247.83,14.65 248.15,14.33 248.15,13.78 247.98,13.61 247.48,13.61 247.47,13.6 247.47,13.08 247.44,13.05 247.22,13.05 247.22,13.59 247.2,13.61 246.68,13.61 246.67,13.59 246.67,13.05
+3.3V_RUN on BOTTOM: 246.56,26.84 246.31,26.84 245.8,26.34 245.8,25.83 245.93,25.7 245.93,25.57 246.18,25.32 248.72,25.32 249.36,25.95 250.25,25.95 250.37,26.08 250.37,27.61 249.99,27.99 247.71,27.99
+3.3V_RUN on BOTTOM: 160.33,82.34 159.95,82.34 158.17,80.56 158.17,74.72 160.46,72.44 162.87,72.44 163.12,72.69 163.12,73.07 162.36,73.83 161.85,73.83 161.22,74.47 161.22,76.75 161.73,77.26 161.73,77.52 160.58,78.66 160.58,82.09
+3.3V_RUN on BOTTOM: 221.42,33.19 219.51,33.19 219.26,32.94 219.26,32.43 219.51,32.18 221.29,32.18 222.05,31.42 222.43,31.42 222.56,31.54 222.56,32.05
+3.3V_RUN on BOTTOM: 245.21,11.23 245.1,11.34 245.1,11.67 245.46,12.02 245.46,12.75 245.63,12.92 245.63,13.41 244.3,14.74 244.3,16.76 244.4,16.86 246.26,16.86 246.51,16.61 248.28,16.61 248.87,16.02 248.87,16.01 248.9,15.87 248.98,15.76 249.03,15.72 249.08,15.69 249.1,15.67 249.1,15.55 249.26,15.39 249.26,15.38 249.34,15.27 249.45,15.19 249.46,15.19 249.69,14.96 249.69,14.7 249.48,14.5 248.9,14.5 248.9,13.97 248.87,13.94 248.47,13.94 248.47,14.5 247.73,14.5 247.73,13.94 247.27,13.94 247.27,14.47 246.51,14.47 246.44,14.4 246.44,12.68 246.44,12.67 246.44,12.55 246.23,12.37 246.19,12.1 246.2,12.07 246.05,11.93 246.05,11.8 245.93,11.69 245.93,11.32 245.84,11.23
+3.3V_RUN on IN1: 290.07,48.31 290.12,48.23 290.12,48.16 290.38,47.89 290.38,46.27 290,45.89 289.46,45.89 288.98,46.38 279.32,46.38 279.09,46.61 279.09,48.75 279.63,49.3 279.63,53.82 280.34,54.53 289.91,54.53 290.12,54.33 290.12,51.94 290.07,51.86 289.98,51.85 289.55,51.69 289.58,51.23 289.61,51.16 289.58,51.1 289.49,50.8 289.66,50.53 289.7,50.45 289.67,50.37 289.58,49.92 289.99,49.71 290.08,49.69 290.12,49.61 290.12,49.15 290.07,49.07 289.98,49.05 289.49,48.69 289.98,48.32
+3.3V_RUN on IN3: 66.03,91.11 65.02,91.11 64.95,91.04 64.95,89.39 65.84,88.5 65.84,87.99 64.57,86.72 64.57,83.99 64.83,83.74 65.84,83.74 65.97,83.87 65.97,86.53 66.79,87.36 66.79,89.58 66.16,90.22 66.16,90.98
+3.3V_RUN on VCC: outline of 142 points within 17.71,9.87 280.85,96.57
+3.3V_RUN_AUDIO on TOP (solid shape): 255.44,26.02 255.44,24.96 255.37,24.89 253.83,24.89 253.72,25 253.72,26.13 253.91,26.33 255.13,26.33
+3.3V_RUN_AUDIO on TOP (solid shape): 242.83,36.32 243.28,36.32 243.28,36.02 242.27,35.01 242.27,34.47 242.84,34.47 242.84,34.28 242.28,34.28 242.28,33.63 242.24,33.6 240.85,33.6 240.68,33.77 240.68,35.46 241.53,36.32 242.64,36.32 242.64,36.88 242.83,36.88
+3.3V_RUN_AUDIO_UZ5 on TOP (solid shape): 244.87,36.08 244.87,34.21 244.81,34.15 244.32,34.15 244.01,33.83 242.41,33.83 242.41,34.14 242.98,34.14 242.98,34.63 242.42,34.63 242.42,34.92 243.64,36.14 244.81,36.14
+3.3V_RUN_CARD on TOP: 87.51,95.79 87.58,95.79 87.58,96.41 87.52,96.47 87.52,98.44 87.63,98.55 88.2,98.55 88.29,98.46 88.29,96.84 88.37,96.76 88.37,96.65 88.36,96.52 88.39,96.4 88.39,96.05 88.84,95.6 88.84,92.77 88.57,92.5 87.53,92.5 87.46,92.58 87.46,95.64 87.51,95.69
+3.3V_RUN_CARD on BOTTOM: 77.73,93.67 76.89,93.67 76.81,93.75 75.98,93.75 75.59,93.37 75.59,93.19 75.77,93.01 76.15,93.01 76.33,93.19 76.53,93.19 76.79,93.44 77.7,93.44 77.78,93.52 77.78,93.62
+3.3V_RUN_CARD on IN2: 88.45,93.01 87.48,93.01 87.43,92.96 87.43,92.25 87.05,91.87 87.05,91.49 87.56,90.98 87.94,90.98 88.7,91.74 88.7,92.76
+3.3V_RUN_CARD on IN2: 76.51,93.77 76,93.77 75.62,93.39 75.62,92.63 76.13,92.12 76.64,92.12 77.02,92.5 77.02,92.88 76.76,93.14 76.76,93.52
+3.3V_RUN_DIMM1 on TOP (solid shape): outline of 110 points within 113.07,19.87 120.75,23.37
+3.3V_RUN_DIMM1 on BOTTOM (solid shape): 115.18,22.65 115.18,21.95 115.05,21.82 114.24,21.82 113.83,21.82 113.78,21.77 113.78,21.44 113.77,21.4 113.66,21.29 113.58,21.26 113.32,21.26 113.15,21.44 113.15,22.48 113.45,22.78 115.05,22.78
+3.3V_RUN_DIMM2 on TOP (solid shape): 198.94,21.99 198.94,21.33 198.82,21.21 198.63,21.21 198.3,20.88 198.3,19.47 198.03,19.19 196.64,19.19 196.42,18.98 195.42,18.98 195.05,19.04 194.8,18.75 194.79,18.71 194.34,18.71 194.29,18.75 194.29,19.84 194.66,20.21 195.61,20.21 197.43,22.03 198.9,22.03
+3.3V_RUN_DIMM2 on BOTTOM (solid shape): 197.83,21.21 197.83,19.21 197.74,19.12 197.61,19.12 197.51,19.22 197.51,20.85 197.27,21.1 197.27,21.27 197.41,21.42 197.62,21.42
+3.3V_RUN_UT9 on TOP (solid shape): 22.6,80.37 22.6,79.55 22.41,79.36 20.91,79.36 20.76,79.21 20.76,78.84 20.71,78.79 19.8,78.79 19.74,78.85 19.74,79.8 20.82,80.88 22.09,80.88
+3.3V_RUN_UT9 on BOTTOM (solid shape): 13.71,68.12 13.71,67.23 13.64,67.17 11.74,67.17 11.68,67.23 11.68,68.06 11.8,68.18 13.64,68.18
+3.3V_RUN_UT9 on BOTTOM (solid shape): 19.74,70.21 19.74,69.71 18.79,68.75 18.41,68.75 17.96,69.2 17.96,69.58 17.97,69.59 18.05,69.65 18.12,69.73 18.98,70.6 19.36,70.6
+3.3V_RUN_UT9 on IN2 (solid shape): 22.29,80.31 22.29,79.42 21.75,78.88 21.75,76.41 22.29,75.87 22.29,74.59 22.26,74.58 22,74.22 22.26,73.85 22.29,73.84 22.29,70.53 20.95,69.19 19.18,69.19 18.98,69.39 18.98,70.4 19.74,71.17 19.74,74.34 19.11,74.98 19.11,75.74 19.36,75.99 19.87,75.99 20.5,76.63 20.5,79.92 21.01,80.43 22.17,80.43
+3.3V_RUN_UZ3 on TOP (solid shape): 173.16,67.3 173.91,67.3 173.91,67.85 174.36,67.85 174.36,67.3 175.67,67.3 176.04,66.93 176.04,63.33 175.91,63.2 175.37,63.2 175.24,63.07 175.24,62.54 175.17,62.47 174.49,62.47 174.36,62.6 173.63,62.6 173.32,62.92 173.14,62.92 173.07,62.99 173.07,63.64 172.85,63.86 172.85,63.86 171.88,64.82 171.88,67.2 171.98,67.3 172.71,67.3 172.71,67.85 173.16,67.85
+3.3V_TBTA_FLASH on BOTTOM (solid shape): outline of 437 points within 26.47,62.2 33.85,70.66
+3.3V_TBTA_FLASH on IN1: 32.62,61.74 32.16,62.2 32.16,65.54 31.42,66.28 30.28,66.28 29.85,65.85 29.61,65.85 29.41,66.05 29.41,66.44 30.13,67.17 31.74,67.17 32.63,68.06 35.39,68.06 36.22,68.88 37.1,68.88 37.1,68.88 37.28,68.91 37.42,69.01 38.63,69.01 38.64,69 40.85,69 41.07,69.23 44.03,69.23 44.27,68.98 44.27,67.97 44.28,67.97 44.28,67.53 44.14,67.4 38.97,67.4 38.76,67.19 38.76,67.19 37.43,65.87 37.41,65.87 37.19,65.83 37.03,65.67 35.59,64.23 35.57,64.23 35.29,64.15 35.16,63.89 35.15,63.85 33.46,63.85 33.29,63.81 33.16,63.72 32.9,63.47 32.9,63.12 33.15,62.87 33.39,62.87 33.51,62.75 33.51,61.92 33.33,61.74
+3.3V_TP on TOP (solid shape): 199.97,26.23 200.42,26.23 200.51,26.15 200.51,25.69 200.35,25.54 200.08,25.54 199.9,25.37 199.9,24.43 199.8,24.32 199.27,24.32 198.64,24.95 198.64,26.09 198.79,26.23 199.74,26.23 199.74,26.79 199.97,26.79
+3.3V_TP on BOTTOM (solid shape): 206.85,20.21 206.85,19.43 206.58,19.16 204.61,19.16 204.46,19.31 204.46,20.33 204.58,20.46 206.6,20.46
+3.3V_TP on IN2 (solid shape): 206.84,20.38 206.84,18.61 205.43,17.2 204.54,17.2 204.36,17.38 204.36,19.51 205.39,20.54 206.67,20.54
+3.3V_TP on IN3 (solid shape): outline of 309 points within 198.48,19.91 206.92,26.98
+3.3V_TSP on TOP (solid shape): 67,108.85 67,107.71 67.11,107.6 67.18,107.51 67.27,107.43 67.52,107.19 67.86,107.19 68.01,107.04 68.01,106.62 67.43,106.04 67.18,106.04 66.75,106.2 66.48,105.83 66.48,105.81 66.07,105.41 64.86,105.41 64.67,105.6 64.67,109.14 65.02,109.48 66.36,109.48
+3.3V_TSP on BOTTOM (solid shape): 69.15,106.68 69.15,105.34 69.02,105.22 67.68,105.22 67.33,105.57 67.33,105.92 67.05,106.2 67.05,106.45 67.63,107.02 68.22,107.02 68.8,107.02
+3.3V_VCCHDA on TOP (solid shape): 129.02,60.44 129.02,60.24 129.15,60.12 129.66,60.12 129.79,59.99 129.79,58.59 129.72,58.53 129.21,58.53 129.15,58.59 129.15,59.13 129.18,59.16 129.18,59.22 129.18,59.23 129.21,59.4 129.16,59.56 129.15,59.57 129.15,59.67 129.09,59.74 128.52,59.74 128.45,59.8 128.45,60.44 128.52,60.5 128.96,60.5
+3.3V_VDD_PIC on TOP (solid shape): 40.38,74.6 40.38,74.29 40.85,73.82 40.85,73.05 40.73,72.93 39.45,72.93 39.27,73.11 39.27,73.78 39.15,73.91 39.15,74.63 39.27,74.76 40.22,74.76
+3.3V_VDD_PIC on TOP (solid shape): 12.52,67.32 12.52,67.13 12.54,67.13 12.97,67.13 12.97,67.13 12.99,67.13 12.99,67.29 12.99,67.69 13.44,67.69 13.52,67.61 13.52,66.94 14.06,66.4 15.37,66.4 15.64,66.13 15.64,65.06 15.44,64.86 13.5,64.86 13.46,64.89 12.45,64.89 12.18,65.16 12.18,67.65 12.22,67.69 12.52,67.69
+3.3V_VDD_PIC on BOTTOM (solid shape): 14.53,66.28 14.53,65.77 14.15,65.39 11.87,65.39 11.68,65.58 11.68,66.4 11.74,66.47 14.34,66.47
+3.3V_VDD_PIC on IN2 (solid shape): 35.41,73.15 35.41,71.57 35.21,71.37 34.73,71.37 34.22,71.88 34.22,73.66 34.32,73.76 34.8,73.76
+3.3V_VDD_PIC on IN2 (solid shape): 15.17,66.64 15.31,66.64 16.28,65.68 16.28,65.37 15.98,65.07 15.65,65.07 14.99,65.73 13.57,65.73 13.39,65.91 13.39,66.42 13.62,66.65 15.17,66.65
+3.3V_VDD_PIC on IN2 (solid shape): outline of 590 points within 39.15,48.34 60.48,79.32
+3.3V_VDD_PIC_PDA on TOP (solid shape): 13.17,68.65 13.52,68.42 13.87,68.65 14.05,68.65 14.23,68.47 15.76,68.47 16.04,68.2 16.04,68.1 16.03,68.09 16.03,67.89 15.65,67.51 13.97,67.51 13.67,67.81 12.87,67.81 12.87,67.74 12.87,67.73 12.87,67.26 12.65,67.26 12.65,67.73 12.64,67.74 12.64,67.81 12.24,67.81 12.22,67.84 12.22,68.4 12.47,68.65
+3.3V_VGA on TOP (solid shape): 282.52,47.16 282.52,46.19 282.43,46.1 281.75,46.1 280.73,45.09 280.73,44.48 280.44,44.19 279.62,44.19 279.55,44.26 279.55,45.07 279.84,45.36 279.98,45.45 280.07,45.58 280.41,45.92 280.41,45.94 281.52,47.06 282.21,47.06 282.38,47.23 282.45,47.23
+3.3V_WLAN on TOP (solid shape): 218.52,21.36 218.52,20.35 218.88,19.99 219.39,19.99 219.4,19.98 219.52,19.98 219.72,19.78 219.72,18.81 218.96,18.06 217.99,18.06 217.77,18.27 217.77,21.47 217.83,21.54 218.34,21.54
+3.3V_WLAN on TOP (solid shape): outline of 114 points within 210.22,37.41 218.88,40.77
+3.3V_WLAN on BOTTOM (solid shape): 218.77,39.04 218.75,38.95 218.75,38.87 218.75,37.85 218.46,37.56 215.93,37.56 215.75,37.75 215.75,38.48 215.79,38.53 215.8,38.53 216.02,38.68 216.17,38.9 216.17,38.91 216.44,39.17 218.64,39.17
+3.3V_WLAN on BOTTOM (solid shape): 216.13,21.33 216.15,21.33 216.67,20.82 217.9,20.82 218,20.91 218.54,20.91 218.69,20.77 218.69,20.38 218.95,20.12 219.55,20.12 219.7,19.97 219.7,18.55 219.48,18.33 217.05,18.33 216.96,18.37 216.95,18.47 216.96,18.51 216.97,18.65 216.93,18.77 216.91,18.8 216.94,18.85 216.95,18.85 217.05,18.94 217.11,19.06 217.11,19.27 217,19.46 216.97,19.53 216.99,19.6 217.07,19.71 217.1,19.83 216.81,20.23 216.37,20.02 216.29,19.96 216.2,19.99 216.15,20.04 216.08,20.09 215.91,20.27 215.71,20.27 215.54,20.3 215.37,20.3 215.35,20.3 214.43,21.21 214.43,21.39 214.77,21.73 215.74,21.73
+3.3V_WLAN_UZ4 on TOP (solid shape): 211.16,37.92 211.71,37.92 211.71,38.47 211.96,38.47 211.96,37.92 212.51,37.92 213.28,37.16 213.28,34.3 213.17,34.2 211.86,34.2 211.85,34.2 211.78,34.22 211.7,34.22 211.62,34.22 211.19,34.65 210.4,34.65 210.31,34.73 210.31,36 210.38,36.22 210.31,36.44 210.31,37.83 210.41,37.92 210.91,37.92 210.91,38.47 211.16,38.47
+3.3V_WWAN on TOP (solid shape): 228.73,42.48 228.73,41.41 228.72,41.41 228.21,41.41 228.18,41.38 228.18,40.67 228.19,40.66 228.73,40.66 228.74,40.65 228.74,40.21 228.72,40.2 228.21,40.2 228.18,40.17 228.18,39.47 228.19,39.46 228.73,39.46 228.74,39.44 228.74,38.91 228.52,38.68 226.29,38.68 226.03,38.94 226.03,39.41 226.03,39.42 226.03,39.9 225.56,40.37 225.56,41.98 225.9,42.32 226.58,42.32 226.88,42.62 228.59,42.62
+3.3V_WWAN on TOP (solid shape): 279.2,37.97 279.27,37.97 279.39,37.85 279.39,36.85 279.38,36.84 279.35,36.69 279.38,36.54 279.39,36.53 279.39,36.35 279.35,36.3 279.26,36.21 277.99,36.21 277.83,36.04 277.83,35.24 277.81,35.24 277.47,35.11 277.2,34.88 277.13,34.82 276.86,34.82 276.78,34.9 276.78,35.28 276.76,35.3 276.76,35.31 276.67,35.41 276.67,35.95 278.24,37.51 278.24,37.92 278.3,37.98 279.18,37.98
+3.3V_WWAN on BOTTOM (solid shape): 277.17,37.16 277.17,36.55 277.18,36.54 277.18,36.3 277.8,35.67 277.8,35.24 277.8,35.24 277.4,35.07 277.11,34.76 276,34.76 275.85,34.91 275.85,37.21 275.9,37.26 277.07,37.26
+3.3V_WWAN on BOTTOM (solid shape): outline of 1038 points within 226.17,34.94 260.59,47.09
+3.3V_WWAN on IN4 (solid shape): outline of 542 points within 258.63,33.77 278.19,36.11
+3.3V_WWAN_UZ2 on TOP (solid shape): 230.86,43.84 230.86,43.43 231.57,42.72 231.57,41.65 231.45,41.53 230.84,41.53 230.73,41.42 230.73,40.69 230.55,40.51 229.64,40.51 229.64,40.5 229.64,39.48 229.05,38.9 228.91,38.9 228.87,38.93 228.87,39.58 228.86,39.59 228.34,39.59 228.33,39.61 228.33,40.06 228.34,40.07 228.86,40.07 228.88,40.08 228.88,40.79 228.86,40.8 228.34,40.8 228.33,40.81 228.33,41.26 228.34,41.27 228.86,41.27 228.87,41.28 228.87,42.65 229.35,43.13 229.35,43.8 229.43,43.87 230.83,43.87
+5V_ALW on TOP (solid shape): 244.31,16.75 244.31,15.45 244.26,15.4 243.59,15.4 243.51,15.48 243.51,16.11 243.04,16.58 242.6,16.58 242.54,16.64 242.54,17.03 242.64,17.13 243.93,17.13
+5V_ALW on TOP (solid shape): 38.64,58.19 38.64,57.68 38.13,57.68 38.13,56.98 38.64,56.98 38.64,56.48 38.13,56.48 38.13,55.78 38.64,55.78 38.64,54.96 38.26,54.58 34.88,54.58 34.47,54.99 34.47,58.21 34.58,58.32 38.51,58.32
+5V_ALW on TOP (solid shape): 280.54,35.37 280.54,31.42 279.94,30.83 277.38,30.83 277.28,30.93 277.28,31.76 277.37,31.85 277.63,31.85 277.79,32 278.81,32 279.22,32.41 279.22,33.59 279.75,34.12 279.75,35.39 279.8,35.44 280.47,35.44
+5V_ALW on TOP (solid shape): 216.85,32.78 216.85,30.55 216.65,30.35 216.64,30.35 216.52,30.22 215.29,30.22 215.09,30.43 215.09,31.55 214.51,32.12 214.51,32.26 214.51,32.27 214.51,32.81 214.58,32.87 215.52,32.87 215.58,32.94 216.69,32.94
+5V_ALW on TOP (solid shape): 30.5,19.08 30.5,18.5 30.64,18.36 31.59,18.36 31.73,18.33 31.87,18.36 32.32,18.36 32.48,18.2 32.48,17.24 32.28,17.03 29.94,17.03 29.75,17.21 28.69,17.21 28.52,17.37 28.52,19.01 28.71,19.2 30.38,19.2
+5V_ALW on TOP (solid shape): 255.63,13.12 255.63,11.17 255.61,11.15 255.59,11.15 255.26,10.91 255.34,10.51 255.34,10.4 255.26,10.33 255.26,9.53 255.18,9.44 255.05,9.44 254.93,9.56 254.93,10.4 254.79,10.54 254.79,11.38 255.01,11.6 255.01,12.03 254.84,12.19 254.84,12.26 254.85,12.27 254.91,12.49 254.82,12.71 254.82,13.29 254.91,13.38 255.37,13.38
+5V_ALW on TOP (solid shape): 242.18,16.72 242.18,16.42 242.39,16.22 242.71,16.22 242.78,16.15 242.78,15.49 242.69,15.4 242.44,15.4 241.98,14.95 241.98,13.31 240.6,11.93 239.49,11.93 239.06,12.36 239.06,14.52 239.79,14.52 239.8,14.47 239.81,14.41 239.83,14.36 239.86,14.32 239.9,14.27 239.94,14.24 239.99,14.2 240.04,14.18 240.09,14.16 240.15,14.16 240.2,14.16 240.26,14.16 240.31,14.18 240.36,14.2 240.41,14.24 240.45,14.27 240.48,14.32 240.51,14.36 240.54,14.41 240.55,14.47 240.56,14.52 240.55,14.58 240.54,14.63 240.53,14.69 240.5,14.74 240.47,14.78 240.43,14.82 240.38,14.86 240.34,14.88 240.28,14.9 240.23,14.92 240.17,14.92 240.12,14.92 240.06,14.9 240.01,14.88 239.96,14.86 239.92,14.82 239.88,14.78 239.85,14.74 239.82,14.69 239.8,14.63 239.79,14.58 239.79,14.52 239.06,14.52 239.06,14.9 239.54,15.38 240.31,15.38 240.53,15.6 240.53,16 241.36,16.82 242.08,16.82
+5V_ALW on BOTTOM (solid shape): 178.36,101.9 178.36,100.94 178.24,100.81 176.46,100.81 176.46,101.37 175.95,101.37 175.95,100.81 175.7,100.81 175.65,100.86 175.65,101.89 175.89,102.13 178.13,102.13
+5V_ALW on BOTTOM (solid shape): 180.64,53.01 180.67,53.01 181.31,52.37 181.31,51.3 181.22,51.21 179.37,51.21 179.37,51.22 179.37,51.77 178.89,51.77 178.89,51.22 178.86,51.19 178.18,51.19 178.03,51.34 178.03,52.73 178.49,53.18 180.47,53.18
+5V_ALW on BOTTOM (solid shape): 36.62,57.94 36.62,54.43 36.41,54.22 36.21,54.22 35.92,53.93 35.92,53.46 35.74,53.29 34.85,53.29 34.85,52.74 34.42,52.74 34.42,53.29 33.66,53.29 33.66,52.74 33.23,52.74 33.23,53.29 32.7,53.29 32.56,53.43 32.53,53.53 32.61,53.6 32.89,54.05 32.46,54.35 32.39,54.36 32.35,54.42 32.35,58.12 32.57,58.34 36.22,58.34
+5V_ALW on IN1 (solid shape): 36.72,58.38 36.72,55.45 36.45,55.18 34.82,55.18 34.61,55.39 34.61,56.51 34.71,56.61 34.71,58.4 34.89,58.58 36.51,58.58
+5V_ALW on IN1 (solid shape): outline of 697 points within 282.27,31.85 291.55,45.64
+5V_ALW on IN2 (solid shape): 180.51,52.18 180.51,51.32 180.39,51.19 179.5,51.19 178.85,51.85 178.85,53.11 179.05,53.31 179.38,53.31
+5V_ALW on IN2 (solid shape): outline of 701 points within 44.58,67.66 62.89,82.39
+5V_ALW on IN3 (solid shape): 181.36,54.35 181.36,51.81 181,51.45 180.07,51.45 178.84,52.68 178.84,53.4 178.96,53.53 178.96,53.53 180.4,54.96 180.75,54.96
+5V_ALW on IN3 (solid shape): 184.16,68.68 184.16,68.67 184.29,68.55 184.29,65.82 183.89,65.43 182.16,65.43 181.82,65.77 181.82,69.07 182.22,69.47 183.37,69.47
+5V_ALW on IN3 (solid shape): 244.36,16.8 244.36,15.58 244.15,15.37 241.82,15.37 241.36,15.83 241.36,16.81 241.66,17.11 244.04,17.11
+5V_ALW on IN3 (solid shape): outline of 1088 points within 278.08,30.91 291.98,45.56
+5V_ALW on IN1: 58.86,64.79 58.86,68.88 59.24,69.26 60.76,69.26 61.14,68.88 61.14,65.55 61.37,65.32 66.6,65.32 67.62,64.31 67.62,63.48 69.09,62 71.69,62 71.98,62.29 73.1,62.29 73.43,61.96 73.43,60.95 71.6,59.12 71.6,58.79 71.53,58.72 69.4,58.72 65.33,62.78 63.56,62.78 63.43,62.66 60.99,62.66
+5V_ALW on VCC: outline of 312 points within 23.42,1.17 300.01,111.93 ; 1 cut-out
+5V_ALW2 on BOTTOM (solid shape): 40.76,45.7 40.76,45.48 40.7,45.42 39.79,45.42 39.69,45.51 39.19,45.51 38.95,45.76 38.95,46.13 39.08,46.26 40.2,46.26
+5V_ALW_PDA on TOP (solid shape): 30.03,59.5 30.08,59.43 30.16,59.37 30.63,58.9 30.95,58.9 31.06,58.79 31.06,58.63 31.27,58.42 31.27,57.74 31.07,57.54 29.54,57.54 28.87,58.21 28.87,58.45 28.29,59.03 28.11,59.21 28.11,59.48 28.16,59.53 30,59.53
+5V_ALW_PDA on BOTTOM (solid shape): outline of 308 points within 24.35,50.97 35.92,59.11
+5V_ALWP on TOP (solid shape): 39.91,58.12 39.91,57.35 40.95,56.3 40.95,55.77 41.6,55.13 41.6,49.39 41.25,49.04 40.54,49.04 40.42,48.92 38.41,48.92 38.18,49.15 38.18,54.31 38.82,54.95 38.82,55.88 38.78,55.91 38.27,55.91 38.27,56.36 38.76,56.36 38.76,56.38 38.78,56.38 38.78,57.08 38.76,57.08 38.76,57.11 38.27,57.11 38.27,57.56 38.76,57.56 38.76,57.58 38.78,57.58 38.78,58.37 39.67,58.37
+5V_ALWP on BOTTOM (solid shape): 45.04,56.09 45.04,53.79 44.67,53.41 44.67,51.37 44.35,51.05 41.3,51.05 40.91,50.66 40.91,48.56 40.79,48.44 38.29,48.44 38.08,48.65 38.08,55.91 38.5,56.33 44.8,56.33
+5V_HDD on BOTTOM (solid shape): 254.03,7.84 254.03,6.22 254.02,6.14 254.03,6.06 254.03,5.52 253.86,5.34 252.91,5.34 252.76,5.5 252.76,6.02 252.79,6.14 252.76,6.27 252.76,7.85 252.83,7.92 253.95,7.92
+5V_HDD on TOP: 247.49,4.48 250.23,4.48 251.67,5.92 251.67,5.92 251.82,6.17 251.74,6.45 251.74,7.08 252.19,7.53 253.74,7.53 254.15,7.12 254.15,6.43 254.02,6.14 254.15,5.86 254.15,2.98 253.29,2.13 246.44,2.13 245.66,2.91 245.66,6.52 245.49,6.69 244.5,6.69 244.49,6.7 244.49,7.25 244.48,7.26 244.02,7.26 244.01,7.25 244.01,6.71 244,6.69 243.4,6.69 243.39,6.69 243.09,6.69 242.87,6.91 242.87,7.84 242.85,8.12 242.8,8.3 242.75,8.49 242.75,10.27 242.93,10.46 243.65,10.46 243.67,10.47 243.67,11.04 243.67,11.04 243.86,11.04 243.86,10.47 243.86,10.46 244.59,10.46 244.68,10.38 244.68,8.82 245.35,8.15 246.98,8.15 247.17,7.96 247.17,7.09 246.92,6.85 246.92,5.05
+5V_HDD_UZ23 on TOP (solid shape): 244.28,13.92 244.28,12.91 244.34,12.85 244.4,12.77 244.48,12.71 244.68,12.51 244.68,12.35 244.67,12.35 244.64,12.2 244.67,12.06 244.68,12.05 244.68,11.5 244.67,11.49 244.67,10.75 244.53,10.61 244.01,10.61 244.01,11.18 243.99,11.19 243.55,11.19 243.54,11.18 243.54,10.65 243.52,10.63 242.14,10.63 241.87,10.9 241.87,11.63 243.51,13.28 243.51,13.93 243.58,14 244.2,14
+5V_PD_VDD on TOP: 16.24,65.33 16.33,65.43 17.7,65.43 17.83,65.29 17.83,63.8 17.82,63.79 17.82,63.39 17.85,63.37 17.85,63.28 18.41,62.72 18.41,60.5 18.28,60.37 15.93,60.37 15.85,60.45 15.85,61.83 16.44,62.42 16.44,63.23 16.24,63.43
+5V_RUN on TOP (solid shape): 193.22,42.34 190.94,42.34 190.68,42.59 190.68,43.23 190.81,43.35 193.22,43.35
+5V_RUN on TOP (solid shape): 181.7,72.26 181.7,72.11 181.01,71.42 180.93,71.42 179.35,73 179.35,73.46 179.68,73.79 180.17,73.79
+5V_RUN on TOP (solid shape): 244.34,7.11 244.34,6.58 244.36,6.55 245.31,6.55 245.36,6.5 245.36,4.82 245.32,4.78 245.32,4.78 245.06,4.53 243.37,4.53 243.08,4.82 243.08,6.41 243.22,6.55 244.14,6.55 244.16,6.57 244.16,7.11 244.17,7.12 244.33,7.12
+5V_RUN on TOP (solid shape): 270.28,12.9 270.28,10.52 269.87,10.12 269.34,10.12 269.24,10.22 269.24,10.78 269.35,10.9 269.75,11.01 269.81,11.42 269.81,11.43 269.81,11.7 269.54,11.97 269.54,12.88 269.67,13 270.17,13
+5V_RUN on BOTTOM (solid shape): 191.7,42.85 191.7,42.21 191.06,41.58 190.81,41.58 190.43,41.96 190.43,42.97 190.81,43.35 191.19,43.35
+5V_RUN on BOTTOM (solid shape): 194.37,31.12 194.37,28.88 194.11,28.62 193.35,28.62 193.22,28.75 193.22,31.6 193.29,31.67 193.82,31.67
+5V_RUN on BOTTOM (solid shape): 183.73,89.77 183.73,88.75 183.23,88.26 182.79,88.18 181.72,85.52 181.49,85.39 180.98,85.58 180.98,85.58 180.11,85.91 180.11,86.16 180.57,87.92 180.57,88.39 180.52,88.44 180.52,89.2 180.27,89.45 180.27,89.96 180.4,90.09 183.41,90.09
+5V_RUN on BOTTOM (solid shape): outline of 317 points within 279.38,39.01 286.42,43.38
+5V_RUN on IN2 (solid shape): outline of 429 points within 243.38,3.98 258.12,8.36
+5V_RUN on IN3 (solid shape): 194.37,29.51 194.37,27.57 194.15,27.35 193.26,27.35 193.1,27.52 193.1,29.46 193.29,29.65 194.23,29.65
+5V_RUN on IN4 (solid shape): 180.55,74.67 180.55,72.9 180.31,72.67 179.89,72.67 179.16,73.4 179.16,74.82 179.33,75 180.22,75
+5V_RUN on IN4 (solid shape): 183.72,89.24 183.72,87.02 183.6,86.9 182.81,86.9 182.56,87.15 182.56,89.19 182.79,89.42 183.55,89.42
+5V_RUN on TOP: 212.87,26.65 212.65,26.87 212.65,27.5 212.51,27.64 212.51,28.59 212.72,28.8 213.14,28.8 213.14,28.25 213.65,28.25 213.65,28.8 213.94,28.8 213.94,28.25 214.45,28.25 214.45,28.8 215.12,28.8 215.19,28.77 215.22,28.71 215.26,28.56 215.35,28.44 215.58,28.34 215.82,28.41 215.93,28.42 215.98,28.33 216.33,27.98 216.33,27.47 216.36,27.4 216.33,27.33 216.23,27.08 216.32,26.83 216.35,26.76 216.32,26.69 216.28,26.65
+5V_RUN on TOP: 250.4,35.73 250.32,35.66 248.9,35.66 248.42,36.14 248.42,37.31 248.16,37.56 247.83,37.56 247.63,37.36 246.33,37.36 246.24,37.45 246.24,38.19 246.31,38.26 246.31,38.65 246.95,39.29 247.71,39.29 247.83,39.42 247.83,39.92 247.71,40.05 247.71,40.31 247.77,40.37 248.66,40.37 248.73,40.3 248.73,39.84 250.4,38.17
+5V_RUN on IN1: outline of 115 points within 246.88,37.79 279.84,41.53
