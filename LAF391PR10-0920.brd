# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_P10: length 161.3
  TOP w0.094: JUSH1.18 259.6,10.35 259.76,10.52 259.76,10.77 259.96,10.97 260.13,10.97 260.87,11.7 260.87,12.73 259.22,14.38 256.02,14.38 255.39,15.01 254.09,15.01 253.6,15.5 253.6,16.24 253.97,16.61 253.97,19.38 253.4,19.95 253.4,20.1 253.4,23.16 253.06,23.5 253.06,24.51 252.93,24.64 252.93,25.95 252.8,26.08 252.75,26.08 252.33,26.51 252.33,26.55 251.91,26.97 251.56,26.97 251.22,27.31 250.8,27.31 v1(250.6,27.11)
  IN1 w0.076: 141.92,55.82 141.92,55.83 141.93,55.84 141.93,56.22 141.12,57.03 140.47,57.03 139.2,58.3 137.95,58.3 137.72,58.07 137.33,58.07 137.14,58.26 137.14,58.58 v1(136.91,58.81)
  IN1 w0.089: 141.92,55.82 141.92,55.41 142.85,54.48 146.03,54.48 146.79,53.72 152,53.72 152.16,53.56 154.72,53.56 155.66,52.62 155.66,52.14 163.42,44.37 164.27,44.37 165.12,43.52 169.83,43.52 170.25,43.1 177.47,43.1 180.9,39.67 184.31,39.67 190,33.98 195.71,33.98 196.42,33.27 197.11,33.27 198.74,31.64 200.23,31.64 201.73,30.14 203.49,30.14 205.92,27.71 206.59,27.71 207.41,26.89 209.53,26.89 210.62,25.8 210.62,24.43 211.08,23.97 212.5,23.97 212.78,24.25 216.67,24.25 218.54,26.13 225.34,26.13 225.47,26.26 229.22,26.26 229.34,26.38 237.87,26.38 238.2,26.71 239.78,26.71 240.54,25.96 240.54,25.52 241.64,24.43 242.98,24.43 243.51,24.96 246.01,24.96 246.85,25.8 246.85,26.27 248.77,28.19 249.69,28.19 249.94,27.93 249.94,27.65 250.25,27.34 250.37,27.34 v1(250.6,27.11)
  BOTTOM w0.076: v1(136.91,58.81) 136.57,59.15 UC1.AH8
USB_OC0#: length 205.2
  TOP w0.102: UI3.13 278.9,29.01 278.96,29.08 280.55,29.08 280.93,29.46 v1(280.93,30.1) ; v1(144.7,89.1) 145.11,88.69 150.39,88.69 v2(151.64,89.95) 158.54,89.95 159.31,89.18 v1(159.31,89.07)
  IN2 w0.122: v1(203.85,37.26) 195.89,37.26 189.88,43.27 189.88,44.85 185.61,49.12 185.61,54.18 181.18,58.62 181.18,61.09 179.58,62.68 179.58,63.42 165.91,77.1 165.91,78.13 163.78,80.26 163.19,80.26 159.69,83.76 159.69,88.69 v1(159.31,89.07)
  IN4 w0.089: v1(280.93,30.1) 280.93,28.83 280.84,28.74 275.92,28.74 275.54,29.13 267.26,29.13 265.23,31.16 257.74,31.16 257.31,30.73 250.32,30.73 249.72,30.13 249.11,30.13 248.36,29.38 248,29.38 244.82,26.21 243.03,26.21 242.78,26.46 242.35,26.46 240.09,28.72 240.09,30.02 238.73,31.38 235.55,31.38 235.09,30.92 232.71,30.92 232.26,31.37 224.44,31.37 223.67,32.14 220.89,32.14 220.46,31.71 218.53,31.71 217.35,30.53 213.29,30.53 209.58,34.24 207.55,34.24 204.52,37.26 v1(203.85,37.26)
  BOTTOM w0.076: UC1.A9 135.95,73.72 138.03,75.79 138.18,75.79
  BOTTOM w0.102: 142.74,79.93 142.86,80.06 143.51,80.06 144.36,80.9 144.36,81.66 144.15,81.87 144.15,84.07 144.05,84.17 144.05,86.06 144.7,86.71 v1(144.7,89.1) ; 142.74,79.93 RPC3.2 ; 142.74,79.93 142.61,80.06 141.66,80.06 140.92,79.31 140.92,78.24 140.83,78.16 140.83,76.58 140.04,75.79 138.18,75.79
USB_OC1#: length 283.2
  TOP w0.102: v1(46.79,28.88) 46.66,28.75 46.66,28.11 47.86,26.92 47.86,18.51 v2(46.98,17.63) 45.78,16.43 44,16.43 41.71,14.14 30.92,14.14 28.41,16.65 UI1.3
  IN2 w0.122: v1(41.56,82.6) 41.63,82.6 42.09,83.05 42.8,83.05 46.28,86.53 52.38,86.53 54.92,89.07 54.92,90.52 55.26,90.86 63.42,90.86 64.95,89.33 67.01,89.33 70.89,93.21 70.89,95.26 71.54,95.91 72.55,95.91 72.85,95.6 73.51,95.6 74.45,96.54 75.09,96.54 80.64,90.99 85.1,90.99 87.94,93.83 89.64,93.83 91.92,91.55 92.9,91.55 94.43,90.01 100.12,90.01 101.69,88.45 108.65,88.45 109.3,87.79 110.54,87.79 111.63,86.7 112.77,86.7 113.84,85.63 127.86,85.63 128.68,84.81 131.83,84.81 134.93,81.71 138.87,81.71 138.96,81.8 141.98,81.8 142.33,81.45 142.33,79.05 v1(141.84,78.56)
  IN3 w0.122: v1(41.56,82.6) 41.53,82.57 40.03,82.57 38.85,81.39 30.8,81.39 29.82,80.41 25.81,80.41 24.66,79.26 21.25,79.26 18.34,76.35 18.34,68.5 17.27,67.42 17.27,64.96 15.55,63.25 15.55,55.29 18.5,52.35 18.5,49.86 17.33,48.69 17.33,43.96 19.7,41.59 19.7,34.3 18.7,33.3 18.7,26.84 22.23,23.31 33.18,23.31 34.47,22.02 35.87,22.02 36.38,21.51 37.77,21.51 39.68,23.41 45.65,23.41 46.79,24.56 v1(46.79,28.88)
  BOTTOM w0.102: UC1.C9 135.95,72.56 136.61,73.22 136.61,73.89 138.12,75.4 140.29,75.4 141.28,76.39 141.28,77.53 141.84,78.08 v1(141.84,78.56) 142.24,78.96 RPC3.3
USB_OC2#: length 12.6
  BOTTOM w0.076: UC1.D9 135.95,71.87 136.42,72.34 136.59,72.34 136.81,72.55 136.81,73.48 136.8,73.49
  BOTTOM w0.102: RPC3.1 143.24,79.14 143.34,79.04 143.34,78.69 142.8,78.15 v2(142.42,78.15) 142.23,78.15 141.51,77.43 141.51,76.3 140.41,75.2 138.18,75.2 136.8,73.81 136.8,73.49
USB_OC3#: length 10.1
  BOTTOM w0.076: UC1.B9 136.32,73.37 136.32,73.85 138.06,75.59 138.23,75.59
  BOTTOM w0.102: RPC3.4 141.74,79.14 141.25,78.65 141.25,77.96 v2(141.16,77.88) 141.06,77.77 141.06,76.49 140.16,75.59 138.23,75.59
USB_POWERSHARE_EN#: length 46.7
  TOP w0.076: 254.87,46.07 255.99,46.07 v1(256.21,46.29) 256.37,46.45 256.56,46.45 256.72,46.3 256.85,46.3 258.06,46.3 259.01,47.24 260.2,47.24 260.51,46.93 260.51,46.8 260.71,46.61 260.99,46.61 261.15,46.76 261.15,47.31 260.82,47.64 UE1.J3
  TOP w0.102: 254.87,46.07 254.25,46.07 254.2,46.11 RPE11.2 ; v1(273.94,44.78) 273.51,44.34 273.51,42.35 273.23,42.07 273.23,37.51 v2(273.07,37.35) 272.93,37.21 272.93,34.95 273.87,34.01 273.87,33.47 274.22,33.12 274.22,32.79 273.74,32.3 273.74,31.16 273.33,30.76 273.33,29.92 273.66,29.59 274.3,29.59 274.73,30.01 UI3.6
  IN1 w0.089: v1(273.94,44.78) 273.79,44.62 272.62,44.62 270.91,46.33 265.83,46.33 265.58,46.08 264.53,46.08 263.71,46.91 256.83,46.91 v1(256.21,46.29)
USB_POWERSHARE_VBUS_EN: length 47.3
  TOP w0.076: 254.87,46.76 255.07,46.76 255.18,46.87 256.63,46.87 256.85,46.66 257.67,46.66 257.99,46.97 257.99,47.27 257.75,47.51 257.75,47.82 257.8,47.87 257.8,47.88 257.96,48.04 259.52,48.04 259.84,47.73 UE1.J2 ; 260.38,48.07 v1(260.38,48.1)
  TOP w0.102: UI3.5 274.85,30.51 274.17,29.84 273.79,29.84 273.56,30.07 273.56,30.65 273.97,31.06 273.97,32.19 274.23,32.46 274.46,32.46 v2(274.54,32.54) 274.54,32.88 274.48,32.94 274.48,33.19 274.12,33.55 274.12,34.08 273.16,35.05 273.16,36.93 273.46,37.23 273.46,41.08 v1(274.09,41.71) ; RPE11.4 254.36,47.11 254.72,46.76 254.87,46.76 ; UE1.J2 260.05,47.73 260.38,48.07
  BOTTOM w0.102: v1(274.09,41.71) 274.09,43.49 271.15,46.43 269.07,46.43 268.71,46.78 266.63,46.78 266.45,46.96 266.45,49.88 266.21,50.12 265.89,50.12 265.64,50.38 265.64,50.81 265.54,50.91 265.01,50.91 264.82,51.1 264.82,51.53 264.63,51.73 263.87,51.73 263.12,50.97 261.03,50.97 260.79,50.73 260.79,48.52 v1(260.38,48.1)
USB_PWR_EN1#: length 281.3
  TOP w0.076: 254.87,46.44 v1(255.63,46.44) 255.85,46.66 256.6,46.66 256.79,46.47 257.99,46.47 258.94,47.42 260.34,47.42 UE1.K3
  TOP w0.102: UI1.4 31.25,14.59 41.53,14.59 v2(42.45,15.52) 43.81,16.88 45.59,16.88 47.6,18.89 47.6,26.54 47.05,27.1 46.22,27.93 46.22,30.59 52.63,37 v1(52.63,39.34) ; 254.87,46.44 254.36,46.44 254.19,46.61 RPE11.3
  IN2 w0.122: v1(52.63,39.34) 55.58,39.34 64.24,30.68 69.36,30.68 71.56,28.48 97.84,28.48 99.75,30.4 135.44,30.4 142.1,23.74 154.69,23.74 156.45,25.51 183.67,25.51 185.97,27.81 192.74,27.81 194.16,26.39 196.14,26.39 196.42,26.67 196.42,27.45 196.88,27.91 198.05,27.91 198.94,27.02 204.6,27.02 204.98,27.4 206.41,27.4 207.04,26.76 207.04,26.76 207.14,26.66 207.14,26.44 208.18,25.4 217.53,25.4 217.78,25.14 227.61,25.14 228.26,24.49 229.04,24.49 229.34,24.79 229.34,25.24 230.8,26.7 237.06,26.7 237.97,27.61 238.33,27.61 239.3,28.59 239.3,30.14 243.1,33.94 244.69,33.94 245.33,34.58 246.6,34.58 249.28,37.26 250.22,37.26 252.04,39.08 252.04,39.3 253.8,41.06 253.8,42.98 254.77,43.95 255.16,43.95 255.45,44.24 255.45,46.26 v1(255.63,46.44)
USB_PWR_EN2#: length 13.9
  TOP w0.102: v2(252.75,44.18) 253.34,44.77 v1(253.35,44.77) 253.35,44.87 RPE11.1 ; UE1.G5 v1(262.01,48.92)
  IN2 w0.122: v1(262.01,48.92) 261.58,49.35 259.54,49.35 259.14,48.94 256.72,48.94 255.26,47.48 255.12,47.48 254.06,46.41 254.06,45.48 v1(253.35,44.77)
USBCOMP: length 15.7
  TOP w0.127: v1(150.17,64.6) 149.38,65.39 RC44.1
  IN3 w0.127: v1(138.17,62.04) 138.28,62.15 138.54,62.15 139.59,63.2 148.09,63.2 149.5,64.6 v1(150.17,64.6)
  BOTTOM w0.076: UC1.AB6 137.87,62.34 v1(138.17,62.04)
  BOTTOM w0.127: v2(149.34,64.51) 150.08,64.51 v1(150.17,64.6)
USH_DET#: length 91.6
  TOP w0.076: 273.36,53.39 273.36,53.01 272.89,52.53 UE1.C13
  TOP w0.102: v1(250.8,17.37) 251.08,17.37 251.26,17.19 251.26,14.11 DZ7.2 250.94,13.13 251.2,12.87 RZ87.1 ; 273.36,53.39 273.36,54.15 273.99,54.78 274.7,54.78 275.37,55.46 275.62,55.46 276.37,56.21 278.67,56.21 279.21,55.67 v2(279.33,55.67) 279.66,55.67 v1(280.01,55.32) 280.01,55.6 RE526.1
  IN4 w0.089: v1(250.8,17.37) 253.49,17.37 254.85,18.73 260.1,18.73 262.84,21.47 263.03,21.47 263.62,22.06 263.62,22.48 264.19,23.05 264.19,23.95 265.89,25.65 266.32,25.65 267.9,27.22 268.66,27.22 268.91,27.48 268.91,28.11 269.42,28.62 275.54,28.62 275.78,28.38 279.32,28.38 279.84,27.86 281.61,27.86 282.58,28.83 282.58,29.97 284.03,31.42 284.03,37.77 287.68,41.42 287.68,43.56 285.02,46.22 283.06,46.22 281.51,47.77 281.51,50.47 280.06,51.91 280.06,55.27 v1(280.01,55.32)
USH_DET#_R: length 4.4
  TOP w0.102: v2(251.81,11.03) 251.81,11.32 252.02,11.54 RZ87.2 251.6,11.96 251.48,12.09 DZ7.1 250.88,12.02 250.88,10.99 251.1,10.77 JUSH1.1
USH_EXPANDER_SMBCLK: length 63.1
  TOP w0.076: UE1.B3 261.09,53.33 261.42,53.01 261.93,53.01 v1(262.06,52.88)
  TOP w0.102: RZ8.2 259.52,13.03 CZ62.1 259.27,11.85 v1(259.27,11.45) 259.27,11.37 v2(258.93,11.02) 258.6,10.7 JUSH1.16
  IN3 w0.122: v1(259.27,11.45) 259.23,11.41 259.23,10.86 258.72,10.35 257.94,10.35 256.81,11.48 254.2,11.48 253.98,11.71 253.29,11.71 252.72,12.28 252.72,13.7 253.47,14.45 253.47,19.37 249.99,22.85 249.99,24.22 248.52,25.69 248.52,30.84 249.22,31.54 249.22,35.22 253.81,39.8 253.81,42.45 254.46,43.09 255.12,43.09 256.13,44.11 257.02,44.11 258.25,45.34 258.63,45.34 259.16,45.86 259.16,47.64 260.28,48.76 260.28,50.97 261.04,51.73 261.35,51.73 261.55,51.93 261.55,52.37 v1(262.06,52.88)
USH_EXPANDER_SMBDAT: length 60.4
  TOP w0.102: UE1.E5 v1(262.03,50.54) ; RZ9.2 257.87,12.92 CZ63.1 258.7,11.5 v1(258.65,11.45) 257.99,11.45 v2(257.65,11.11) 257.65,10.88 258.1,10.43 JUSH1.15
  IN3 w0.122: v1(258.65,11.45) 258.73,11.38 258.73,11.07 258.51,10.85 258.15,10.85 257.01,11.98 254.41,11.98 254.18,12.21 253.5,12.21 253.22,12.49 253.22,13.49 253.97,14.24 253.97,14.66 253.97,19.58 250.49,23.06 250.49,24.43 249.03,25.9 249.03,27.83 250.04,28.85 250.04,31.42 249.73,31.73 249.73,35.01 254.31,39.6 254.31,42.24 254.66,42.59 255.33,42.59 256.34,43.61 257.23,43.61 258.45,44.83 258.84,44.83 260.21,46.21 260.21,47.37 260.78,47.95 260.78,50.77 261.24,51.23 261.55,51.23 262.03,50.74 v1(262.03,50.54)
USH_PWR_STATE#: length 69.6
  TOP w0.076: 254.87,47.38 255.21,47.04 257.29,47.04 257.48,47.23 257.48,47.8 257.96,48.28 259.04,48.28 259.09,48.22 259.71,48.22 UE1.H2
  TOP w0.102: 254.87,47.38 254.07,48.18 252.1,48.18 251.55,47.63 247.28,47.63 244.49,44.85 244.49,44.25 243.98,43.73 242.92,43.73 241.74,42.56 241.74,42.08 239.73,40.08 239.73,39.58 240.34,38.97 240.34,37 239.45,36.11 239.45,32.94 240.19,32.2 245.2,32.2 246.69,30.71 v3(246.69,28.69) 246.69,27.99 245.29,26.59 245.29,25.97 245.6,25.66 v1(245.6,25.62) ; JUSH1.5 253.1,10.41 252.75,10.77 v1(252.38,10.77) 252.38,11.53 252.53,11.68 252.53,12.35 RZ10.2
  IN3 w0.122: v1(252.38,10.77) 252.38,11.4 251.27,12.51 251.27,17.64 249.68,19.23 249.68,19.96 247.95,21.7 246.66,21.7 245.93,22.44 245.93,25.29 v1(245.6,25.62)
USH_RST#_R: length 2.2
  TOP w0.102: JUSH1.6 v1(253.6,8.77)
  BOTTOM w0.102: RZ114.2 253.6,8.86 v1(253.6,8.77)
VCI_IN1#: length 20.2
  TOP w0.076: v1(261.34,55.93) 261.37,55.9 261.37,55.22 262.06,54.53 262.06,53.7 UE1.B5
  BOTTOM w0.102: RE507.1 247.23,53.35 248.07,53.35 248.34,53.62 249.08,53.62 249.36,53.89 249.36,54.38 249.84,54.86 250.59,54.86 v2(252.42,56.69) 252.67,56.94 258.5,56.94 259.52,55.93 v1(261.34,55.93)
VCI_IN2#: length 19.3
  TOP w0.076: UE1.D4 261.31,52.05 261.31,52.86 261.15,53.02 260.64,53.02 260.41,53.26 260.41,54.28 259.55,55.14 259.55,55.28 v1(259.08,55.74)
  BOTTOM w0.102: v1(259.08,55.74) 259.08,55.87 258.26,56.69 252.91,56.69 v2(251.39,55.17) 250.83,54.61 249.92,54.61 249.61,54.3 249.61,53.77 249.23,53.39 248.47,53.39 247.83,52.75 RE508.1
VCT_LAN_R1: length 10.5
  TOP w0.102: RL3.1 v2(267.01,70.28) 266.12,71.17 261.19,71.17 260.41,71.96 260.41,72.94 260.23,73.12 UL1.6
VGA_IDENTIFY: length 12.6
  TOP w0.076: v1(269.9,48.61) 269.93,48.61 270.06,48.48 270.69,48.48 ; v1(265.2,46.47) 265.53,46.13 UE1.L9
  TOP w0.102: v2(276.04,49.04) RE85.1 RE84.1 273.46,48.48 270.69,48.48
  IN1 w0.089: v1(265.2,46.47) 265.49,46.76 268.05,46.76 v1(269.9,48.61)
VID0_PRIM_CORE: length 6
  TOP w0.102: v2(176.62,102.69) PR420.1
  TOP w0.254: v1(174.07,101.95) 174.17,101.95 174.76,102.54 PR418.2 175.56,102.6 PR420.1
  BOTTOM w0.254: PU402.9 174.47,100.37 174.63,100.53 174.63,101.1 174.05,101.69 174.05,101.93 v1(174.07,101.95) 174.15,101.95 174.76,102.56 PR418.2
VID0_VCCIO: length 5.1
  BOTTOM w0.102: v2(178.97,54.66) 178.72,54.4 PR416.1
  BOTTOM w0.305: PU401.9 177.19,51.2 177.73,51.74 177.73,53.29 177.86,53.42 PR414.2 PR416.1
VID1_PRIM_CORE: length 4.3
  TOP w0.102: v2(174.21,101.37) 174.07,101.37 v1(173.45,101.99)
  TOP w0.254: v1(173.45,101.99) 173.45,102.09 173.87,102.51 PR417.2 173.8,102.66 173,102.66 PR419.1
  BOTTOM w0.254: PR417.2 173.87,102.49 173.45,102.06 v1(173.45,101.99) PU402.8
VID1_VCCIO: length 4.7
  BOTTOM w0.102: v2(176.53,55.47) 176.53,54.15 177,53.69 PR413.2
  BOTTOM w0.203: PR413.2 176.99,53.6 PR415.1
  BOTTOM w0.254: PU401.8 175.97,52.37 176.12,52.52 176.12,53.2 176.05,53.28 PR415.1
VIDALERT_N: length 70.3
  TOP w0.152: PR604.2 v1(61.5,66.38) 62.14,66.38 PR625.1 ; RC152.1 103.31,79.19 RC153.2 103.34,79.1 103.34,77.3 v1(103.23,77.19)
  IN1 w0.152: v1(61.5,66.38) 62.14,66.38 62.79,67.04 62.79,69.15 65.97,72.32 65.97,73.75 68.86,76.65 68.86,80.27 69.79,81.2 71.7,81.2 75.12,84.63 75.41,84.63 75.71,84.92 81.6,84.92 82.58,85.9 83.86,85.9 86.98,89.02 99.67,89.02 100.77,87.91 100.77,83.01 101.43,82.35 101.43,80.29 101.91,79.8 101.91,78.02 102.75,77.19 v1(103.23,77.19)
  BOTTOM w0.152: v1(61.5,66.38) v2(60.82,66.38)
VIDALERT_N_B: length 3
  TOP w0.152: PR625.2 63.41,66.68 64.62,66.68 v2(64.75,66.81) PU602.36
VIDSCLK: length 73.5
  TOP w0.152: PR601.2 61.06,65.73 v1(61.55,65.73) 61.91,65.73 PR618.1 ; v1(103.94,76.12) 104.32,76.5 CC321.1 105.05,77.26 v2(105.31,77.53)
  IN1 w0.152: v1(61.55,65.73) 61.89,65.73 63.07,66.91 63.07,69.03 66.29,72.25 66.29,73.63 69.14,76.49 69.14,80.16 69.91,80.92 71.81,80.92 75.24,84.35 75.53,84.35 75.82,84.64 81.86,84.64 82.71,85.49 83.85,85.49 87.1,88.74 99.55,88.74 100.49,87.8 100.49,79.62 101.46,78.65 101.46,77.71 103.05,76.12 v1(103.94,76.12)
  BOTTOM w0.076: UC1.A63 104.7,73.78 104.7,74.05 104.44,74.31 104.44,75.68 104,76.12 v1(103.94,76.12)
VIDSCLK_B: length 3.9
  TOP w0.152: PR618.2 63.84,66.24 v1(64.06,66.24) 64.68,66.24 64.84,66.41 PU602.37
  BOTTOM w0.152: v2(64.62,66.65) 64.47,66.65 v1(64.06,66.24)
VIDSOUT: length 75
  TOP w0.152: v2(102.11,77.44) 102.11,77.92 v1(102.52,78.33) 102.42,78.43 RC157.1 ; PR605.2 60.86,67.23 v1(61.47,67.23) PR626.1
  IN1 w0.152: v1(102.52,78.33) 102.32,78.53 102.32,80.59 102.17,80.74 101.86,80.74 101.71,80.89 101.71,81.2 101.86,81.35 102.17,81.35 102.32,81.5 102.32,81.85 101.05,83.12 101.05,88.03 99.78,89.3 86.87,89.3 83.81,86.24 82.43,86.24 81.4,85.2 75.59,85.2 75.3,84.9 75.01,84.9 71.58,81.48 69.68,81.48 68.58,80.39 68.58,76.76 65.65,73.83 65.65,72.4 62.51,69.27 62.51,67.62 62.13,67.23 v1(61.47,67.23)
  BOTTOM w0.076: UC1.D64 104.3,72.26 104.59,72.55 104.59,72.8 104.37,73.02 104.37,73.91 104.11,74.17 104.11,74.78 103.06,75.83 103.06,76.59 102.42,77.24 102.42,78.23 v1(102.52,78.33)
VIDSOUT_B: length 3.6
  TOP w0.152: PR626.2 63.1,67.21 v1(64.15,67.21) PU602.35
  BOTTOM w0.152: v2(63.44,67.14) 63.48,67.14 63.55,67.21 v1(64.15,67.21)
VRALERT#: length 18
  TOP w0.102: v1(135.58,57.72) 135.67,57.81 v2(136.15,57.81) 136.16,57.82 137.58,57.82 138.32,57.08 139.36,57.08 141.43,55.01 147.49,55.01 147.73,55.25 148.07,55.25 149.14,56.33 149.66,56.33 149.97,56.64 RC73.1
  BOTTOM w0.076: v1(135.58,57.72) 134.93,57.72 134.61,57.39 UC1.AM11
VSA_SEN+: length 98
  TOP w0.152: PC640.2 67.35,73.88 67.68,74.21 PC652.1 ; PC640.2 67.35,72.52 PC650.1 ; PC640.2 67,73.34 v1(66.76,73.1) ; v1(126.98,74.88) 126.93,74.88 126.55,75.26 126.55,76.55 RC168.2
  IN3 w0.152: v1(129.24,68.78) 128.79,68.59 128.6,68.68 128.51,68.87 127.92,69.47 127.13,69.47 126.39,70.2 126.39,74.84 126.57,75.02 126.84,75.02 v1(126.98,74.88) 127.16,74.88 127.41,75.13 127.41,76.7 124.85,79.27 124.85,83.99 122.12,86.72 117.61,86.72 117.19,87.14 112.12,87.14 111.23,86.25 107.9,86.25 106.99,87.17 105.79,87.17 105.18,86.56 101.21,86.56 99.22,84.56 99.22,82.95 98.85,82.58 93.82,82.58 93.5,82.27 93.5,81.85 v1(93.32,81.68)
  IN4 w0.152: v1(93.32,81.68) 93.46,81.54 93.46,80.15 92.5,79.18 90.58,79.18 89.23,80.53 88.12,80.53 87.79,80.86 86.31,80.86 85.65,80.2 85.65,77.1 85.22,76.67 78.37,76.67 77.36,75.66 75.82,75.66 74.12,73.96 73.51,73.96 71.86,72.31 67.54,72.31 v1(66.76,73.1)
  BOTTOM w0.152: UC1.H20 129.44,68.98 v1(129.24,68.78) ; PR649.2 66.82,73.03 v1(66.76,73.1)
VSA_SEN-: length 96.5
  TOP w0.152: PU602.26 68.17,70.42 67.9,70.69 v1(67.9,70.76) 67.92,70.79 67.92,70.91 67.38,71.46 PC650.2 ; v1(126.98,75.46) 126.85,75.59 126.85,76.48 RC166.1
  IN3 w0.152: v1(93.91,81.68) 93.81,81.78 93.81,82.14 93.95,82.28 98.98,82.28 99.52,82.83 99.52,84.44 101.34,86.25 105.31,86.25 105.92,86.86 106.86,86.86 107.78,85.95 111.36,85.95 112.25,86.84 117.06,86.84 117.48,86.42 121.99,86.42 124.54,83.87 124.54,79.14 127.11,76.58 127.11,75.59 v1(126.98,75.46) 126.84,75.32 126.45,75.32 126.09,74.96 126.09,70.08 127,69.16 127.8,69.16 128.25,68.7 128.31,68.56 128.23,68.36 v1(127.79,68.17)
  IN4 w0.152: v1(93.91,81.68) 93.77,81.54 93.77,80.02 92.63,78.88 90.45,78.88 89.11,80.22 87.99,80.22 87.66,80.55 86.44,80.55 85.96,80.07 85.96,76.98 85.35,76.37 78.5,76.37 77.49,75.36 75.95,75.36 74.25,73.66 73.64,73.66 71.99,72.01 68.08,72.01 67.92,71.85 67.92,70.79 v1(67.9,70.76)
  BOTTOM w0.152: UC1.H21 128.72,68.98 127.91,68.17 v1(127.79,68.17) ; v1(67.9,70.76) 67.83,70.69 PC649.1
VSET_5105: length 17.1
  TOP w0.102: v1(265.25,52.94) 265.62,52.57 UE1.C9 ; v1(272.98,61.26) RE77.1 CE38.1
  BOTTOM w0.102: v1(265.25,52.94) 265.42,52.94 265.84,52.52 267.8,52.52 268.66,53.39 271.07,53.39 271.96,54.28 271.96,60.24 v2(272.2,60.48) v1(272.98,61.26)
VSYNC_CONN: length 8.2
  TOP w0.102: JCRT1.14 v2(291.16,51.25) 290.5,51.91 289.39,51.91 288.93,52.37 CV132.1 RV121.1 287.84,52.37 287.35,51.89 286.63,51.89 286.06,52.46 RV651.2
VSYNC_CRT: length 2.2
  TOP w0.102: RV651.1 285.3,52.56 v1(285.3,51.66) 285.16,51.52 284.98,51.52 284.77,51.31 UV6.18
WIGIG_32KHZ: length 3.7
  TOP w0.102: RZ56.1 219.38,25.79 v1(219.46,25.71)
  BOTTOM w0.102: v2(220.2,26.09) 219.81,25.71 v1(219.46,25.71) 218.92,26.25 JNGFF1.50
WLAN_COEX1: length 98.9
  IN1 w0.089: v1(222.22,13.59) 221.87,13.93 221.87,14.69 222.91,15.72 231.08,15.72 231.31,15.49 232.97,15.49 234.1,14.36 237.53,14.36 238.24,13.66 241.6,13.66 241.94,14 249.31,14 250.57,15.26 251.57,15.26 252.91,16.6 254.61,16.6 257.45,19.43 257.45,23.57 258.79,24.91 264.56,24.91 265.87,26.22 266.93,26.22 267.59,26.88 273.1,26.88 273.72,27.5 273.72,28.06 275.16,29.5 276.91,29.5 277.73,30.31 277.73,31.78 279.35,33.41 v1(279.35,34.27)
  BOTTOM w0.102: v1(222.22,13.59) 221.73,13.59 v2(221.67,13.65) 221.48,13.84 221.48,14.64 222.71,15.87 222.71,21.37 223.88,22.54 223.88,24.11 223.49,24.51 222.6,24.51 221.67,25.44 221.67,26.38 221.29,26.75 JNGFF1.48 ; RZ130.2 276.97,38.22 276.97,37.79 279.54,35.21 279.54,34.46 v1(279.35,34.27)
WLAN_COEX2: length 103.7
  IN1 w0.089: v1(280.25,35.98) 280.25,33.69 278.16,31.6 278.16,30.05 274.81,26.7 273.89,26.7 273.64,26.45 267.77,26.45 267.11,25.79 266.05,25.79 264.74,24.48 258.97,24.48 257.88,23.39 257.88,18.99 256.53,17.64 256.53,16.87 256.18,16.52 255.54,16.52 255.2,16.18 255.2,15.67 254.61,15.08 252.17,15.08 251.84,14.75 250.67,14.75 249.49,13.57 242.12,13.57 241.78,13.22 238.06,13.22 237.35,13.93 233.92,13.93 232.79,15.06 231.06,15.06 230.84,15.29 223.3,15.29 222.67,14.66 222.67,14.06 v1(222.65,14.03)
  BOTTOM w0.102: v2(280.79,35.62) 280.43,35.98 v1(280.25,35.98) 279.89,35.62 279.58,35.62 279.06,36.14 279.06,36.84 276.18,39.72 RZ129.2 ; v1(222.65,14.03) 222.04,14.03 221.75,14.32 221.75,14.58 222.94,15.78 222.94,21.27 224.11,22.44 224.11,24.21 223.58,24.74 222.69,24.74 221.89,25.53 221.89,26.77 220.78,27.89 219.5,27.89 218.87,27.25 JNGFF1.46
WLAN_COEX3: length 101
  TOP w0.102: v1(222.27,14.52) 222.27,14.99 v2(222.56,15.27)
  IN1 w0.089: v1(279.68,36.1) 279.68,34.9 279.82,34.76 279.82,33.57 277.94,31.69 277.94,30.22 277,29.28 275.25,29.28 273.94,27.97 273.94,27.41 273.19,26.67 267.68,26.67 267.02,26.01 265.96,26.01 264.65,24.69 258.88,24.69 257.67,23.48 257.67,19.34 254.7,16.38 253,16.38 251.66,15.04 250.66,15.04 249.4,13.78 242.03,13.78 241.69,13.44 238.15,13.44 237.44,14.14 234.01,14.14 232.88,15.28 231.22,15.28 230.99,15.5 223.21,15.5 222.27,14.56 v1(222.27,14.52)
  BOTTOM w0.102: v1(279.68,36.1) 279.29,36.49 279.29,36.94 276.2,40.03 275.05,40.03 RZ128.2 ; JNGFF1.44 219.04,27.75 219.41,28.11 220.88,28.11 222.12,26.87 222.12,25.63 222.79,24.96 223.68,24.96 224.34,24.3 224.34,22.35 223.17,21.18 223.17,15.41 v1(222.27,14.52)
WLAN_PWR_EN: length 6
  TOP w0.102: UZ4.5 214.93,33.93 v2(215.99,33.93) RZ71.2 RZ70.2 216.95,34.82 RZ38.2 219.22,35.71 DZ9.1
WLAN_WIGIG60GHZ_DIS#: length 102.9
  TOP w0.076: v1(269.83,45) 269.93,44.9 270.56,44.9 270.69,44.77 270.69,44.74 ; 269.3,45.56 268.82,46.04 UE1.L13
  TOP w0.102: 270.69,44.74 270.94,44.5 272.81,44.5 273.03,44.28 273.03,42.96 v2(272.93,42.87) 272.47,42.4 RE8.1 ; v1(213.52,19.66) 213.52,21.26 215.04,22.78 215.58,22.78 215.83,22.53 217.35,22.53 217.54,22.72 218.11,22.72 218.22,22.82 218.22,24.91 218,25.13 DZ1.1 ; v1(269.83,45) 269.83,45.07 269.34,45.56 269.3,45.56
  IN2 w0.122: v1(269.83,45) 270.3,44.53 270.3,42.74 270.18,42.63 270.18,41.19 269.91,40.92 269.91,37.11 268.79,35.99 267.15,35.99 266.53,35.37 266.53,34.95 266.6,34.87 266.6,33.3 265.36,32.05 263.07,32.05 262.69,31.67 260.94,31.67 259.81,30.54 259.81,30.08 258.2,28.47 258.2,24.44 256.72,22.96 256.72,19.86 256.33,19.47 255.72,19.47 253.05,16.8 251.54,16.8 251.1,16.36 250.23,16.36 249.91,16.68 247.93,16.68 247.2,17.42 241.91,17.42 240.84,16.35 240.84,15.87 238.53,13.56 234.27,13.56 231.07,16.76 231.07,16.94 230.47,17.54 224.78,17.54 223.34,18.98 221.41,18.98 221.17,19.21 217.97,19.21 216.89,18.13 214.63,18.13 214.28,18.49 214.28,18.89 v1(213.52,19.66)
WLAN_WIGIG60GHZ_DIS#_R: length 4.5
  TOP w0.102: v1(216.48,24.9) 216.3,25.07 DZ1.2
  BOTTOM w0.102: v2(219.99,24.75) JNGFF1.56 216.63,24.75 v1(216.48,24.9)
WWAN_COEX1: length 3.5
  BOTTOM w0.102: JNGFF2.64 274.5,37.17 274.22,37.44 274.22,37.93 274.66,38.37 v2(274.66,38.68) 275.06,39.08 RZ130.1
WWAN_COEX2: length 3.8
  BOTTOM w0.102: RZ129.1 273.36,39.01 v2(273.36,38.92) 273.36,37.89 274,37.25 JNGFF2.62
WWAN_COEX3: length 5
  BOTTOM w0.102: RZ128.1 273.33,40.42 v2(273.21,40.29) 272.98,40.06 272.98,37.75 273.5,37.23 JNGFF2.60
WWAN_PWR_EN: length 5.2
  BOTTOM w0.102: v2(261.26,40.03) 260.65,40.03 RZ43.1 261.14,38.79 CZ198.1 261.14,38.45 260,37.31 JNGFF2.6
WWAN_RADIO_DIS#: length 26.4
  TOP w0.076: UE1.F12 268.02,50.14 v1(267.64,50.52)
  TOP w0.102: v1(257.36,38.48) DZ5.1 257.23,39.29 257.23,41.56 RE10.1
  IN4 w0.089: v1(267.64,50.52) 268.79,49.37 268.79,46.87 269.28,46.37 269.28,44.56 266.04,41.32 264.04,41.32 261.59,38.87 260.54,38.87 260.29,39.12 258,39.12 v1(257.36,38.48)
  BOTTOM w0.102: v1(267.64,50.52) 268.04,50.52 v2(268.23,50.33)
WWAN_RADIO_DIS#_R: length 7.5
  TOP w0.102: DZ5.2 v2(257.36,36.38) 256.87,35.9 256.87,35.33 257.1,35.1 258.32,35.1 258.78,34.64 v1(259.47,34.64)
  BOTTOM w0.102: v1(259.47,34.64) 259.57,34.64 260.5,35.58 JNGFF2.8
WWAN_WAKE#: length 21.2
  TOP w0.076: 270.63,44.18 v2(270.24,44.56) 270.18,44.62 269.42,44.62 268.82,45.22 UE1.M13
  TOP w0.102: 270.63,44.18 270.68,44.18 v1(270.77,44.09) 270.84,44.01 RE38.1
  IN3 w0.122: v1(270.77,44.09) 270.58,43.9 270.58,42.73 268.69,40.84 268.69,35.63 264.72,31.67 v1(264.72,30.07)
  BOTTOM w0.102: JNGFF2.23 264.25,29.57 264.72,30.04 v1(264.72,30.07)
XCLK_BIASREF: length 21.6
  TOP w0.102: RC52.1 123.22,82.8 v1(122.86,82.44) 122.83,82.41 122.83,80.01 v2(122.94,79.9) 122.94,78.84 123.27,78.51 123.27,76.65 RC324.1
  IN4 w0.089: v1(122.86,82.44) 122.51,82.09 122.51,80.64 117.39,75.52 v1(117.39,71.18)
  BOTTOM w0.076: v1(117.39,71.18) 117.16,71.18 UC1.E42
XDP_DBRESET#: length 90.2
  TOP w0.102: v1(110.16,97.46) 110.16,98.78 108.72,100.22 v2(108.72,103.46) 108.37,103.81 107.65,103.81 106.38,105.08 105.48,105.08 104.99,104.59 98.58,104.59 v1(96.24,102.26)
  IN2 w0.122: v1(147.81,86.2) 147.38,85.77 146.28,85.77 145.93,86.12 137.04,86.12 134.37,88.79 121.52,88.79 120.3,90.01 114.43,90.01 110.16,94.28 v1(110.16,97.46)
  IN4 w0.089: v1(91.64,102.26) 87.33,102.26 v1(84.51,99.44)
  BOTTOM w0.102: v1(96.24,102.26) 95.36,101.37 92.26,101.37 91.64,101.99 v1(91.64,102.26) JXDP1.48 ; RC137.1 CC32.1 v1(84.51,99.44) ; v1(147.81,86.2) 147.85,86.16 149.38,86.16 149.71,85.82 150.94,85.82 151.57,86.45 151.57,87.85 151.11,88.31 RC290.1 UC12.1
XDP_JTAGX: length 19.8
  IN4 w0.089: v1(112.6,85.95) 112.6,81.92 110.89,80.21 108.01,80.21 v1(107.42,79.62)
  BOTTOM w0.076: 107.31,74.97 107.31,73.68 UC1.A59
  BOTTOM w0.102: RC328.2 v1(112.6,85.95) ; 107.31,74.97 106.91,75.37 v2(106.91,76.01) 106.91,76.89 106.13,77.68 106.13,78.86 106.8,79.54 106.8,79.84 CC305.1 107.19,79.85 v1(107.42,79.62) 107.84,80.04 RC87.1
XDP_OBS0: length 4.5
  BOTTOM w0.102: JXDP1.21 98.14,96.89 v2(99.47,95.56) 100.14,94.89 RC239.2
XDP_OBS0_R: length 26.7
  IN4 w0.089: v1(109.28,75.79) 109.21,75.87 108.46,75.87 106.01,78.32 106.01,79.11 105.36,79.76 105.36,81.56 105.29,81.63 105.29,86.84 105.34,86.89 105.34,87.27 104.7,87.91 104.7,89.46 104.48,89.68 104.48,90.44 104.27,90.65 104.27,90.98 103.78,91.47 103.78,92 103.38,92.4 102.78,92.4 102.36,92.82 v1(100.19,92.82)
  BOTTOM w0.076: v1(109.28,75.79) 109.28,75.74 109.26,75.71 UC1.C55
  BOTTOM w0.102: v1(100.19,92.82) 100.14,92.88 RC239.1
XDP_OBS1: length 4.6
  BOTTOM w0.102: RC240.2 99.52,94.62 99.52,94.93 97.64,96.82 JXDP1.23
XDP_OBS1_R: length 29.4
  IN4 w0.089: v1(99.59,92.82) 100,93.24 102.5,93.24 102.94,92.8 103.54,92.8 104.18,92.16 104.18,91.63 104.67,91.14 104.67,90.81 105.36,90.11 105.36,87.83 105.73,87.46 105.73,86.73 105.68,86.68 105.68,82.66 106.2,82.14 106.2,80.23 106.51,79.93 106.51,78.38 108.51,76.37 109.47,76.37 v1(109.49,76.35)
  BOTTOM w0.076: UC1.D55 109.26,72.22 109.58,72.54 109.58,72.81 109.44,72.95 109.44,74.89 109.78,75.23 109.78,75.99 109.49,76.28 v1(109.49,76.35)
  BOTTOM w0.102: RC240.1 99.59,93.1 v1(99.59,92.82)
XDP_OBS2_R: length 4.1
  BOTTOM w0.076: UC1.B54 110.09,73.27 110.09,73.81 109.92,73.97 109.92,74.6 110.27,74.95 T10.1
XDP_OBS3_R: length 6.9
  BOTTOM w0.076: T11.1 109.09,78.65 109.09,78.11 108.41,77.43 108.41,75.57 108.96,75.02 108.96,72.79 108.69,72.52 UC1.C56
XDP_PRSNT_PIN1: length 8.7
  BOTTOM w0.102: JXDP1.1 103.14,96.9 103,96.76 103,94.81 103.69,94.12 103.69,93.52 v2(102.67,92.5) 101.29,92.5 RC122.1 RC121.1
XDP_TMS: length 34.7
  TOP w0.102: v1(107.38,102.92) 107.38,100.83 RC228.1 107.13,100.58 UC8.9 ; v1(108.03,107.78) v2(108.03,107.2) 106.87,106.04 105.08,106.04 104.59,105.56 103.85,105.56 102.75,106.65 98.3,106.65 v1(97.21,107.74)
  IN2 w0.122: v1(88.64,105.84) 89.68,106.88 93.2,106.88 93.86,106.21 95.66,106.21 97.18,107.74 v1(97.21,107.74)
  BOTTOM w0.102: JXDP1.58 89.14,105.34 v1(88.64,105.84) ; v1(107.38,102.92) 108.03,103.57 v1(108.03,107.78)
XTAL24_IN_U22: length 5.5
  BOTTOM w0.102: RC419.2 RC46.2 119.68,80.84 CC21.1 120.15,81.58 120.15,82.93 119.17,83.91 YC1.3
XTAL24_IN_U22_CPU: length 8.8
  BOTTOM w0.076: 120.24,75.8 119.75,75.3 119.75,74.09 119.47,73.81 119.47,72.5 119.44,72.47 119.44,72.23 119.46,72.21 119.46,71.84 119.44,71.82 119.44,71.14 UC1.E37
  BOTTOM w0.102: 120.24,75.8 120.59,76.15 v2(120.59,77.96) RC419.1
XTAL24_IN_U42: length 4.9
  BOTTOM w0.102: YC3.3 147.69,82.45 CC334.1 148.59,80.85 RC421.2 148.61,80.22 v2(148.3,79.91) 147.39,79.91 RC417.2
XTAL24_IN_U42_CPU: length 12.3
  IN1 w0.089: v1(145.8,78.67) 145.8,77.99 141.26,73.45 140.36,73.45 v1(139.3,72.39)
  BOTTOM w0.076: v1(139.3,72.39) 139.3,72.38 UC1.E3
  BOTTOM w0.102: RC417.1 146.9,78.61 145.85,78.61 v1(145.8,78.67)
XTAL24_OUT_U22: length 3.4
  BOTTOM w0.102: v2(121.85,77.68) 121.85,77.86 121.45,78.25 RC420.2 RC295.1 RC46.1
XTAL24_OUT_U22_CPU: length 9.4
  BOTTOM w0.076: UC1.E35 120.02,71.47 120.02,74.71 120.96,75.65 120.96,75.8
  BOTTOM w0.102: RC420.1 122.23,79.03 122.23,77.14 v2(121.43,76.34) 120.96,75.87 120.96,75.8
XTAL24_OUT_U22_R: length 2.6
  BOTTOM w0.102: YC1.1 121.28,82.1 121.92,81.45 CC22.1 121.92,80.74 122.37,80.3 RC295.2
XTAL24_OUT_U42: length 1.9
  BOTTOM w0.102: RC421.1 146.81,80.85 RC422.1 146.44,80.49 RC418.2
XTAL24_OUT_U42_CPU: length 12.7
  IN1 w0.089: v1(145.04,78.2) 145.04,77.9 141.08,73.94 139.38,73.94 v1(137.6,72.16)
  BOTTOM w0.076: UC1.C7 137.4,72.35 v1(137.6,72.16)
  BOTTOM w0.102: v1(145.04,78.2) 145.04,78.49 145.64,79.09 146.4,79.09 RC418.1
XTAL24_OUT_U42_R: length 4.8
  BOTTOM w0.102: YC3.1 147.07,83.83 147.07,82.01 CC335.1 145.91,80.85 RC422.2
XTALI: length 8.9
  TOP w0.102: UL1.10 260.15,74.72 260.56,74.32 260.56,73.48 261.31,72.73 RL11.2 262.13,72.74 CL14.1 262.82,74.27 262.82,76.38 YL1.1
XTALO: length 5.1
  TOP w0.102: UL1.9 260.13,74.32 260.33,74.12 260.33,73.4 260.66,73.07 260.66,72.58 v2(261.15,72.09) 261.42,71.81 RL11.1 RL34.2
XTALO_R: length 2.6
  TOP w0.102: YL1.3 263.78,74.24 CL13.1 263.12,73.1 263.01,72.98 RL34.1
Z2805: length 3.9
  TOP w0.102: RL18.1 v2(268.1,84.95)
  TOP w0.508: RL18.1 268.72,86.03 v1(268.99,85.76)
  BOTTOM w0.508: v1(268.99,85.76) 268.72,86.03 TL1.24
Z2806: length 3.8
  TOP w0.102: RL16.1 v2(268.1,90.89)
  TOP w0.508: v1(269.03,91.94) 268.15,91.94 RL16.1
  BOTTOM w0.508: v1(269.03,91.94) 268.95,92.03 TL1.18
Z2807: length 3.8
  TOP w0.102: RL17.1 v2(268.1,87.83)
  TOP w0.508: v1(268.99,89.03) 268.95,89.07 RL17.1
  BOTTOM w0.508: TL1.21 v1(268.99,89.03)
Z2808: length 3.9
  TOP w0.102: RL15.1 268.1,95.12 267.49,95.73 v2(267.49,96.24)
  TOP w0.381: RL15.1 268.33,94.81 v1(268.83,94.81)
  BOTTOM w0.508: v1(268.83,94.81) 268.62,95.03 TL1.15
N04748: length 4.4
  TOP w0.102: v1(34.37,44.85) 34.58,44.85 v2(34.84,44.6)
  TOP w0.381: v1(34.37,44.85) 33.96,44.45 PC939.1
  BOTTOM w0.203: PU901.3 33.46,44.64 33.52,44.7 34.22,44.7 v1(34.37,44.85)
  BOTTOM w0.381: PR929.1 35.4,44.42 34.96,44.85 v1(34.37,44.85)
N43975: length 5.6
  TOP w0.102: QN1.5 250.13,16.34 249.99,16.2 249.72,16.2 249.48,16.44 QN1.6 248.91,16.68 RN2.2 248.44,15.11 249.69,13.86 v2(249.77,13.86)
N16399089:
  vias: v2(26.73,39.42)
N16400770: length 8.1
  TOP w0.102: v1(23.6,43) v2(23.02,43.58)
  IN2 w0.254: v1(27.03,39.01) 26.93,39.01 25.81,40.13 25.38,40.13 23.6,41.91 v1(23.6,43)
  BOTTOM w0.254: v1(23.6,43) 23.69,42.91 PR901.3 ; PR910.1 27.22,39.2 v1(27.03,39.01)
N16775301: length 5.9
  BOTTOM w0.102: PR206.1 57,63.45 v2(57,64.84)
  BOTTOM w0.254: PR204.2 54.8,62.97 PC208.2 PR206.1 56.52,62.6 56.19,62.26 56.19,61.94 55.88,61.63 PU200.16
N16775385: length 4.1
  BOTTOM w0.102: v2(59.26,55.99) 58.95,56.31 PC218.1
  BOTTOM w0.254: PU200.3 56.33,58 57.39,56.93 57.39,56.92 58.01,56.31 PC218.1
N16775433: length 3.5
  BOTTOM w0.102: PR202.2 v2(50.68,63.81)
  BOTTOM w0.508: PC204.1 49.46,62.28 PR202.2
N16775513: length 1.5
  BOTTOM w0.102: PR203.2 52.3,63.89 v2(52.51,64.09)
N16775517: length 1.5
  BOTTOM w0.102: v2(53.81,64.17) 53.7,64.05 PR203.1
N16776853: length 3.6
  TOP w0.254: v1(55.07,62.25) 55.07,62.2 55.48,61.79 55.96,61.79 v2(56.11,61.95) 56.44,62.28 PC207.1
  BOTTOM w0.254: v1(55.07,62.25) 55.05,62.23 55.05,61.69 54.98,61.63 PU200.14
N16783095: length 1.9
  BOTTOM w0.102: PR108.1 141.41,101.14 v2(141.57,100.97)
  BOTTOM w0.254: PC113.2 PR108.1
N16783126:
  vias: v2(140.83,103.96)
N16783134: length 2.3
  BOTTOM w0.102: v2(39.07,42.66) 38.79,42.93 PC127.2
  BOTTOM w0.254: PC127.2 38.24,43.16 PR117.1
N16784595: length 1.4
  BOTTOM w0.102: v2(139.08,111.12) 139.24,110.97 PC102.1
N16784799: length 4.3
  BOTTOM w0.102: v2(46.52,42.39) 46.71,42.57 46.71,44.71 PR111.2
  BOTTOM w0.508: PC114.1 46.17,45.24 PR111.2
N17023599: length 8.8
  TOP w0.102: v2(22.22,49.09) 22.22,49.4 22.66,49.84 PR939.2 22.98,50.08 23.17,49.89 PD905.3 24.24,49.89 24.57,50.21 24.57,51.86 24.97,52.27 27.88,52.27 PR950.1
N17023623: length 2.7
  TOP w0.102: PU903.1 26.1,50.07 PD905.1 25.63,51.22 PR961.1
N17023625: length 1.1
  TOP w0.102: PR946.1 28.88,48.02 PU903.4
N17023649: length 1.1
  TOP w0.102: PR942.2 26.11,49.42 PU903.2
N17023661: length 2.3
  TOP w0.102: PD905.2 23.52,50.98 PR941.2 22.66,51.53 v2(22.27,51.93)
N17185089: length 1.5
  TOP w0.254: PQ1204.5 35.78,71.46 35.09,72.15 PR1218.1
N17185092: length 9.9
  TOP w0.102: PR1218.2 33.96,72.15 v2(33.96,71.47)
  TOP w0.254: PR1214.2 39.48,72.19 39.48,71.55 39.58,71.45 39.58,70.74 38.75,69.91 36.72,69.91 36.14,70.49 35.38,70.49 35.13,70.75 PQ1204.6 34.28,72.01 34.28,72.26 PR1218.2
N17185371: length 3.5
  TOP w0.127: v2(33.77,69.9) 35.26,69.9 35.78,69.38 PQ1204.2
  TOP w0.254: PR1223.1 35.78,68.39 PQ1204.2
N17188383: length 2.4
  TOP w0.254: PQ1201.2 38.44,71.46 37.84,72.07 PR1216.1 38.73,72.36 PR1262.1
N17275961: length 5.1
  TOP w0.102: PU602.39 64.7,65.61 64.2,65.11 64.2,63.99 v2(64,63.79) 63.94,63.73 PR612.2 63.08,62.86 PR614.2
N17275988: length 4.2
  TOP w0.102: PU602.40 65.16,65.21 v1(64.62,64.66)
  BOTTOM w0.102: v2(62.62,66.06) 63.17,65.5 PR616.2 64.06,65.5 64.62,64.94 v1(64.62,64.66)
N17370862: length 14
  TOP w0.102: v2(59.26,87.68) 59.26,86.95 v1(59.39,86.82)
  TOP w0.254: v1(59.39,86.82) PR16.1 60.48,86.82 60.89,86.42 PQ5.1 ; PQ4.4 52.78,86.74 53.47,87.44 PR11.2 54,87.84 v1(54.28,87.55)
  IN2 w0.254: v1(54.28,87.55) 55.01,86.82 v1(59.39,86.82)
  BOTTOM w0.254: v1(54.28,87.55) 54.28,86.52 53.94,86.18 PC4.2
N17370885: length 4.1
  TOP w0.102: v2(66.67,87.18) 66.1,86.62 PR10.2
  TOP w0.254: PR10.2 PR15.1 65.02,85.64 64.84,85.46 PQ5.2
N17370921: length 5.7
  TOP w0.102: v2(66.68,85.39) 66.24,85.39 PR15.2
  TOP w0.254: PQ1.6 63.04,81.61 63.47,82.04 63.47,82.61 PR15.2
N17370927: length 2.3
  TOP w0.102: v2(59.19,85.13) 59.55,84.77 PQ7.1
  TOP w0.254: PQ7.1 60.17,85.77 PR16.2
N17370961: length 5
  TOP w0.102: v2(41.9,85.91) 42.38,86.39 PR6.2
  TOP w0.254: PR6.2 43.09,86.4 PL3.1 43.1,87.23 PR3.1 44.79,86.43 PQ2.1
N17370983: length 5.5
  TOP w0.254: PR5.1 48,86.68 PQ2.3 45.32,88.24 v2(44.96,88.24) 44.08,88.24 PR3.2
N17370995: length 4.3
  TOP w0.102: PR6.1 v2(43.08,84.21) PQ3.2 44.06,83.2 PR8.2
N17370999: length 3
  TOP w0.254: PQ3.1 46.45,82.55 PR7.2 47.06,83.68 v1(46.87,83.86) PQ2.2
N17371029: length 5.4
  TOP w0.508: v1(49.28,91.64) 49.79,91.13 PQ9.4
  BOTTOM w0.102: PR18.1 48.74,95.27 v2(48.35,95.27)
  BOTTOM w0.508: v1(49.28,91.64) 49.28,92.44 PC6.1 49.44,92.69 PR12.2 49.43,93.7 PR18.1
N17371043: length 2.6
  BOTTOM w0.254: PQ6.1 52.19,94.94 v2(51.6,94.94) 50.93,94.94 50.57,94.58 PR18.2
N17371125: length 2.3
  TOP w0.102: v2(59.27,80.64) PR20.1
  TOP w0.254: PR20.1 59.27,82.62 PQ7.2
N17371182: length 6.2
  BOTTOM w0.102: PQ6.2 53.3,92.16 PR23.2 52.62,91.64 52.32,91.94 51.36,91.94 50.92,91.51 PR30.1 50.75,91.51 v2(49,89.76)
N17371184: length 2.3
  BOTTOM w0.102: PR23.1 51.71,90.97 PU1.4 50.18,90.45 v2(50.17,90.46)
N17371196: length 2.3
  BOTTOM w0.102: v2(53.6,88.81) 53.35,88.55 PU1.1 52.49,87.6 PR21.2
N17371202: length 3.5
  BOTTOM w0.127: PU1.2 51.84,88.88 51.5,89.21 50.33,89.21 v2(50.03,88.91)
  BOTTOM w0.254: PU1.2 51.84,87.55 PR22.2
N17372063: length 2.9
  TOP w0.102: v2(66.64,84.07) 66.64,84.04 66.57,83.97 PR17.2
  TOP w0.305: PQ1.3 65.17,82.91 65.38,83.12 PR19.2 66.55,83.12 PR17.2
N17372074: length 3.5
  TOP w0.102: v2(62.56,80.34) 62.36,80.54 62.36,81.77 62.84,82.25 PQ1.5 61.98,83.11 PR25.1
N17372283: length 2
  TOP w0.102: v2(66.68,82.1) 66.58,82.2 PR19.1
  TOP w0.305: PQ1.2 65.66,82.26 PR19.1
N17400451: length 4.2
  TOP w0.102: PR515.2 v2(213.38,13.65)
  TOP w0.254: PU503.3 215.33,12.9 PR516.1 215.24,13.64 PC515.2 215.23,13.65 PR515.2
N17494434: length 10.9
  TOP w0.102: v2(54.79,72.42) PD1205.1
  TOP w0.381: PU1201.5 56.36,73.41 55.96,73.81 PD1205.1 54.32,73.81 54.03,73.51 PC1211.1 53.53,74.38 PR1246.1 53.54,75.21 PR1238.1 52.64,75.24 PR1239.2 51.06,75.24 PQ1212.1 51.78,76.23 PR1255.2
N20151644: length 7.8
  TOP w0.102: v1(24.19,43) 24.19,42.72 v2(23.96,42.49)
  IN2 w0.254: v1(24.19,43) 24.19,41.96 25.63,40.51 26.73,40.51 27.02,40.22 v1(27.02,39.85)
  BOTTOM w0.254: v1(27.02,39.85) 27.58,40.41 PR909.1 ; v1(24.19,43) 24.16,43 24.13,43.02 24.13,43.16 23.69,43.61 PR901.2
N27077001: length 33.5
  TOP w0.102: v2(37.51,45.53) v1(36.68,45.53)
  TOP w0.254: v1(37.44,25.95) 37.39,25.95 37,25.56 PR917.2
  IN1 w0.254: v1(37.44,25.95) 37.57,25.83 41.71,25.83 42.09,26.21 42.09,26.34 43.49,27.73 43.84,27.73 44.89,28.78 44.89,37.59 43.67,38.81 42.06,38.81 39.7,41.16 39.7,41.98 38.41,43.27 38.41,44.84 37.52,45.73 36.89,45.73 v1(36.68,45.53)
  BOTTOM w0.254: v1(36.68,45.53) 36.97,45.53 PR937.2
N28424999: length 11.5
  TOP w0.102: v1(97.48,51.05) 97.48,50.19 96.8,49.5 96.8,48.03 94.34,45.57 T113.1
  BOTTOM w0.076: v1(97.48,51.05) 97.65,51.22 97.65,51.5 98.82,52.67 99.86,52.67 UC1.AW71
N28425002: length 11.1
  TOP w0.102: v1(98.02,50.79) 98.02,50.23 97.03,49.24 97.03,47.93 95.58,46.48 95.58,44.67 T114.1
  BOTTOM w0.076: v1(98.02,50.79) 97.89,50.92 97.89,51.51 98.1,51.71 98.24,51.85 98.87,52.49 100.41,52.49 UC1.AW70
N28489601: length 7.7
  TOP w0.102: v1(293.17,91.49) v3(293.17,92.21)
  BOTTOM w0.102: RC222.1 289.15,93.25 290.66,91.74 292.92,91.74 v1(293.17,91.49) 293.44,91.22 SW1.2
N28769860: length 3.1
  TOP w0.102: v1(174.29,52.98) v2(173.78,52.98)
  BOTTOM w0.254: PU401.5 174.47,52.77 174.29,52.95 v1(174.29,52.98) PR421.2 174.28,53.65 174.28,54.5 PR422.1
N28771761: length 4
  TOP w0.102: PR404.2 174.86,46.51 v2(175.35,46.02)
  TOP w0.508: v1(175.47,48.02) 175.68,47.82 PR425.2 174.86,47.33 PR404.2
  BOTTOM w0.254: PU401.14 v1(175.47,48.02)
N28771835: length 3.9
  TOP w0.254: v1(172.55,96.64) 172.5,96.59 PR426.2 PR410.2
  BOTTOM w0.102: v2(172.58,96) 172.55,96.03 v1(172.55,96.64)
  BOTTOM w0.254: PU402.14 172.95,96.95 172.64,96.64 v1(172.55,96.64)
N28810563: length 1.8
  TOP w0.102: CZ110.1 232.69,43.66 232.69,42.74 232.61,42.66 UZ2.10
N28811129: length 2.3
  TOP w0.203: CZ114.1 172.83,62.3 v2(173.56,62.3) 173.59,62.33 174.31,62.33 174.44,62.2 UZ3.10
N28856399: length 12.9
  TOP w0.102: v1(96.94,50.84) 96.94,49.97 96.57,49.6 96.57,48.26 93.12,44.81 T16.1
  BOTTOM w0.076: UC1.BA70 100.75,51.5 100.75,50.89 100.57,50.7 98.63,50.7 98.34,50.41 97.37,50.41 v1(96.94,50.84)
N28856402: length 10.7
  TOP w0.102: v1(98.83,51.13) 98.83,50.11 97.26,48.53 97.26,47.78 96.85,47.38 T17.1
  BOTTOM w0.076: v1(98.83,51.13) 98.83,51.73 99.08,51.98 99.69,51.98 99.85,51.83 100.25,51.83 100.38,51.96 100.95,51.96 UC1.BA68
N28857231: length 15.2
  TOP w0.102: T12.1 91.14,45.39 93.02,45.39 96.01,48.37 v1(96.01,50.11)
  BOTTOM w0.076: UC1.BB68 101.52,51.02 100.87,50.37 98.77,50.37 98.08,49.68 96.75,49.68
  BOTTOM w0.102: v1(96.01,50.11) 96.01,50.11 96.01,50.11 96.44,49.68 96.75,49.68
N28857234: length 13.6
  TOP w0.102: v1(96.43,50.51) 96.43,49.79 96.33,49.68 96.33,48.37 93.1,45.13 92.26,45.13 T13.1
  BOTTOM w0.076: 96.75,50.2 96.75,50.1 96.8,50.05 98.21,50.05 98.7,50.54 100.63,50.54 101.08,50.99 UC1.BB69
  BOTTOM w0.102: 96.75,50.2 v1(96.43,50.51)
N28857237: length 1.2
  TOP w0.102: v1(133.71,58.86) 133.3,58.86 T14.1
  BOTTOM w0.076: UC1.AK13 133.32,58.46 v1(133.71,58.86)
N28857240: length 1.1
  TOP w0.102: v1(134.28,58.83) 134.79,58.83 T15.1
  BOTTOM w0.076: UC1.AK12 133.97,58.53 v1(134.28,58.83)
N28861827: length 19.6
  BOTTOM w0.076: UC1.C64 104.18,72.8 104.18,73.88 103.95,74.1 103.95,74.71 102.89,75.77 102.89,76.52 102.87,76.53 102.87,76.55 102.04,77.39 102.04,77.85
  BOTTOM w0.102: RC120.1 108.18,87.42 108.18,85.85 107.95,85.62 106.3,85.62 103.69,83 103.69,81.71 v2(103.2,81.23) 102.59,80.62 102.59,79.35 102.04,78.79 102.04,77.85
N28938912: length 0.9
  BOTTOM w0.102: RC29.2 CC8.1
N28938914: length 0.9
  BOTTOM w0.102: RC28.2 CC7.1
N29708559: length 6.7
  BOTTOM w0.076: UC1.AY4 139,51.85 139,51.56 139.21,51.35 140.29,51.35 140.68,50.95 141.23,50.95 141.9,50.28 141.93,50.28
  BOTTOM w0.102: 141.93,50.28 T126.1
N29708561: length 5.7
  BOTTOM w0.076: 141.74,50.08 141.11,50.7 139.81,50.7 UC1.BB3
  BOTTOM w0.102: 141.74,50.08 142.94,48.88 T127.1
N29708599: length 10.1
  BOTTOM w0.076: UC1.AU5 138.28,54.47 138.28,54.93 138.5,55.15 138.54,55.19 140.68,55.19 140.94,55.45 142.84,55.45 142.97,55.32
  BOTTOM w0.102: 142.97,55.32 144.43,55.32 144.91,54.83 T128.1
N29708601: length 7.8
  BOTTOM w0.076: 143.02,55.55 142.95,55.61 140.97,55.61 140.74,55.85 138.53,55.85 138.3,55.62 138.3,55.35 137.94,54.98 UC1.AT5
  BOTTOM w0.102: T129.1 144.76,55.55 143.02,55.55
N29708639: length 13.8
  TOP w0.102: v1(142.95,47.6) 143.13,47.42 143.13,46.9 143.69,46.34 144.37,46.34 145.9,44.81 145.9,43.09 T130.1
  BOTTOM w0.076: 141.09,50.09 140.8,50.37 138.72,50.37 UC1.BB5
  BOTTOM w0.102: v1(142.95,47.6) 142.93,47.62 142.93,48.25 141.09,50.09
N30342894: length 2.6
  TOP w0.102: v2(21.09,54.66) 21.09,54.02 RV18.2 20.58,52.37 QV4.2
N31877076: length 4.5
  TOP w0.102: LV1.1 67.43,95.42 v1(67.25,95.25)
  BOTTOM w0.102: v1(67.25,95.25) 67.35,95.35 JEDP1.21 70.44,95.35 v2(70.77,95.68)
N32590572: length 2.4
  TOP w0.203: CZ117.1 210.76,32.62 v2(211.71,32.62) 212.23,33.14 UZ4.12
N32592963: length 2.2
  TOP w0.203: UZ4.10 v2(211.74,33.94) 210.84,33.94 CZ118.1
N32594166: length 2.5
  TOP w0.102: CZ109.1 231.3,43.42 v2(231.56,43.15) 231.76,42.95 231.76,42.34 231.81,42.29 UZ2.12
N32817808: length 4.2
  TOP w0.102: CZ113.1 172.55,61.29 171.2,61.29 v2(171.1,61.18)
  TOP w0.203: UZ3.12 173.68,61.4 CZ113.1
N32818355: length 4.2
  TOP w0.102: v2(178.71,59.88) RZ64.2
  TOP w0.203: UZ3.3 177.93,61.4 178.13,61.2 RZ64.2 RZ65.2
N32819772: length 3.1
  TOP w0.102: UZ8.6 235.91,35.11 235.73,34.93 234.79,34.93 CZ121.1 233.86,35.23 v2(233.55,35.54)
N32875032: length 4.3
  TOP w0.102: CZ130.1 240.59,11.58 241.2,12.19 v2(241.98,12.19) 242.1,12.19 243.15,13.23 UZ23.6
N33199734: length 6.8
  TOP w0.102: v1(92.67,14.18) 92.67,14.49 92.03,15.13 92.03,17.79 T50.1
  BOTTOM w0.102: JDIMM1.162 92.43,13.08 92.67,13.33 v1(92.67,14.18)
N33199744: length 5.4
  TOP w0.102: v1(94.01,18.54) 93.86,18.54 93.53,18.21 93.53,16.68 94.4,15.81 T51.1
  BOTTOM w0.102: JDIMM1.165 93.18,19 93.37,18.81 93.69,18.81 93.95,18.54 v1(94.01,18.54)
N33290988: length 2
  TOP w0.102: RD31.1 CD62.2 v2(46.64,15.74)
N33298469: length 2.4
  TOP w0.102: T54.1 175.04,13.26 v1(174.92,13.26)
  BOTTOM w0.102: v1(174.92,13.26) 174.92,13.06 174.43,12.57 JDIMM2.162
N33298471: length 5
  TOP w0.102: v1(174.92,15.88) 174.92,15.06 T55.1
  BOTTOM w0.102: JDIMM2.165 175.18,16.31 174.92,16.06 v1(174.92,15.88)
N33612393: length 3.3
  TOP w0.102: RD18.1 94.71,12.68 94.71,11.84 CD31.2 94.22,10.74 v2(93.84,10.36)
N35551558: length 6.1
  TOP w0.102: v2(37.25,62.1) 37.47,61.88 38.22,61.88 38.65,62.32 39.31,62.32 39.53,62.53 PQ1206.4
  TOP w0.508: PQ1206.4 39.06,63.47 PC1210.1 PR1228.2 PR1229.1
N35551572: length 4.7
  TOP w0.102: PC1214.1 57.25,68.5 v2(57.25,68)
  TOP w0.203: PC1214.1 58.28,69.52 PR1243.2 59.59,71.66 PQ1209.5
N35551576: length 2.9
  TOP w0.102: v2(62.51,71.29) 62.15,71.66 PQ1209.2
  TOP w0.254: PQ1209.2 PQ1209.3 61.61,73.44 PR1236.1
N35551581: length 23.7
  TOP w0.254: PQ1209.6 59.59,71.01 59,70.42 59,68.27 57.83,67.1 v2(54.97,67.1) 53.78,67.1 v1(53.23,66.56) ; v1(40.02,66.56) 39.97,66.5 PR1229.2
  IN1 w0.254: v1(40.02,66.56) 40.19,66.39 53.06,66.39 v1(53.23,66.56)
N35551584: length 10.7
  TOP w0.102: v2(53.51,77.16) PR1238.2
  TOP w0.381: PR1240.2 57.4,70.3 PR1243.1 57.37,70.35 PC1213.1 57.66,71.51 PU1201.7 57.66,73.89 57.08,74.47 56.52,74.47 PD1205.2 53.56,76.21 PR1238.2
N35551592: length 5.5
  TOP w0.102: v2(55.97,68.49) 55.97,69.33 55.67,69.63 PR1247.1
  TOP w0.381: PU1201.6 57.01,72.12 56.52,71.62 PR1237.2 55.69,71.23 PC1212.1 55.67,70.35 PR1247.1
N35551616: length 4.5
  TOP w0.102: PR1248.1 PR1250.1 49.92,72.56 50.28,72.91 PQ1212.2 49.53,73.47 PR1249.1 49.01,73.4 49.01,74.02 v2(49.17,74.18)
N35551696: length 12
  TOP w0.406: v1(47.12,60.43) 47.17,60.49 47.95,60.49 48,60.43 PQ1213.4
  BOTTOM w0.508: v1(47.12,60.43) 46.22,60.43 42.89,63.76 v2(42.89,65.45) 42.89,66.05 v1(40.82,68.12)
N35551713: length 1.2
  TOP w0.254: PR1212.2 39.09,68.62 PQ1201.6
N35551783: length 24.9
  TOP w0.356: v1(38.03,70.53) 37.57,70.53 37.09,71.01 37.09,71.43 36.73,71.79 36.38,71.79 35.96,72.21 PR1213.1 35.96,73.21 PR1207.2 36.84,73.22 PC1203.2
  TOP w0.432: v1(49.08,67.36) 49.47,66.96 PQ1202.4
  TOP w0.508: v1(53.27,67.74) 52.42,68.59 PQ1203.1
  IN1 w0.508: v1(38.03,70.53) 38.03,70.15 38.79,69.39 40.69,69.39 41.05,69.74 45.04,69.74 47.43,67.36 v1(49.08,67.36) 52.28,67.36 52.66,67.74 v1(53.27,67.74)
  BOTTOM w0.102: v1(38.03,70.53) v2(38.03,71.24)
N35551785: length 2.9
  TOP w0.254: PQ1203.2 53.33,71.61 PR1209.1 51.71,72.39 PR1202.2
N35551806: length 26.3
  TOP w0.254: v1(36.11,69.83) 36.43,69.52 PQ1204.3 ; PR1209.2 54.14,71.71 54.14,70.05 53.66,69.57 v1(53.06,69.57)
  IN1 w0.254: v1(53.06,69.57) 51.36,67.86 47.81,67.86 44.7,70.98 43.6,70.98 42.9,70.28 40.57,70.28 40.23,70.62 39.39,70.62 38.89,71.12 37.65,71.12 37.38,70.85 37.38,70.18 37.04,69.83 v1(36.11,69.83)
  BOTTOM w0.102: v2(36.3,70.92) 36.11,70.73 v1(36.11,69.83)
N35551822: length 1.6
  TOP w0.254: PR1213.2 36.87,72.3 37.79,71.38 PQ1201.3
N36255106: length 1.1
  TOP w0.254: PQ1201.5 38.44,68.38 PR1220.2
N36626863: length 1.4
  TOP w0.102: UT7.3 v3(17.5,68.44)
N36827741: length 32.7
  TOP w0.102: UZ34.4 156.6,30.43 155.63,31.41 v2(144.42,31.41) 135.01,31.41 132.74,33.68 130.97,33.68 130.64,34.01 129.57,34.01 129.35,33.79 RZ120.2 128.91,33.55 128.22,34.24 UZ26.4
N38749366: length 3.5
  TOP w0.508: RV5.2 v2(78.29,97.58) 78.29,96.75 QV2.1
N38749387: length 2.5
  TOP w0.102: RV400.1 70.04,107.36 RV6.1 70.8,107.84 QV7.1
N38749389: length 6
  TOP w0.102: RV400.2 69.33,107.96 v1(69.02,107.96) QV8.2 67.89,108.39 65.83,110.45 CV635.1
N38798736: length 7.9
  TOP w0.076: UT5.F10 26.94,59.56 26.94,59.16
  TOP w0.102: v2(25.71,53.16) RT97.2 RT98.1 RT99.1 26.52,54.96 26.65,55.09 26.65,57.42 27.17,57.94 27.17,58.94 26.94,59.16
N38798744: length 11.4
  TOP w0.076: UT5.G4 26.73,62.85 26.73,63.24 v1(26.83,63.33)
  TOP w0.127: v1(33.99,66.7) 34.01,66.67 RT85.1
  IN4 w0.091: v1(26.83,63.33) 26.83,63.48 27.4,64.05 30.17,64.05 33.02,66.91 33.77,66.91 v1(33.99,66.7)
  BOTTOM w0.102: v1(33.99,66.7) 33.93,66.76 33.93,66.9 v2(34.27,67.24)
N38798745: length 10.2
  TOP w0.076: UT5.F4 27.19,62.84 27.41,63.05 v1(27.41,63.33)
  TOP w0.102: v1(33.2,64.63) 33.27,64.63 33.33,64.56 33.58,64.56 33.66,64.49 RT84.1
  IN4 w0.091: v1(33.2,64.63) 33.2,64.69 32.76,65.13 31.55,65.13 30.22,63.8 27.6,63.8 27.41,63.61 v1(27.41,63.33)
  BOTTOM w0.102: v2(34.64,65.35) 34.64,65.24 34.03,64.63 v1(33.2,64.63)
N38798858: length 10.2
  TOP w0.076: 27.13,65.3 27.13,64.79 27.19,64.73 UT5.F1
  TOP w0.102: v1(33.85,69.01) 34.01,68.84 RT63.1 ; v1(27.33,65.71) 27.13,65.5 27.13,65.3
  IN4 w0.091: v1(33.85,69.01) 33.34,68.5 32.69,68.5 31.33,67.13 29.23,67.13 27.8,65.71 v1(27.33,65.71)
N38798904: length 5
  TOP w0.076: UT5.K10 25.07,59.81 24.82,59.56 24.54,59.56 24.02,59.04 24.02,58.89
  TOP w0.127: 24.02,58.89 24.02,58.17 v2(23.91,58.07) 23.91,57.91 23.51,57.51 23.51,57.06 22.69,56.23 RT105.1
N38798905: length 6
  TOP w0.076: UT5.K9 25.06,60.31 24.81,60.06 24.19,60.06 23.29,59.16 23.29,58.89
  TOP w0.102: v2(20.6,57.58) 22.1,57.58 RT104.1 22.64,58.01 23.29,58.67 23.29,58.89
N38798908: length 4.6
  TOP w0.102: RT103.1 23.17,55.47 23.17,56.23 23.75,56.82 23.75,57.41 24.36,58.02 24.36,58.98 24.69,59.31
N38798948: length 1.2
  TOP w0.102: T220.1 34.42,65.88 RT85.2
N38798949: length 2.8
  TOP w0.102: RT84.2 35.49,65.05 35.49,66.57 T219.1
N38799002: length 4.7
  TOP w0.076: v1(25.67,61.05) 25.93,61.31 UT5.H7
  TOP w0.127: CT87.1 22.96,59.84 23.19,60.07 v1(23.19,60.16)
  BOTTOM w0.127: v1(25.67,61.05) 24.33,59.71 v2(23.84,59.71) 23.55,59.71 23.19,60.07 v1(23.19,60.16)
N38799008: length 11.5
  TOP w0.076: v1(28.62,62.06) 28.37,61.81 UT5.D6
  TOP w0.102: v2(33.79,61.64) 33.79,62.43 RT101.1 34.5,63.14 35.45,63.14 35.55,63.04 v1(35.55,62.61)
  IN4 w0.089: v1(35.55,62.61) 34.46,61.51 29.52,61.51 28.98,62.06 v1(28.62,62.06)
N39067212: length 18.7
  TOP w0.076: 257.23,53.69 258.52,53.69 258.88,53.33 UE1.B1
  TOP w0.102: 257.23,53.69 255.02,53.69 254.74,53.97 254.74,55.6 255.07,55.93 255.07,56.82 254.82,57.07 252.47,57.07 249.93,54.53 248.59,54.53 v2(248.37,54.3) 248.37,53.49 RE58.1 RE57.1
N39067288: length 3.8
  TOP w0.076: UE1.G2 259.91,49.33 259.58,49.01 259.11,49.01 259.09,49.02 259.09,49.02 258.44,49.02 258.41,48.99 v2(257.47,48.99) 257.36,48.99 257.04,48.68 RE318.1
N39070459: length 4.3
  BOTTOM w0.102: v2(110.25,87.91) 109.99,87.91 109.01,88.89 QE11.3 107.89,89.01 107.75,88.87 RE90.2 RE70.1
N39070470: length 2.9
  BOTTOM w0.102: v2(107.19,90.85) 107.02,91.02 QE4.2 105.86,91.02 106.56,90.32 RE70.2
N39154673: length 2.6
  TOP w0.102: RV123.2 287.63,47.35 v2(287.02,47.35) 286.76,47.35 286.3,47.81 UV6.10
N39154676: length 3
  TOP w0.102: UV6.9 285.82,47.17 286.97,46.02 v2(287.08,46.02) RV124.2
N39317125: length 3.7
  BOTTOM w0.102: PR424.1 v2(172.91,103.57)
  BOTTOM w0.254: PR424.1 171.94,103.57 PR423.1 171.94,102.54 171.56,102.16 171.56,101.8 171.95,101.41 PU402.5
N39469798: length 5.3
  BOTTOM w0.102: v2(83.77,85.15) 83.77,84.65 84.39,84.04 85.41,84.04 85.73,84.36 PR679.1
  BOTTOM w0.254: PR679.1 86.17,84.5 86.48,84.2 87.1,84.2 87.36,84.46 PU614.7
N39469818: length 1.9
  TOP w0.102: PR630.2 70.04,72.49 v2(70.16,72.37)
  TOP w0.254: PC631.1 69.13,73.33 69.12,73.31 69.12,72.5 PR630.2
N39469863: length 5.1
  TOP w0.102: v2(63.83,70.96) 64.14,70.96 PC632.1
  TOP w0.203: PU602.28 67.37,70.05 66.92,70.5 66.92,70.67 66.68,70.91 66.27,70.91 PR636.1 64.75,71.56 PC632.1
N39469972: length 3.6
  TOP w0.102: PU602.38 64.49,66.01 63.97,65.49 v2(63.97,65.43) 63.97,65.08 63.49,64.6 PR678.2
N39469996: length 5.5
  BOTTOM w0.102: v2(84.42,89.47) 84.88,89.93 86.59,89.93 86.86,89.66 PC611.2
  BOTTOM w0.254: PU614.2 87.36,87.85 87.28,87.93
  BOTTOM w0.508: 87.28,87.93 87.28,88.65 PC611.2
