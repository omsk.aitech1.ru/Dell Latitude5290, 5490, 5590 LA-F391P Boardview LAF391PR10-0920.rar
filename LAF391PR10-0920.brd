# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_SPI_CS#1_R1: length 8.8
  TOP w0.102: v2(161.88,65.41) 162.35,65.88 v1(162.42,65.88)
  BOTTOM w0.102: RC42.1 160.7,65.88 v1(162.42,65.88) 163.07,66.53 165.47,66.53 RC32.1 166.45,67.51 167.28,67.51 JSPI1.1
PCH_SPI_CS#1_R2: length 11.7
  BOTTOM w0.102: RC42.2 159.58,64.6 157.45,62.48 v3(157.15,62.48) 156.66,61.99 156.66,58.11 156.56,58.01 156.54,58.01 156.54,58 155.61,57.06 UC6.1
PCH_SPI_CS#2: length 88.7
  TOP w0.102: RZ61.1 162.79,66.4 v1(164.2,67.81)
  IN1 w0.089: v1(168.46,37.89) 168.05,37.49 162.59,37.49 158.21,41.87 155.39,41.87 152.96,44.29 147.32,44.29 145.62,46 145.62,48 145.29,48.33 145.29,52.01 143.97,53.33 v1(143.97,53.43)
  IN2 w0.122: v1(164.2,67.81) 165.73,66.28 165.73,60.73 166.09,60.37 166.09,58.73 167.38,57.45 167.38,53.74 168.18,52.94 168.18,49.18 169,48.37 169,45.62 168.61,45.23 168.61,43.45 168.49,43.33 167.94,43.33 167.82,43.21 167.82,42.8 167.94,42.68 168.49,42.68 168.61,42.56 168.61,42.16 168.49,42.03 167.84,42.03 167.72,41.91 167.72,41.46 167.84,41.33 168.49,41.33 168.61,41.21 168.61,40.73 168.47,40.59 165.4,40.59 165.28,40.46 165.28,40.09 165.4,39.96 168.34,39.96 168.46,39.84 168.46,39.49 168.34,39.37 165.42,39.37 165.27,39.22 165.27,38.89 165.39,38.77 168.34,38.77 168.46,38.65 v1(168.46,37.89)
  BOTTOM w0.102: UC1.AU1 142.42,54.23 142.68,53.97 143.45,53.97 143.97,53.45 v1(143.97,53.43)
PCH_SPI_CS#2_R: length 5.5
  TOP w0.102: RZ61.2 160.7,65.88 159.63,64.82 159.63,64.16 v2(159.24,63.77) 158.68,63.22 158.22,63.22 157.85,62.84 UZ12.20
PCH_SPI_D0: length 90
  TOP w0.102: RC10.2 161.79,45.61 v1(161.61,45.61) 161.31,45.61 v3(160.99,45.93)
  IN2 w0.122: v1(162.44,65.25) 162.16,65.25 161.57,64.66 161.57,63.45 161.84,63.18 161.84,61.92 161.8,61.88 161.8,59.08 162.78,58.1 162.78,49.77 163.01,49.54 164.86,49.54 164.98,49.42 164.98,48.97 164.88,48.87 163.4,48.87 163.21,48.68 163.21,45.74 163.01,45.54 162.47,45.54 162.28,45.72 162.28,48.64 162.16,48.76 157.8,48.76 157.68,48.64 157.68,48.3 157.8,48.18 161.13,48.18 161.26,48.06 161.26,47.69 161.13,47.57 158.84,47.57 158.75,47.48 158.75,47.11 158.87,46.99 161.67,46.99 161.79,46.86 161.79,46.51 161.67,46.39 160.25,46.39 160.11,46.25 160.11,45.95 160.25,45.81 161.42,45.81 v1(161.61,45.61)
  BOTTOM w0.076: UC1.AV3 138.98,52.9 139.19,52.69 140.01,52.69 140.27,52.43 140.27,51.97 140.42,51.82 141.34,51.82 142.38,50.78 142.44,50.78
  BOTTOM w0.102: 142.44,50.78 143.1,50.78 143.55,51.24 143.88,51.24 144.61,50.52 144.61,47.79 147.83,44.56 158.5,44.56 158.61,44.66 158.61,45.53 158.71,45.63 158.91,45.63 159.01,45.53 159.01,44.66 159.11,44.56 160.65,44.56 160.75,44.66 160.75,45.2 160.85,45.3 161.05,45.3 161.15,45.2 161.15,44.66 161.26,44.56 161.48,44.56 161.61,44.69 v1(161.61,45.61) ; JSPI1.4 168.83,67.03 168.14,66.34 168.05,66.34 166.98,65.27 166.98,65.12 RC33.2 166.43,64.56 165.98,64.56 165.68,64.87 165.67,64.87 165.11,65.43 162.61,65.43 v1(162.44,65.25)
PCH_SPI_D0_0_R: length 12.8
  BOTTOM w0.102: RPC1.7 v2(167.07,53.93) 167.07,54.09 166.94,54.21 166.55,54.21 166.43,54.09 166.43,53.39 166.3,53.26 166.04,53.26 165.92,53.39 165.92,54.59 166.04,54.72 166.93,54.72 167.07,54.86 167.07,55.11 166.9,55.28 164.79,55.28 164.65,55.14 164.65,53.16 164.75,53.06 165.16,53.06 165.26,53.17 UC5.5
PCH_SPI_D0_1_R: length 13.1
  BOTTOM w0.102: RC409.2 166.45,48.51 166.45,47.57 165.9,47.02 v1(163.68,47.02) 158.02,47.02 157.92,47.13 157.92,47.67 158.04,47.8 159.17,47.8 159.42,48.05 UC6.5
PCH_SPI_D0_2_R: length 13.3
  TOP w0.102: RZ59.2 160.19,67.72 161.93,67.72 162.07,67.58 162.07,67.01 161.95,66.9 160.34,66.9 160.15,66.71 160.15,66.04 160.02,65.91 159.85,65.91 159.74,66.01 159.74,66.39 159.64,66.49 159.4,66.49 159.28,66.37 v2(159.28,66.16) 159.28,65.93 159.17,65.83 158.72,65.83 158.62,65.73 158.62,65.49 158.72,65.39 159.06,65.39 159.16,65.28 159.16,64.93 159,64.77 159,64.01 158.44,63.45 158.13,63.45 157.53,62.85 157.45,62.85 157.35,62.74 UZ12.21
PCH_SPI_D0_R1: length 30.2
  TOP w0.102: v1(165.93,50.21) v3(166.37,50.65) ; v1(161.27,68.27) 161.21,68.21 RZ59.1
  IN2 w0.122: v1(165.93,50.21) 165.93,52.31 165.79,52.45 165.37,52.87 165.37,56.57 164.43,57.51 164.43,58.02 164.15,58.3 164.15,59.5 163.7,59.95 163.7,61.1 163.74,61.14 163.74,65.29 v1(163.12,65.91) 161.92,67.12 161.92,67.62 v1(161.27,68.27)
  BOTTOM w0.102: v1(163.12,65.91) 165.33,65.91 RC33.1 166.14,65.55 166.57,65.55 167.88,66.85 167.94,66.85 JSPI1.3 ; RC409.1 165.93,49.95 v1(165.93,50.21) 166.26,50.21 166.65,50.61 166.93,50.61 167.07,50.74 RPC1.2
PCH_SPI_D1: length 91.7
  TOP w0.102: v3(169.05,66.1) v1(169.05,65.3)
  IN1 w0.089: v1(141.28,52.81) 141.23,52.77 141.23,50.14 144.2,47.16 144.2,45.08 146.56,42.72 152.54,42.72 154.85,40.41 157.59,40.41 161.98,36.01 176.61,36.01 v1(178.19,37.59)
  IN2 w0.122: v1(178.19,37.59) 178.19,37.82 180.78,40.41 180.78,42.47 183.1,44.79 183.1,54.48 178.83,58.75 178.83,60.11 177.82,61.12 177.22,61.12 173.04,65.3 v1(169.05,65.3)
  BOTTOM w0.076: UC1.AW3 139.59,53.24 140.56,53.24 140.99,52.81 v1(141.28,52.81)
  BOTTOM w0.102: JSPI1.6 168.99,65.81 168.81,65.81 168.45,65.45 RC34.2 168.56,64.81 v1(169.05,65.3)
PCH_SPI_D1_0_R: length 15.5
  BOTTOM w0.102: RPC1.8 167.57,55.29 v3(166.91,55.95) 166.53,56.33 163.33,56.33 162.59,57.07 161.09,57.07 160.79,57.37 160.79,58.2 162.72,60.14 UC5.2
PCH_SPI_D1_1_R: length 13
  BOTTOM w0.102: RC410.2 158.83,62.58 158.25,62.58 158.08,62.42 158.08,61.02 158.25,60.85 159.33,60.85 159.43,60.75 159.43,60.4 159.33,60.3 158.32,60.3 158.18,60.16 v3(158.18,59.93) 158.18,59.42 158.28,59.32 159.35,59.32 159.49,59.18 159.49,58.85 159.35,58.71 158.34,58.71 158.17,58.54 158.17,57.73 157.98,57.54 157.01,57.54 156.88,57.41 UC6.2
PCH_SPI_D1_2_R: length 12.7
  TOP w0.102: RZ58.2 152.2,63.24 152.2,62.96 152.3,62.86 153.01,62.86 153.11,62.76 153.11,62.1 153.21,62 153.41,62 153.52,62.1 v2(153.52,62.52) 153.52,62.94 153.62,63.04 153.95,63.04 154.08,62.92 154.08,61.85 154.18,61.74 154.38,61.74 154.48,61.85 154.48,63.85 154.58,63.95 154.79,63.95 154.89,63.85 154.89,62 154.99,61.9 155.19,61.9 155.3,62 155.3,62.81 155.4,62.91 155.58,62.91 155.85,62.64 UZ12.24
PCH_SPI_D1_R1: length 47.7
  TOP w0.102: RZ58.1 153.83,63.96 153.88,63.96 154.17,64.25 v1(154.17,64.69) ; v1(166.76,50.17) 166.76,51.43 v3(167.41,52.08)
  IN1 w0.089: v1(154.17,64.69) 154.17,66.42 156.15,68.4 158.28,68.4 158.88,67.79 158.88,67.16 161.2,64.84 164.13,64.84 v1(164.58,64.39)
  IN2 w0.122: v1(164.58,64.39) 164.24,64.04 164.24,60.93 164.2,60.89 164.2,60.16 164.65,59.71 164.65,58.51 164.93,58.23 164.93,57.72 165.87,56.78 165.87,53.08 166.67,52.29 166.67,50.27 v1(166.76,50.17)
  BOTTOM w0.102: RC410.1 160.55,64.78 162.87,64.78 163.26,64.39 v1(164.58,64.39) 165.48,64.39 165.78,64.08 166.74,64.08 167.7,65.04 RC34.1 168.58,66.21 168.7,66.21 JSPI1.5 ; v1(166.76,50.17) 167.06,50.17 167.57,50.68 RPC1.1
PCH_SPI_D2: length 83.8
  TOP w0.102: v1(166.86,47.93) 166.86,48.08 v3(167.39,48.61)
  IN2 w0.122: v1(165.47,57.99) 165.47,57.89 166.37,56.99 166.37,53.32 166.65,53.05 167.18,52.52 167.18,48.42 166.86,48.1 v1(166.86,47.93)
  BOTTOM w0.076: 142.44,51.27 142.18,51.27 141,52.45 140.48,52.45 139.98,52.96 UC1.AW2
  BOTTOM w0.102: JSPI1.12 171.61,64.25 171.61,63.85 170.74,62.98 RC38.2 170.63,62.01 169.89,61.27 169.8,61.27 169.09,60.56 169.09,58.57 168.52,57.99 v1(165.47,57.99) ; RC11.2 166.96,48.43 166.96,48.03 v1(166.86,47.93) 166.96,47.82 166.96,47.32 165.99,46.35 164.76,46.35 164.65,46.25 164.65,45.41 164.55,45.31 164.27,45.31 164.17,45.41 164.17,46.25 164.07,46.35 163.79,46.35 163.69,46.25 163.69,44.95 163.59,44.85 163.31,44.85 163.21,44.95 163.21,46.25 163.11,46.35 162.83,46.35 162.72,46.25 162.72,44.95 162.62,44.85 162.34,44.85 162.24,44.95 162.24,46.25 162.14,46.35 160.58,46.35 160.33,46.1 160.33,45.44 160.02,45.13 159.67,45.13 159.5,45.31 159.5,46.2 159.29,46.4 158.25,46.4 158.12,46.27 158.12,45.31 157.95,45.13 157.66,45.13 157.56,45.23 157.56,46.68 157.46,46.78 157.18,46.78 157.08,46.68 157.08,45.23 156.97,45.13 156.7,45.13 156.59,45.23 156.59,46.76 156.49,46.86 156.21,46.86 156.11,46.76 156.11,45.23 156.01,45.13 155.73,45.13 155.63,45.23 155.63,46.76 155.53,46.86 155.25,46.86 155.15,46.76 155.15,45.23 155.04,45.13 154.76,45.13 154.66,45.23 154.66,46.61 154.56,46.71 154.28,46.71 154.18,46.61 154.18,45.23 154.08,45.13 153.8,45.13 153.7,45.23 153.7,46.61 153.6,46.71 153.32,46.71 153.22,46.61 153.22,45.23 153.11,45.13 147.95,45.13 145.19,47.89 145.19,50.71 145.27,50.79 145.27,51.52 144.92,51.86 143.49,51.86 142.9,51.27 142.44,51.27
PCH_SPI_D2_0_R: length 14.1
  BOTTOM w0.102: UC5.3 163.99,60.19 164.98,59.2 165.89,59.2 166.16,59.47 166.16,61.88 166.39,62.11 167.34,62.11 167.44,62.01 v2(167.44,61.01) 167.44,60.37 167.32,60.25 167.05,60.25 166.93,60.37 166.93,61.72 166.83,61.82 166.53,61.82 166.43,61.72 166.43,59.84 RC39.2
PCH_SPI_D2_1_R: length 16.2
  BOTTOM w0.102: UC6.3 158.15,57 158.95,57.81 v2(159.66,57.81) 159.92,57.81 160.08,57.96 160.08,59.14 160.29,59.36 161.26,59.36 162.11,60.21 162.11,62.25 162.26,62.4 163.26,62.4 163.43,62.24 163.43,60.07 164.77,58.72 RC43.2
PCH_SPI_D2_R1: length 8.9
  BOTTOM w0.102: RC43.1 RC39.1 168.33,60.37 RC30.1 168.46,60.61 168.58,60.74 v2(168.58,61.77) 168.71,61.64 169.49,61.64 169.56,61.72 169.7,61.72 169.99,62 RC38.1 171,63.55 171,64.34 JSPI1.11
PCH_SPI_D3: length 85.1
  TOP w0.102: v1(177.22,38.65) v3(177.7,39.14)
  IN1 w0.089: v1(177.22,38.65) 175.57,37 162.39,37 158.02,41.37 155.22,41.37 152.78,43.81 147.11,43.81 145.15,45.77 145.15,47.67 143.31,49.51 143.31,52.05 v1(143.83,52.57)
  IN2 w0.122: v1(172.01,61.69) 172.72,61.69 176.82,57.6 177.84,57.6 181.59,53.86 181.59,49.3 181.09,48.8 181.09,44.94 176.2,40.05 176.2,38.78 176.46,38.53 177.09,38.53 v1(177.22,38.65)
  BOTTOM w0.076: UC1.AU4 138.92,53.96 141.09,53.96 141.11,53.99 142.22,53.99 142.3,53.91
  BOTTOM w0.102: JSPI1.14 172.55,63.8 172.55,62.81 RC40.2 172.13,62.4 172.01,62.28 v1(172.01,61.69) ; 142.3,53.91 142.51,53.7 143.08,53.7 143.83,52.95 v1(143.83,52.57)
PCH_SPI_D3_0_R: length 16.6
  BOTTOM w0.102: RPC1.5 166.07,51.93 165.92,51.77 165.42,51.77 164.28,50.63 v2(164.16,50.63) 163.98,50.63 163.73,50.87 161.95,50.87 161.52,51.3 158.86,51.3 158,52.16 158,52.61 159.69,54.3 160.09,54.3 160.91,55.13 162.35,55.13 162.72,54.75 UC5.7
PCH_SPI_D3_1_R: length 14.4
  BOTTOM w0.102: RC407.2 162.74,50.26 162.62,50.39 161.68,50.39 v2(161.24,50.82) 157.74,50.82 157.52,51.05 157.52,52.42 157.42,52.52 157.1,52.52 157,52.42 157,51.04 156.9,50.94 156.63,50.94 156.52,51.05 156.52,51.57 156.42,51.67 156.16,51.67 156.04,51.54 156.04,49.92 156.21,49.74 156.77,49.74 156.88,49.63 UC6.7
PCH_SPI_D3_R1: length 28.8
  TOP w0.102: v3(163.11,49.72) 164.18,49.72 v1(164.73,50.26)
  IN2 w0.122: v1(163.38,57.64) 163.37,57.64 163.37,51.99 164.73,50.64 v1(164.73,50.26)
  BOTTOM w0.102: RPC1.4 165.41,51.08 164.75,50.42 164.75,50.33 164.73,50.31 v1(164.73,50.26) 164.73,49.78 RC316.1 164.29,49.35 164.29,49.33 163.9,48.94 163.89,48.94 RC31.1 RC407.1 ; JSPI1.13 172.01,63.96 172.01,63.62 171.38,62.99 RC40.1 171.25,62.79 171.25,62.28 171.38,62.15 171.38,61.97 170.87,61.46 170.67,61.46 170.09,60.87 170.09,60.87 169.61,60.39 169.61,58.4 168.51,57.3 163.73,57.3 v1(163.38,57.64)
PCH_SPI_DO2_XDP: length 125.2
  TOP w0.102: v1(98.74,105.25) 99.2,105.71 103.01,105.71 103.65,105.08 104.79,105.08 105.28,105.56 109.3,105.56 v2(113.07,101.79) 114.48,100.38 115.24,100.38 v1(115.75,99.87)
  IN2 w0.122: v1(88.64,105.25) 89.06,104.83 98.31,104.83 v1(98.74,105.25) ; v1(161.19,57.55) 160.29,58.45 160.29,61.84 159.98,62.15 159.98,65.62 158.76,66.85 158.76,68.64 158.01,69.39 158.01,70.76 157.64,71.13 157.64,78.05 157.03,78.65 156.33,78.65 152.38,82.6 152.38,87.46 151.2,88.64 150.18,88.64 147.92,90.9 139.83,90.9 137.66,93.08 132.43,93.08 132.11,92.76 128.2,92.76 127.69,92.25 124.16,92.25 123.86,92.55 118.45,92.55 115.75,95.25 v1(115.75,99.87)
  BOTTOM w0.102: RC11.1 168.05,50.44 168.05,55.7 166.93,56.82 163.53,56.82 162.79,57.55 v1(161.19,57.55) ; JXDP1.60 v1(88.64,105.25)
PCH_SPI_DO_XDP: length 133
  TOP w0.102: RC10.1 162.23,49.56 v1(161.81,49.98)
  IN2 w0.122: v1(97.74,102.26) 98.26,101.74 102.19,101.74 102.97,100.97 104.91,100.97 105.41,101.47 107.45,101.47 107.9,101.01 115.75,101.01 116.26,100.5 116.26,95.45 118.66,93.05 123.54,93.05 123.76,93.27 131.91,93.27 132.22,93.58 137.87,93.58 140.03,91.41 148.12,91.41 150.39,89.14 151.41,89.14 152.89,87.67 152.89,83.51 158.14,78.26 158.14,71.34 158.52,70.97 158.52,69.6 160.49,67.63 160.49,62.36 160.8,62.05 160.8,58.66 161.62,57.84 161.62,57.15 161.28,56.82 161.28,50.51 v1(161.81,49.98)
  BOTTOM w0.102: RC128.1 89.26,93 RC133.1 88.78,91.64 v2(88,91.64) 87.43,91.64 86.67,92.4 86.67,94.05 86.9,94.28 86.9,95.27 87.74,96.11 87.74,100.27 88.32,100.86 96.35,100.86 v1(97.74,102.26)
PCI_CLK_LPC1: length 13.8
  TOP w0.102: v1(141.22,47.62) 141.83,47.62 142.17,47.29 v2(142.17,46.54) 142.17,45.77 142.9,45.03 143.49,45.03 144.07,44.45 RC22.1
  BOTTOM w0.076: UC1.AY9 135.95,52.07 135.95,51.82 136.13,51.64 136.13,50.98 137.28,49.83 138.49,49.83 138.61,49.7 138.93,49.7
  BOTTOM w0.102: 138.93,49.7 139.78,49.7 140.8,48.69 140.8,48.04 v1(141.22,47.62)
PCIE_PRX_C_DTX_N1: length 2.2
  BOTTOM w0.094: CR14.2 77.96,90.14 77.96,90.69 78.07,90.8 78.07,91.12 77.97,91.22 UR1.8
PCIE_PRX_C_DTX_N4: length 9.8
  TOP w0.094: UL1.39 255.24,69.7 255.11,69.57 255.11,68.87 252.58,66.34 252.4,66.34 252.4,66.34 v4(252.1,66.34) 251.65,66.34 251.65,66.34 251.05,66.34 250.94,66.24 250.94,65.84 251.1,65.69 252.24,65.69 252.5,65.44 252.5,65.08 CL2.2
PCIE_PRX_C_DTX_N11: length 2.5
  BOTTOM w0.094: JNGFF3.29 274.1,10.77 274.53,11.2 274.53,11.3 274.77,11.55 274.86,11.63 RN82.1
PCIE_PRX_C_DTX_N12: length 3.9
  BOTTOM w0.094: RN78.1 270.7,12.53 270.84,12.67 271.2,12.67 271.4,12.47 271.4,11.95 270.84,11.39 270.84,11 270.6,10.76 JNGFF3.43
PCIE_PRX_C_DTX_P1: length 2.2
  BOTTOM w0.094: UR1.7 78.37,91.24 78.26,91.13 78.26,90.72 78.15,90.61 78.15,90.14 CR13.2
PCIE_PRX_C_DTX_P4: length 9.9
  TOP w0.094: UL1.38 254.84,69.7 254.92,69.62 254.92,68.95 252.53,66.56 252.4,66.56 252.39,66.57 251.81,66.57 251.77,66.53 250.95,66.53 250.72,66.3 v4(250.72,66.05) 250.72,65.81 251.02,65.51 252.16,65.51 252.31,65.36 252.31,65.08 CL1.2
PCIE_PRX_C_DTX_P11: length 3.4
  BOTTOM w0.094: RN81.1 273.91,12.15 273.91,11.9 274.02,11.8 274.35,11.8 274.35,11.81 274.51,11.81 274.59,11.73 274.59,11.62 274.35,11.38 274.35,11.28 274.04,10.98 273.73,10.98 273.6,10.84 JNGFF3.31
PCIE_PRX_C_DTX_P12: length 3.9
  BOTTOM w0.094: RN77.1 270.98,12.86 271.27,12.86 271.58,12.55 271.58,11.88 271.02,11.32 271.02,10.94 271.1,10.87 JNGFF3.41
PCIE_PRX_C_RD_DTX_N11: length 1.8
  TOP w0.094: UN4.4 245.39,23.18 245.23,23.03 244.89,23.03 244.75,23.17 244.57,23.17 244.3,23.44 CN27.2
PCIE_PRX_C_RD_DTX_N12: length 1.9
  TOP w0.094: CN37.2 232.83,21.48 233.07,21.48 233.26,21.67 233.51,21.67 233.66,21.83 UN5.4
PCIE_PRX_C_RD_DTX_P11: length 1.8
  TOP w0.094: CN26.2 244.3,22.75 244.54,22.99 244.67,22.99 244.82,22.84 245.2,22.84 245.36,22.68 UN4.5
PCIE_PRX_C_RD_DTX_P12: length 1.9
  TOP w0.094: UN5.5 233.67,21.33 233.51,21.49 233.34,21.49 233.14,21.29 232.83,21.29 CN36.2
PCIE_PRX_DTX_N1: length 79
  IN2 w0.122: v1(132.96,69.29) 132.42,70.01 132.42,71.38 132.16,71.64 132.16,74.65 131.12,75.69 131.12,80.97 131.65,81.5 131.65,82.72 131.14,83.23 130.2,83.23 129.44,82.47 123.85,82.47 121.69,80.31 118.88,80.31 114.97,84.22 111.79,84.22 110.62,85.39 108.98,85.39 107.32,87.04 105.85,87.04 105.23,86.43 101.84,86.43 99.67,88.59 93.78,88.59 92.76,89.61 88.8,89.61 87.56,88.36 83.09,88.36 81.03,86.3 77.91,86.3 77.5,86.72 77.5,87.27 77.96,87.72 77.96,87.95 v1(77.76,88.15)
  BOTTOM w0.076: UC1.H13 v1(132.96,69.29)
  BOTTOM w0.094: CR14.1 77.93,88.55 77.93,88.32 v1(77.76,88.15)
PCIE_PRX_DTX_N3: length 109.4
  IN4 w0.076: 131.14,71.76 131.13,71.75 131.13,71.74 130.57,71.18 130.57,69.78 v1(131.09,69.27)
  IN4 w0.089: 131.14,71.76 132.39,73.01 138.81,73.01 140.47,74.67 145.14,74.67 146.06,73.76 146.06,72.97 148.11,70.91 150.98,70.91 151.52,71.45 155.76,71.45 156.11,71.8 159.17,71.8 160.38,70.6 165.38,70.6 165.95,70.03 167.66,70.03 171.31,66.39 172.2,66.39 176.81,61.77 178.34,61.77 179.51,60.6 179.51,59.18 186.34,52.34 186.34,47.09 191.16,42.26 191.85,42.26 194.94,39.18 195.19,39.18 198.96,35.41 200.08,35.41 206.31,29.18 206.31,28.87 206.74,28.44 207.6,28.44 207.77,28.61 v1(207.77,28.94)
  BOTTOM w0.076: UC1.H16 v1(131.09,69.27)
  BOTTOM w0.094: JNGFF1.43 207.99,28 207.77,28.22 v1(207.77,28.94)
PCIE_PRX_DTX_N4: length 194.5
  TOP w0.094: CL2.1 252.5,63.33 252.5,57.67 249.84,55.01 247.68,55.01 245.39,52.73 241.58,52.73 v4(238.47,49.61) 238.13,49.27 238.13,48.74 237.7,48.31 236.02,48.31 234.66,46.95 234.66,46.9 234.24,46.48 234.06,46.48 234.05,46.48 233.08,46.48 232.44,45.84 231.02,45.84 230.49,45.31 229.5,45.31 228.43,44.24 226.24,44.24 223.88,41.88 223.88,39.88 v1(224.08,39.67)
  IN4 w0.076: 124.66,74 124.66,73.98 124.67,73.97 124.67,71.95 125.01,71.62 125.01,69.78 125.45,69.34 129.87,69.34 130.48,68.73 131.33,68.73 131.67,69.07 131.67,69.81 131.77,69.91 v1(132.03,69.91)
  IN4 w0.089: 124.66,74 124.66,74.47 123.06,76.07 123.06,78.17 125.35,80.46 125.35,81.91 129.21,85.77 132.9,85.77 133.84,86.71 136.02,86.71 136.86,85.88 146.38,85.88 146.46,85.8 149.23,85.8 150.27,84.76 154.59,84.76 158.14,81.21 164.52,81.21 165.26,80.46 168.79,80.46 172.47,76.78 172.47,73.47 175.48,70.47 178.28,70.47 186.43,62.31 186.43,59.69 192.1,54.02 192.1,51.2 196.34,46.96 199.01,46.96 201.8,44.17 204.04,44.17 205.11,43.1 206.43,43.1 208.08,41.45 209.27,41.45 210.85,39.87 211.33,39.87 212.13,39.08 212.59,39.08 213.26,38.4 219.76,38.4 222.03,40.66 223.85,40.66 224.08,40.43 v1(224.08,39.67)
  BOTTOM w0.076: UC1.G15 v1(132.03,69.91)
PCIE_PRX_DTX_N8: length 190.7
  IN4 w0.076: v1(128.31,69.96) 128.46,70.1 128.79,70.1 129.01,70.32 129.01,70.91 128.62,71.3 128.62,72.49 126.78,74.33 126.78,74.34 126.76,74.35
  IN4 w0.089: 126.76,74.35 126.52,74.6 126.52,78.77 129.01,81.26 129.01,82.01 130.58,83.58 140.58,83.58 143.65,80.51 144.23,80.51 144.55,80.83 149.95,80.83 150.66,81.54 152.35,81.54 153.43,80.46 155.3,80.46 158.35,77.42 160.05,77.42 160.43,77.8 162.23,77.8 163.25,76.78 164.11,76.78 166.25,74.65 167.83,74.65 172.83,69.65 173.55,69.65 174.64,68.56 177.49,68.56 184.28,61.77 184.28,59.1 189.94,53.44 189.94,49.5 198.56,40.89 201.91,40.89 203.52,39.28 203.98,39.28 207.78,35.48 209.99,35.48 213.42,32.05 217.1,32.05 218.29,33.24 223.55,33.24 223.98,33.67 228.95,33.67 229.28,33.35 232.57,33.35 233.53,32.38 240.54,32.38 241.21,33.05 244.87,33.05 247.4,30.53 248.14,30.53 249.38,31.77 256.44,31.77 257.1,32.43 258.93,32.43 259.26,32.76 260.84,32.76 261.22,32.38 266.05,32.38 267.14,31.29 268.71,31.29 268.99,31.57 268.99,32.06 v1(269.21,32.27)
  BOTTOM w0.076: UC1.G21 128.46,69.96 v1(128.31,69.96)
  BOTTOM w0.094: v1(269.21,32.27) 269,32.07 269,30.44 269.09,30.35 269.09,29.8 269.25,29.64 JNGFF2.43
PCIE_PRX_DTX_N11: length 164.3
  TOP w0.094: CN27.1 243.39,23.29 243.24,23.14 242.98,23.14 242.18,23.95 242.18,24.1 240.36,25.92 240.36,26.4 v4(239.89,26.86) 238.49,28.26 238.49,29.2 234.88,32.81 234.88,33.21 v1(235.08,33.41)
  IN4 w0.076: v1(125.63,71.22) 125.87,70.98 126.13,70.98 126.29,71.14 126.29,73.26 125.89,73.66 125.88,73.66 125.87,73.68
  IN4 w0.089: 125.87,73.68 125.75,73.8 125.75,79.13 127.69,81.07 127.69,82.52 129.67,84.5 142.04,84.5 144.96,81.58 149.64,81.58 150.36,82.3 152.65,82.3 153.71,81.24 155.59,81.24 158.22,78.61 162.82,78.61 163,78.43 165.19,78.43 165.81,77.81 165.81,77.27 167.57,75.51 168.11,75.51 173.22,70.4 173.87,70.4 174.95,69.32 177.8,69.32 185.11,62 185.11,59.36 190.79,53.69 190.79,50.49 199.62,41.65 202.54,41.65 203.89,40.31 204.04,40.31 206.46,37.89 208.66,37.89 209.68,36.88 210.19,36.88 212.96,34.11 212.96,33.9 213.8,33.07 214.3,33.07 214.74,33.5 217.33,33.5 217.84,34.01 223.2,34.01 223.65,34.46 229.28,34.46 229.64,34.1 234.58,34.1 234.86,33.83 234.86,33.63 v1(235.08,33.41)
  BOTTOM w0.076: UC1.E28 124.52,71.22 v1(125.63,71.22)
PCIE_PRX_DTX_N12: length 147.8
  TOP w0.094: v1(230.2,24.48) 230,24.28 230,23.27 230.27,23 230.33,23 230.75,22.57 230.75,22.52 230.92,22.36 230.92,21.58 231.02,21.48 231.21,21.48 CN37.1
  IN4 w0.076: 139.28,67.35 139.27,67.34 139.27,67.32 138.79,66.85 128.62,66.85 128.2,67.27 124.5,67.27 124.21,66.97 124.2,66.97 124.16,66.94 124.15,66.94 124.14,66.93 ; 123.25,66.93 123.23,66.94 123.22,66.94 123.09,67.07 123.09,69.23 123.42,69.55 123.42,70.21 123.6,70.39 123.6,70.99 123.42,71.17 v1(122.86,71.17)
  IN4 w0.089: 124.14,66.93 124.13,66.92 123.26,66.92 123.25,66.93 ; 139.28,67.35 141.18,69.25 141.18,70.32 142.64,71.78 144.07,71.78 144.71,71.14 144.71,70.74 146.41,69.03 150.07,69.03 150.94,68.17 152.34,68.17 153.62,69.46 159.58,69.46 160.16,68.87 164.67,68.87 165.21,68.33 167.23,68.33 170.9,64.66 171.48,64.66 173.42,62.72 173.42,61.55 173.61,61.36 174.01,61.36 175.34,60.04 175.77,60.04 178.18,57.63 178.54,57.63 183.75,52.42 183.75,48.08 184.36,47.47 184.36,45.74 190.4,39.7 191.24,39.7 191.67,39.27 191.67,38.22 193.12,36.78 194.31,36.78 196.33,34.76 196.84,34.76 198.66,32.94 200.03,32.94 202.85,30.12 203.72,30.12 205.11,28.73 205.11,28.21 206.07,27.25 209.89,27.25 210.9,28.27 214.61,28.27 215.14,27.74 217.84,27.74 218.02,27.91 221.62,27.91 223.02,26.51 223.02,26.21 223.42,25.8 229.7,25.8 230,25.5 230,24.68 v1(230.2,24.48)
  BOTTOM w0.076: UC1.E30 123.31,71.15 123.17,71.29 122.98,71.29 v1(122.86,71.17)
PCIE_PRX_DTX_P1: length 78.9
  IN2 w0.122: v1(78.37,88.15) 78.19,87.96 78.19,87.63 77.73,87.17 77.73,86.81 78.01,86.53 80.93,86.53 82.99,88.59 87.46,88.59 88.71,89.84 92.86,89.84 93.88,88.82 99.77,88.82 101.93,86.66 105.14,86.66 105.75,87.27 107.42,87.27 109.07,85.62 110.72,85.62 111.89,84.45 115.06,84.45 118.97,80.54 121.6,80.54 123.76,82.7 129.34,82.7 130.11,83.46 131.24,83.46 131.88,82.82 131.88,81.41 131.35,80.87 131.35,75.79 132.39,74.75 132.39,71.74 132.66,71.47 132.66,70.53 132.78,70.4 133.14,70.4 133.26,70.28 133.26,70.08 133.14,69.96 v1(132.96,69.96)
  BOTTOM w0.076: UC1.G13 133.29,69.63 v1(132.96,69.96)
  BOTTOM w0.094: CR13.1 78.13,88.5 78.13,88.39 v1(78.37,88.15)
PCIE_PRX_DTX_P3: length 109.4
  IN4 w0.076: v1(131.12,69.94) 131.12,69.8 131.04,69.72 130.87,69.72 130.74,69.85 130.74,71.11 131.25,71.62 131.26,71.62 131.27,71.64
  IN4 w0.089: v1(208.36,28.94) 207.68,28.26 206.66,28.26 206.13,28.8 206.13,29.1 200,35.23 198.89,35.23 195.12,39 194.86,39 191.77,42.08 191.09,42.08 186.16,47.01 186.16,52.27 179.33,59.1 179.33,60.53 178.26,61.59 176.74,61.59 172.12,66.21 171.23,66.21 167.59,69.85 165.88,69.85 165.31,70.42 160.31,70.42 159.1,71.62 156.19,71.62 155.83,71.27 151.59,71.27 151.06,70.73 148.04,70.73 145.88,72.89 145.88,73.68 145.07,74.49 140.54,74.49 138.88,72.83 132.47,72.83 131.27,71.64
  BOTTOM w0.076: v1(131.12,69.94) 131.43,69.63 UC1.G16
  BOTTOM w0.094: JNGFF1.41 209.41,28.5 209.09,28.19 208.07,28.19 207.96,28.3 207.96,28.54 v1(208.36,28.94)
PCIE_PRX_DTX_P4: length 194.5
  TOP w0.094: CL1.1 252.31,63.33 252.31,57.75 249.76,55.2 247.6,55.2 245.32,52.91 241.51,52.91 238.57,49.98 238.52,49.98 238.1,49.55 238.1,49.5 237.94,49.35 237.94,48.82 237.62,48.49 235.94,48.49 v4(234.3,46.84) 234.12,46.67 233,46.67 232.36,46.03 230.94,46.03 230.41,45.5 229.42,45.5 228.35,44.43 226.17,44.43 223.69,41.96 223.69,39.87 v1(223.5,39.67)
  IN4 w0.076: v1(132.03,70.53) 131.7,70.2 131.7,70.08 131.5,69.88 131.5,69.13 131.26,68.89 130.55,68.89 129.94,69.5 125.52,69.5 125.18,69.85 125.18,71.69 124.84,72.02 124.84,73.97 124.85,73.98 124.85,74
  IN4 w0.089: v1(223.5,39.67) 223.28,39.89 223.28,40.01 223.35,40.08 223.82,40.08 223.9,40.17 223.9,40.36 223.78,40.48 222.1,40.48 219.84,38.22 213.19,38.22 212.51,38.9 212.06,38.9 211.26,39.69 210.77,39.69 209.2,41.27 208.01,41.27 206.36,42.92 205.03,42.92 203.96,43.99 201.73,43.99 198.94,46.78 196.27,46.78 191.92,51.13 191.92,53.95 186.25,59.62 186.25,62.23 178.2,70.28 175.4,70.28 172.29,73.4 172.29,76.71 168.71,80.28 165.19,80.28 164.45,81.03 158.06,81.03 154.51,84.58 150.19,84.58 149.16,85.62 146.39,85.62 146.31,85.7 136.78,85.7 135.94,86.53 133.91,86.53 132.97,85.59 129.29,85.59 125.53,81.83 125.53,80.39 123.24,78.1 123.24,76.15 124.85,74.55 124.85,74
  BOTTOM w0.076: v1(132.03,70.53) 132.29,70.28 UC1.F15
PCIE_PRX_DTX_P8: length 190.7
  IN4 w0.076: v1(128.32,70.61) 128.32,70.47 128.53,70.27 128.72,70.27 128.85,70.39 128.85,70.84 128.45,71.23 128.45,72.42 126.66,74.21 126.65,74.21 126.64,74.23
  IN4 w0.089: v1(268.62,32.27) 268.81,32.09 268.81,31.64 268.64,31.47 267.21,31.47 266.12,32.56 261.29,32.56 260.91,32.94 259.19,32.94 258.86,32.61 257.03,32.61 256.37,31.95 249.31,31.95 248.06,30.71 247.47,30.71 244.95,33.23 241.14,33.23 240.47,32.56 233.61,32.56 232.64,33.53 229.35,33.53 229.02,33.85 223.91,33.85 223.47,33.42 218.21,33.42 217.02,32.23 213.49,32.23 210.06,35.66 207.85,35.66 206,37.51 204.05,39.46 203.6,39.46 201.98,41.07 198.63,41.07 190.12,49.58 190.12,53.51 184.46,59.18 184.46,61.84 177.56,68.74 174.72,68.74 173.63,69.83 172.9,69.83 167.9,74.83 166.32,74.83 164.19,76.96 163.32,76.96 162.31,77.98 160.36,77.98 159.97,77.6 158.42,77.6 155.38,80.64 153.5,80.64 152.42,81.72 150.58,81.72 149.87,81.01 144.48,81.01 144.16,80.69 143.72,80.69 140.65,83.76 130.5,83.76 128.83,82.09 128.83,81.34 126.34,78.85 126.34,74.52 126.64,74.23
  BOTTOM w0.076: UC1.F21 128.8,70.49 128.68,70.61 v1(128.32,70.61)
  BOTTOM w0.094: JNGFF2.41 268.75,29.64 268.91,29.8 268.91,30.27 268.81,30.37 268.81,32.08 v1(268.62,32.27)
PCIE_PRX_DTX_P11: length 164.3
  TOP w0.094: v1(234.49,33.41) 234.69,33.21 234.69,32.74 238.31,29.12 238.31,28.18 239.53,26.96 239.53,26.89 239.93,26.49 239.98,26.49 240.17,26.3 240.17,25.84 241.99,24.02 241.99,23.87 242.9,22.96 243.28,22.96 243.39,22.85 CN26.1
  IN4 w0.076: v1(125.6,70.56) 125.85,70.81 126.2,70.81 126.46,71.07 126.46,73.33 126.01,73.78 126.01,73.79 125.99,73.8
  IN4 w0.089: v1(234.49,33.41) 234.67,33.59 234.67,33.75 234.51,33.92 229.57,33.92 229.2,34.28 223.73,34.28 223.27,33.83 217.91,33.83 217.4,33.32 214.81,33.32 214.38,32.89 213.72,32.89 212.78,33.83 212.78,34.03 210.12,36.7 209.61,36.7 208.59,37.71 206.38,37.71 203.97,40.13 203.82,40.13 202.47,41.47 199.55,41.47 190.61,50.42 190.61,53.62 184.93,59.29 184.93,61.93 177.72,69.14 174.88,69.14 173.79,70.22 173.14,70.22 168.04,75.33 167.49,75.33 165.63,77.2 165.63,77.74 165.11,78.25 162.92,78.25 162.74,78.43 158.14,78.43 155.52,81.06 153.64,81.06 152.57,82.12 150.43,82.12 149.71,81.4 144.89,81.4 141.97,84.32 129.75,84.32 127.87,82.45 127.87,81 125.93,79.05 125.93,73.87 125.99,73.8
  BOTTOM w0.076: UC1.E27 125.1,70.96 124.82,70.96 124.71,70.86 124.71,70.64 124.76,70.59 125.58,70.59 v1(125.6,70.56)
PCIE_PRX_DTX_P12: length 147.8
  TOP w0.094: v1(229.62,24.48) 229.82,24.28 229.82,23.19 v4(230.39,22.62) 230.73,22.28 230.73,21.5 230.94,21.29 231.21,21.29 CN36.1
  IN4 w0.076: 139.41,67.22 139.41,67.22 139.39,67.21 139.38,67.21 138.86,66.69 128.55,66.69 128.13,67.11 124.57,67.11 124.27,66.8 ; v1(122.86,70.59) 122.86,70.64 123.23,71.01 123.35,71.01 123.44,70.92 123.44,70.46 123.25,70.27 123.25,69.62 122.93,69.3 122.93,66.99 123.12,66.8
  IN4 w0.089: v1(229.62,24.48) 229.82,24.68 229.82,25.42 229.62,25.62 223.35,25.62 222.84,26.14 222.84,26.44 221.54,27.73 218.09,27.73 217.91,27.56 215.06,27.56 214.53,28.09 210.98,28.09 209.96,27.07 206,27.07 204.93,28.14 204.93,28.65 203.65,29.94 202.77,29.94 199.95,32.76 198.58,32.76 196.76,34.58 196.26,34.58 194.24,36.6 193.04,36.6 191.49,38.15 191.49,39.19 191.16,39.52 190.33,39.52 184.18,45.66 184.18,47.39 183.57,48 183.57,52.35 178.46,57.45 178.1,57.45 175.69,59.86 175.26,59.86 173.94,61.18 173.54,61.18 173.24,61.48 173.24,62.65 171.41,64.48 170.82,64.48 167.15,68.15 165.14,68.15 164.59,68.69 160.09,68.69 159.5,69.27 153.7,69.27 152.41,67.99 150.86,67.99 150,68.85 146.33,68.85 144.53,70.66 144.53,71.07 144,71.6 142.71,71.6 141.36,70.25 141.36,69.18 139.41,67.22 ; 123.12,66.8 123.18,66.74 124.21,66.74 124.27,66.8
  BOTTOM w0.076: UC1.F30 123.17,70.28 v1(122.86,70.59)
PCIE_PRX_RD_DTX_N11: length 47.7
  TOP w0.094: UN4.15 250.68,23.18 250.98,22.89 250.98,20.92 250.91,20.85 250.91,20.29 251.57,19.63 251.57,18.6 251.9,18.27 251.9,17.93 251.93,17.9 251.93,17.3 251.9,17.27 251.9,13.89 v1(252.28,13.51)
  IN1 w0.089: v1(274.75,13.81) 274.75,13.5 274.78,13.47 274.78,13.43 274.78,13.16 273.81,12.19 273.66,12.19 271.53,12.19 269.24,9.9 264.54,9.9 263.84,9.19 262.69,9.19 261.68,8.17 261.68,6.78 261.04,6.14 259.26,6.14 259.01,5.89 257.55,5.89 254.18,9.26 252.77,9.26 250.7,11.33 250.7,14.09 250.94,14.33 251.58,14.33 251.9,14.02 251.9,13.89 v1(252.28,13.51)
  BOTTOM w0.094: v1(274.75,13.81) 274.58,13.64 274.58,13.42 RN82.2
PCIE_PRX_RD_DTX_N12: length 47.2
  TOP w0.094: v1(242.2,18.46) 242,18.66 242,20.61 240.94,21.67 238.74,21.67 238.58,21.83 UN5.15
  IN4 w0.089: v1(242.2,18.46) 241.99,18.67 241.99,18.91 242.08,19 246.93,19 247.53,18.4 247.53,17.67 248.23,16.97 250.08,16.97 250.27,16.79 253.75,16.79 255.12,18.16 257.15,18.16 258.28,17.04 258.28,14.5 258.39,14.39 258.39,12.12 257.93,11.67 257.93,10.4 258.63,9.7 265.74,9.7 266.5,10.46 268.46,10.46 268.66,10.66 268.66,11.06 v1(268.86,11.26)
  BOTTOM w0.094: RN78.2 269.44,12.59 269.04,12.59 268.66,12.21 268.66,11.46 v1(268.86,11.26)
PCIE_PRX_RD_DTX_P11: length 46.7
  TOP w0.094: UN4.14 250.31,22.68 250.42,22.8 250.42,22.93 250.49,23 250.6,23 250.79,22.81 250.79,21 250.72,20.93 250.72,20.21 251.38,19.55 251.38,18.53 251.71,18.2 v4(251.71,17.6) 251.71,13.53 v1(251.69,13.51)
  IN1 w0.089: v1(251.69,13.51) 251.71,13.52 251.71,13.95 251.51,14.15 251.02,14.15 250.88,14.02 250.88,11.4 252.84,9.44 254.25,9.44 257.62,6.07 258.93,6.07 259.19,6.32 260.97,6.32 261.49,6.85 261.49,8.25 262.62,9.37 263.76,9.37 264.47,10.08 269.17,10.08 271.46,12.37 273.74,12.37 274.6,13.23 274.6,13.36 274.51,13.45 274.2,13.45 274.11,13.54 274.11,13.75 v1(274.16,13.81)
  BOTTOM w0.094: RN81.2 274.25,13.14 274.39,13.29 274.39,13.58 v1(274.16,13.81)
PCIE_PRX_RD_DTX_P12: length 47.2
  TOP w0.094: UN5.14 238.58,21.33 238.74,21.49 240.86,21.49 241.81,20.54 241.81,18.66 v1(241.61,18.46)
  IN4 w0.089: v1(241.61,18.46) 241.81,18.66 241.81,18.98 242,19.18 247.01,19.18 247.71,18.47 247.71,17.75 248.3,17.15 250.16,17.15 250.34,16.97 253.67,16.97 255.04,18.34 257.23,18.34 258.46,17.11 258.46,14.57 258.57,14.46 258.57,12.05 258.11,11.59 258.11,10.47 258.7,9.88 265.66,9.88 266.43,10.64 268.38,10.64 268.48,10.74 268.48,11.06 v1(268.28,11.26)
  BOTTOM w0.094: v1(268.28,11.26) 268.47,11.46 268.47,12.29 268.96,12.78 269.44,12.78 RN77.2
PCIE_PTX_C_DRX_N1: length 2.2
  BOTTOM w0.094: UR1.4 79.57,91.25 79.67,91.14 79.67,90.9 79.99,90.59 79.99,90.13 CR12.2
PCIE_PTX_C_DRX_N3: length 4
  BOTTOM w0.094: JNGFF1.37 209.43,29.5 209.27,29.66 208.98,29.66 208.14,30.5 207.58,30.5 207.55,30.53 207.25,30.53 CZ13.2
PCIE_PTX_C_DRX_N4: length 6.3
  TOP w0.094: CL6.2 255.49,65.07 255.49,65.37 v4(255.92,65.8) 256.33,66.22 256.33,68.71 256.37,68.74 256.37,69.33 256.33,69.36 256.33,69.6 256.44,69.7 UL1.42
PCIE_PTX_C_DRX_N8: length 3
  TOP w0.094: CZ10.2 270.4,28.38 270.4,27.71 v1(270.2,27.5)
  BOTTOM w0.094: JNGFF2.47 270.25,28.16 270.41,28 270.41,27.72 v1(270.2,27.5)
PCIE_PTX_C_DRX_N11: length 2.5
  BOTTOM w0.094: CN69.1 272.75,11.87 272.75,11.5 272.44,11.19 272.44,10.91 272.6,10.76 JNGFF3.35
PCIE_PTX_C_DRX_N12: length 16.3
  BOTTOM w0.094: JNGFF3.47 269.6,9.24 269.49,9.14 269.49,8.62 267.41,6.54 264.3,6.54 263.66,7.18 260.11,7.18 259.82,7.46 259.82,7.59 259.79,7.62 259.79,8.22 259.82,8.25 v4(259.82,9.23) 259.82,9.63 259.24,10.21 258.73,10.21 CN71.1
PCIE_PTX_C_DRX_P1: length 2.2
  BOTTOM w0.094: UR1.3 79.97,91.24 79.86,91.13 79.86,90.98 80.17,90.66 80.17,90.14 CR11.2
PCIE_PTX_C_DRX_P3: length 3.9
  BOTTOM w0.094: CZ12.2 207.23,30.71 v4(207.88,30.71) 208.03,30.71 208.19,30.71 209.06,29.84 209.27,29.84 209.43,30 JNGFF1.35
PCIE_PTX_C_DRX_P4: length 6.3
  TOP w0.094: UL1.41 256.04,69.7 256.15,69.6 v4(256.15,69.03) 256.15,66.3 256.01,66.16 255.97,66.16 255.55,65.75 255.55,65.7 255.3,65.45 255.3,65.08 CL5.2
PCIE_PTX_C_DRX_P8: length 3
  TOP w0.094: v1(270.78,27.5) 270.59,27.7 270.59,28.36 CZ11.2
  BOTTOM w0.094: v1(270.78,27.5) 270.59,27.69 270.59,27.99 270.75,28.15 JNGFF2.49
PCIE_PTX_C_DRX_P11: length 2.5
  BOTTOM w0.094: JNGFF3.37 272.1,10.76 272.26,10.91 272.26,11.26 272.44,11.45 272.57,11.57 272.57,11.87 CN70.1
PCIE_PTX_C_DRX_P12: length 16.2
  BOTTOM w0.094: CN72.1 258.45,10.56 258.61,10.4 259.31,10.4 260.01,9.7 260.01,9.56 260.04,9.53 260.04,8.94 260.01,8.9 v4(260.01,7.92) 260.01,7.54 260.18,7.36 263.73,7.36 264.37,6.72 267.33,6.72 269.31,8.7 269.31,9.05 269.1,9.26 JNGFF3.49
PCIE_PTX_C_RD_DRX_N11: length 3.5
  TOP w0.094: CN23.2 243.96,25.68 244.23,25.68 244.27,25.64 244.77,25.64 244.91,25.5 244.91,24.56 245.13,24.34 245.32,24.34 245.47,24.18 UN4.2
PCIE_PTX_C_RD_DRX_N12: length 1.9
  TOP w0.094: CN33.2 232.83,23.2 233.02,23.2 233.22,22.99 233.51,22.99 233.67,22.83 UN5.2
PCIE_PTX_C_RD_DRX_P11: length 3.5
  TOP w0.094: CN22.2 243.95,25.86 v4(244.57,25.86) 244.81,25.86 245.1,25.57 245.1,24.64 245.2,24.53 245.33,24.53 245.48,24.68 UN4.1
PCIE_PTX_C_RD_DRX_P12: length 1.9
  TOP w0.094: UN5.1 233.66,23.33 233.51,23.17 233.3,23.17 233.09,23.38 232.83,23.38 CN32.2
PCIE_PTX_DRX_N1: length 71.3
  IN2 w0.122: v1(131.85,77.9) 132.08,78.13 132.08,78.43 132.92,79.26 132.92,82.7 131.55,84.07 126.63,84.07 125.74,84.96 112.3,84.96 111.13,86.13 109.18,86.13 107.58,87.73 101.48,87.73 99.85,89.35 93.95,89.35 92.43,90.88 88.95,90.88 87.1,89.02 82.81,89.02 81.15,87.37 80.25,87.37 79.96,87.66 79.96,87.98 v1(79.79,88.15)
  BOTTOM w0.076: v1(131.85,77.9) 132.15,78.19 132.15,78.35 132.07,78.43 131.83,78.43 131.47,78.08 131.47,73.9 UC1.B17
  BOTTOM w0.094: v1(79.79,88.15) 79.99,88.35 79.99,88.52 CR12.1
PCIE_PTX_DRX_N3: length 114.8
  IN4 w0.089: v1(204.78,33.85) 204.98,34.06 204.98,34.26 204.12,35.12 202.47,35.12 199.8,37.79 198.35,37.79 195.19,40.94 194.57,40.94 193.6,41.91 193.6,42.57 191.88,44.29 190.5,44.29 187.4,47.4 187.4,52.68 181.69,58.39 181.69,59.59 180.6,60.68 180.6,61.06 178.87,62.78 178.87,63.93 176.53,66.27 173.69,66.27 172.6,67.35 171.8,67.35 167.43,71.73 159.85,71.73 159.11,72.46 156.77,72.46 151.2,78.04 147.87,78.04 144.94,75.1 136.96,75.1 135.89,76.17 135.89,78.25 135.39,78.76 133.56,78.76 132.57,79.75 132.18,79.75 v1(132.01,79.58)
  BOTTOM w0.076: 131.14,78.89 131.14,78.87 131.13,78.86 131.13,74.23 130.73,73.83 130.73,73.54 130.79,73.43 130.79,73.28 130.73,73.08 130.73,72.91 130.76,72.82 130.87,72.69 131.07,72.64 131.08,72.64 131.12,72.64 131.29,72.47 131.29,72.23 131.13,71.94 UC1.D17
  BOTTOM w0.094: CZ13.1 205.91,30.36 205.71,30.56 205.48,30.56 205.06,30.98 205.06,33.57 v1(204.78,33.85) ; 131.14,78.89 131.14,79.28 131.65,79.79 131.79,79.79 v1(132.01,79.58)
PCIE_PTX_DRX_N4: length 201.7
  TOP w0.094: CL6.1 255.5,63.35 255.5,63.2 255.6,63.1 256.75,63.1 v1(256.94,63.29)
  IN1 w0.089: v1(124.56,90.63) 124.79,90.85 124.79,91.12 125.15,91.49 127.69,91.49 129.14,92.94 137.86,92.94 139,91.79 142.73,91.79 143.82,92.88 152.68,92.88 153.96,91.6 159.32,91.6 160.56,90.37 161.51,90.37 164.68,87.2 176.23,87.2 178.19,85.24 178.19,76.83 186.63,68.38 186.63,64.01 188.21,62.44 188.21,60.45 199.66,49 200.54,49 202.62,46.91 203.76,46.91 205.41,45.26 208.16,45.26 208.74,44.67 210.19,44.67 210.52,44.34 211.64,44.34 212.01,43.97 217.48,43.97 218.18,43.28 223.3,43.28 223.75,43.74 225.48,43.74 225.81,44.07 228.1,44.07 228.78,44.75 229.8,44.75 230.08,44.47 230.79,44.47 231.83,45.51 232.34,45.51 233.48,46.66 236.02,46.66 240.08,50.72 240.47,50.72 241.66,51.92 244.2,51.92 244.97,52.69 245.71,52.69 247.73,54.71 249.54,54.71 253.75,58.92 253.75,62.17 254.67,63.09 256.74,63.09 v1(256.94,63.29)
  BOTTOM w0.076: UC1.B19 129.37,73.55 129.37,73.73 129.48,73.97 129.48,76.94 129.02,77.4 129.01,77.4 128.99,77.41
  BOTTOM w0.094: v1(124.56,90.63) 124.8,90.39 124.8,88.35 123.06,86.61 123.06,83.03 123.42,82.67 123.42,82.29 123.06,81.94 123.06,80.64 123.67,80.03 123.67,77.61 124.31,76.97 125.96,76.97 127.01,78.02 128.39,78.02 128.69,77.72 128.99,77.41
PCIE_PTX_DRX_N8: length 186.6
  TOP w0.094: v1(270.21,30.61) 270.48,30.33 270.48,30.07 CZ10.1
  IN4 w0.089: v1(128.25,75.02) 128.09,75.18 127.84,75.18 126.98,76.05 126.98,78.58 130.21,81.81 130.78,81.81 131.95,82.99 134.54,82.99 136.53,81 139.26,81 140.71,79.55 143.19,79.55 143.78,78.96 145.11,78.96 146.58,80.43 150.11,80.43 150.71,81.03 152.29,81.03 153.27,80.05 155.15,80.05 158.83,76.38 162.56,76.38 164.8,74.14 167.78,74.14 172.66,69.26 173.39,69.26 174.48,68.17 177.32,68.17 183.82,61.67 183.82,59 189.49,53.34 189.49,49.4 190.94,47.95 190.94,46.78 191.21,46.51 192.38,46.51 198.4,40.49 200.66,40.49 202.44,38.71 203.94,38.71 207.78,34.87 209.96,34.87 213.19,31.65 217.58,31.65 218.22,32.28 220.22,32.28 220.65,32.71 223.95,32.71 224.49,33.24 227.21,33.24 227.64,32.81 232.24,32.81 233.07,31.97 240.87,31.97 241.26,32.36 244.99,32.36 247.27,30.07 248.24,30.07 249.53,31.37 257.05,31.37 257.43,31.75 266.04,31.75 266.96,30.83 267.97,30.83 268.79,30.02 270.49,30.02 270.61,30.14 270.61,30.21 v1(270.21,30.61)
  BOTTOM w0.076: UC1.D21 128.23,72.23 128.23,72.23 128.23,72.41 128.09,72.89 128.09,73.13 128.11,73.19 128.11,73.45 128.09,73.51 128.09,73.9 128.47,74.29 128.47,74.8 v1(128.25,75.02)
PCIE_PTX_DRX_N11: length 163.9
  TOP w0.094: v1(236.02,33.57) 236.05,33.55 236.05,32.27 239.01,29.31 239.01,28.62 240.74,26.89 240.74,26.53 240.97,26.3 240.97,26.25 241.61,25.62 242.04,25.62 242.12,25.69 242.32,25.69 CN23.1
  IN4 w0.089: v1(236.02,33.57) 236.2,33.75 236.2,33.91 235.97,34.13 235.13,34.13 234.77,34.49 233.2,34.49 232.25,35.45 226.14,35.45 225.99,35.61 217.99,35.61 217.04,34.66 213.52,34.66 210.49,37.69 210.06,37.69 208.97,38.78 207.02,38.78 205.03,40.76 204.07,40.76 202.77,42.06 199.85,42.06 191.29,50.62 191.29,53.77 185.62,59.44 185.62,62.05 177.96,69.71 175.17,69.71 171.02,73.86 171.02,76.35 168.51,78.86 165.8,78.86 164.39,80.27 162.73,80.27 162.28,79.83 158.22,79.83 155.35,82.7 149.99,82.7 149.33,82.04 145.06,82.04 142.15,84.96 129.54,84.96 127.06,82.47 127.06,81.07 124.21,78.23 124.21,75.99 124.54,75.67 124.94,75.67 v1(125.22,75.95)
  BOTTOM w0.076: v1(125.22,75.95) 125.09,75.82 125.09,75.68 125.2,75.58 125.39,75.58 125.46,75.5 125.95,75.5 126.52,74.93 126.52,73.27 126.66,73.12 126.66,73.03 126.89,72.8 126.89,72.55 UC1.D24
PCIE_PTX_DRX_N12: length 151.9
  TOP w0.094: v1(230.47,25.02) 230.61,24.87 230.61,24.55 230.88,24.28 230.88,23.42 231.11,23.2 231.41,23.2 231.56,23.05 CN33.1
  IN4 w0.076: 131.7,68.2 131.69,68.2 131.68,68.2 131.63,68.2 131.62,68.21 128.67,68.21 128.21,68.67 125,68.67 124.21,69.46 124.21,71.37 121.51,74.07 121.51,74.9 121.85,75.23 v1(122.58,75.23)
  IN4 w0.089: v1(230.47,25.02) 230.47,25.92 230.18,26.21 223.62,26.21 223.42,26.41 223.42,26.67 221.77,28.32 217.23,28.32 217.05,28.14 215.35,28.14 214.81,28.67 210.75,28.67 209.73,27.66 206.23,27.66 205.53,28.35 205.53,28.87 203.8,30.6 203.08,30.6 200.26,33.42 198.91,33.42 194.57,37.77 192.74,37.77 192.13,38.37 192.13,39.8 191.29,40.64 190.05,40.64 184.81,45.87 184.81,51.94 178.11,58.64 178.11,59.2 176.88,60.43 175.55,60.43 174.51,61.47 174.51,62.19 171.64,65.06 171.06,65.06 167.39,68.72 165.37,68.72 164.83,69.27 160.32,69.27 159.14,70.45 152.4,70.45 151.39,69.44 146.56,69.44 145.32,70.69 145.32,71.32 144.45,72.18 142.3,72.18 138.12,68 135.63,68 135.18,67.56 134.52,67.56 134.45,67.64 133.95,67.64 133.39,68.2 131.7,68.2
  BOTTOM w0.076: UC1.A25 125.87,73.65 125.79,73.73 125.79,74.47 125.44,74.82 123,74.82 v1(122.58,75.23)
PCIE_PTX_DRX_P1: length 71.2
  IN2 w0.122: v1(132.43,77.9) 132.31,78.02 132.31,78.33 133.15,79.17 133.15,82.8 131.65,84.3 126.73,84.3 125.84,85.19 112.4,85.19 111.23,86.36 109.27,86.36 107.67,87.96 101.58,87.96 99.95,89.58 94.05,89.58 92.52,91.11 88.86,91.11 87,89.25 82.71,89.25 81.06,87.6 80.34,87.6 80.19,87.75 80.19,87.96 v1(80.38,88.15)
  BOTTOM w0.076: UC1.A17 131.11,73.65 131.2,73.74 131.31,73.94 131.31,78.22 v4(131.5,78.41) 131.69,78.6 132.14,78.6 132.31,78.42 132.31,78.02 v1(132.43,77.9)
  BOTTOM w0.094: v1(80.38,88.15) 80.18,88.35 80.18,88.52 CR11.1
PCIE_PTX_DRX_P3: length 114.8
  IN4 w0.089: v1(132.01,80.16) 132.24,79.93 132.64,79.93 133.63,78.94 135.46,78.94 136.07,78.33 136.07,76.25 137.04,75.28 144.86,75.28 147.79,78.22 151.28,78.22 156.85,72.64 159.18,72.64 159.92,71.91 167.5,71.91 171.87,67.53 172.67,67.53 173.76,66.45 176.61,66.45 179.05,64 179.05,62.86 180.78,61.13 180.78,60.75 181.87,59.66 181.87,58.47 187.58,52.75 187.58,47.47 190.58,44.47 191.95,44.47 193.78,42.64 193.78,41.98 194.64,41.12 195.27,41.12 198.42,37.97 199.87,37.97 202.54,35.3 204.19,35.3 205.16,34.33 205.16,34.05 v1(205.36,33.85)
  BOTTOM w0.076: 130.96,78.89 130.96,78.88 130.97,78.87 130.97,74.3 130.56,73.9 130.56,73.5 130.62,73.39 130.62,73.3 130.56,73.11 130.56,72.89 130.58,72.84 130.57,72.86 130.62,72.69 130.64,72.63 130.69,72.57 130.69,72.15 130.78,72.06 130.91,72.06 131,72.15 UC1.C17
  BOTTOM w0.094: CZ12.1 205.91,30.9 205.76,30.74 205.56,30.74 205.24,31.06 205.24,33.74 v1(205.36,33.85) ; 130.96,78.89 130.96,79.36 131.57,79.98 131.82,79.98 v1(132.01,80.16)
PCIE_PTX_DRX_P4: length 201.7
  TOP w0.094: v1(256.94,62.7) 256.73,62.91 255.52,62.91 255.31,63.12 255.31,63.32 CL5.1
  IN1 w0.089: v1(256.94,62.7) 256.73,62.91 254.74,62.91 253.93,62.1 253.93,58.85 249.61,54.53 247.81,54.53 245.78,52.51 245.05,52.51 244.28,51.74 241.74,51.74 240.54,50.54 240.16,50.54 236.09,46.48 233.56,46.48 232.41,45.33 231.91,45.33 230.86,44.29 230,44.29 229.72,44.57 228.86,44.57 228.17,43.88 225.88,43.88 225.56,43.56 223.83,43.56 223.37,43.1 218.1,43.1 217.41,43.79 211.93,43.79 211.56,44.16 210.44,44.16 210.11,44.49 208.67,44.49 208.08,45.08 205.34,45.08 203.69,46.73 202.55,46.73 200.46,48.81 199.58,48.81 188.03,60.37 188.03,62.37 186.45,63.94 186.45,68.31 178.01,76.75 178.01,85.16 176.15,87.02 164.61,87.02 161.44,90.19 160.48,90.19 159.25,91.42 153.89,91.42 152.61,92.7 143.89,92.7 142.8,91.61 138.93,91.61 137.79,92.76 129.22,92.76 127.77,91.31 125.22,91.31 124.97,91.05 124.97,90.82 v1(125.17,90.62)
  BOTTOM w0.076: UC1.A19 130,73.65 130.08,73.73 130.08,73.88 130,73.96 129.72,73.96 129.64,74.04 129.64,77.01 129.14,77.52 129.14,77.53 129.12,77.55
  BOTTOM w0.094: 129.12,77.55 128.47,78.2 126.93,78.2 125.88,77.16 124.39,77.16 123.86,77.69 123.86,80.11 123.25,80.72 123.25,81.86 123.6,82.22 123.6,82.75 123.25,83.1 123.25,86.53 124.98,88.27 124.98,90.43 v1(125.17,90.62)
PCIE_PTX_DRX_P8: length 186.6
  TOP w0.094: v1(270.79,30.61) 270.67,30.49 270.67,29.91 CZ11.1
  IN4 w0.089: v1(270.79,30.61) 270.79,30.07 270.56,29.84 268.71,29.84 267.9,30.65 266.88,30.65 265.97,31.57 257.51,31.57 257.13,31.18 249.61,31.18 248.32,29.89 247.2,29.89 244.91,32.18 241.33,32.18 240.95,31.79 233,31.79 232.16,32.63 227.56,32.63 227.13,33.06 224.56,33.06 224.03,32.53 220.73,32.53 220.3,32.1 218.29,32.1 217.66,31.47 213.11,31.47 209.89,34.69 207.7,34.69 203.86,38.53 202.37,38.53 200.59,40.31 198.33,40.31 192.31,46.33 191.14,46.33 190.76,46.71 190.76,47.88 189.31,49.33 189.31,53.26 183.64,58.93 183.64,61.59 177.25,67.99 174.4,67.99 173.31,69.08 172.59,69.08 167.7,73.96 164.72,73.96 162.49,76.2 158.75,76.2 155.08,79.87 153.2,79.87 152.22,80.85 150.79,80.85 150.19,80.25 146.66,80.25 145.19,78.78 143.7,78.78 143.12,79.37 140.63,79.37 139.18,80.82 136.45,80.82 134.47,82.81 132.03,82.81 130.85,81.63 130.28,81.63 127.16,78.51 127.16,76.12 127.91,75.36 128.04,75.36 v1(128.3,75.62)
  BOTTOM w0.076: v1(128.3,75.62) 128.35,75.62 128.64,75.33 128.64,74.22 128.25,73.84 128.25,73.54 128.27,73.48 128.27,73.16 128.25,73.1 128.25,72.91 128.31,72.74 128.37,72.68 128.68,72.68 128.76,72.61 128.76,72.41 128.7,72.35 UC1.C21
PCIE_PTX_DRX_P11: length 163.9
  TOP w0.094: v1(236.6,33.57) 236.23,33.21 236.23,32.35 239.2,29.38 239.2,28.7 240.92,26.97 240.92,26.61 v4(241.34,26.19) 241.61,25.93 241.61,25.9 241.7,25.8 241.96,25.8 242.04,25.88 242.36,25.88 CN22.1
  IN4 w0.089: v1(125.22,75.21) 124.94,75.49 124.46,75.49 124.03,75.92 124.03,78.3 126.87,81.15 126.87,82.54 129.47,85.14 142.22,85.14 145.14,82.22 149.26,82.22 149.92,82.88 155.43,82.88 158.3,80.01 162.21,80.01 162.66,80.45 164.46,80.45 165.87,79.04 168.58,79.04 171.2,76.43 171.2,73.93 175.24,69.89 178.04,69.89 185.8,62.13 185.8,59.51 191.47,53.84 191.47,50.69 199.93,42.24 202.85,42.24 204.15,40.94 205.11,40.94 207.09,38.96 209.05,38.96 210.13,37.87 210.57,37.87 213.59,34.84 216.97,34.84 217.91,35.79 226.06,35.79 226.22,35.63 232.32,35.63 233.28,34.67 234.85,34.67 235.21,34.31 236.05,34.31 236.38,33.98 236.38,33.8 v1(236.6,33.57)
  BOTTOM w0.076: v1(125.22,75.21) 125.35,75.34 125.88,75.34 126.35,74.86 126.35,73.2 126.5,73.05 126.5,72.99 126.3,72.79 126.3,72.5 126.41,72.38 126.51,72.38 126.6,72.47 UC1.C24
PCIE_PTX_DRX_P12: length 151.9
  TOP w0.094: CN32.1 231.56,23.53 231.41,23.38 231.19,23.38 231.07,23.5 231.07,24.35 230.8,24.63 230.8,24.76 v1(231.05,25.02)
  IN4 w0.076: v1(122.58,74.65) 122.16,75.07 121.92,75.07 121.68,74.83 121.68,74.14 124.38,71.44 124.38,69.53 125.07,68.83 128.28,68.83 128.74,68.37 131.7,68.37
  IN4 w0.089: 131.7,68.37 131.7,68.38 133.47,68.38 134.02,67.82 134.52,67.82 134.6,67.74 135.11,67.74 135.55,68.18 138.04,68.18 142.22,72.36 144.53,72.36 145.5,71.4 145.5,70.76 146.64,69.62 151.31,69.62 152.33,70.63 159.21,70.63 160.4,69.45 164.91,69.45 165.45,68.91 167.47,68.91 171.13,65.24 171.72,65.24 174.69,62.27 174.69,61.54 175.62,60.61 176.95,60.61 178.29,59.28 178.29,58.72 185,52.01 185,45.94 190.12,40.82 191.37,40.82 192.31,39.87 192.31,38.45 192.81,37.95 194.64,37.95 198.99,33.6 200.33,33.6 203.15,30.78 203.87,30.78 205.71,28.94 205.71,28.43 206.3,27.84 209.66,27.84 210.67,28.85 214.89,28.85 215.42,28.32 216.97,28.32 217.15,28.5 221.85,28.5 223.6,26.74 223.6,26.49 223.7,26.39 230.25,26.39 230.65,25.99 230.65,25.42 v1(231.05,25.02)
  BOTTOM w0.076: v1(122.58,74.65) 125.37,74.65 125.62,74.4 125.62,73.66 125.8,73.49 125.8,73.24 UC1.B25
PCIE_PTX_RD_DRX_N11: length 43.1
  TOP w0.094: UN4.17 250.76,24.18 251.2,24.63 252.07,24.63 252.47,24.23 252.47,23.26 252.82,22.92 252.82,20.39 252.82,19.71 253.34,19.19 v4(253.34,18.02) 253.34,16.89 252.4,15.96 252.4,14.75 v1(252.33,14.68)
  IN1 w0.089: v1(252.33,14.68) 252.72,14.29 252.72,12.68 253.45,11.96 254,11.96 254.86,11.1 254.86,10.52 256.6,8.78 256.6,7.78 257.34,7.03 259.26,7.03 259.87,7.64 259.87,8.3 260.19,8.62 260.85,8.62 262.18,9.95 263.45,9.95 264.22,10.71 266.91,10.71 269.05,12.86 272.71,12.86 272.98,13.13 272.98,13.67 v1(273.06,13.76)
  BOTTOM w0.094: CN69.2 273.06,13.18 v1(273.06,13.76)
PCIE_PTX_RD_DRX_N12: length 30.6
  TOP w0.094: UN5.17 238.65,22.83 238.81,22.99 238.98,22.99 239.2,23.21 239.2,24.04 239.33,24.18 240.92,24.18 241.4,23.69 241.4,23.41 v1(241.21,23.23)
  BOTTOM w0.094: CN71.2 257.2,10.26 256.94,10.26 256.69,10.51 256.69,11.4 256.29,11.8 253.45,11.8 253.3,11.8 252.58,12.51 251.05,12.51 250.5,13.07 250.5,15.23 250.09,15.64 250.09,16.11 249.62,16.57 247.6,16.57 246.88,17.29 246.88,18.67 246.2,19.35 v4(245.55,19.35) 244.91,19.35 243.64,20.62 243.64,21.76 243.14,22.27 242.14,22.27 241.99,22.42 241.65,22.42 241.45,22.62 241.45,22.99 v1(241.21,23.23)
PCIE_PTX_RD_DRX_P11: length 43.1
  TOP w0.094: v1(252.92,14.68) 252.59,15 252.59,15.88 253.52,16.81 253.52,17.65 253.55,17.68 253.55,18.32 253.52,18.36 253.52,19.26 253,19.78 253,20.32 253,22.99 252.66,23.34 252.66,24.3 252.15,24.81 251.13,24.81 250.68,24.37 250.53,24.37 250.22,24.68 UN4.18
  IN1 w0.089: v1(272.48,13.76) 272.8,13.44 272.8,13.2 272.63,13.04 268.98,13.04 266.83,10.9 264.14,10.9 263.38,10.13 262.11,10.13 260.77,8.8 260.11,8.8 259.69,8.38 259.69,7.72 259.19,7.21 257.42,7.21 256.78,7.85 256.78,8.85 255.04,10.59 255.04,11.17 254.07,12.14 253.52,12.14 252.91,12.75 252.91,14.67 v1(252.92,14.68)
  BOTTOM w0.094: v1(272.48,13.76) 272.48,13.4 CN70.2
PCIE_PTX_RD_DRX_P12: length 30.6
  TOP w0.094: UN5.18 238.65,23.33 238.81,23.17 238.9,23.17 239.01,23.28 239.01,24.12 239.25,24.36 240.99,24.36 241.58,23.77 241.58,23.44 v1(241.8,23.23)
  BOTTOM w0.094: v1(241.8,23.23) 241.63,23.06 241.63,22.7 241.73,22.6 242.07,22.6 242.21,22.45 243.21,22.45 243.83,21.84 243.83,20.7 244.99,19.54 245.22,19.54 245.25,19.57 245.84,19.57 245.87,19.54 246.28,19.54 247.07,18.75 247.07,17.37 247.67,16.76 249.7,16.76 250.27,16.19 250.27,15.71 250.68,15.31 250.68,13.15 251.13,12.7 252.66,12.7 253.37,11.98 256.36,11.98 256.87,11.47 256.87,10.59 257.01,10.45 257.17,10.45 CN72.2
PCIE_RCOMPN: length 10.4
  TOP w0.381: v1(137.5,70.61) 137.86,70.61 138.79,71.54 139.26,71.54 139.88,72.16 139.88,74.05 v2(140.95,75.12) 141.58,75.75 141.58,77.35 141.16,77.78 140.9,77.78 RC45.1
  BOTTOM w0.305: UC1.F5 137.83,70.28 v1(137.5,70.61)
PCIE_RCOMPP: length 7.6
  TOP w0.381: v1(137.48,71.2) 138.58,72.29 138.58,72.78 139.2,73.4 139.2,74.33 v2(139.55,74.69) 140.9,76.03 RC45.2
  BOTTOM w0.305: UC1.E5 137.94,70.95 137.5,71.16 v1(137.48,71.2)
PCIE_WAKE#: length 144.2
  TOP w0.102: RE275.1 RE274.1 271.58,40.42 v1(271.55,40.38)
  IN1 w0.089: v1(274.63,33.63) 274.5,33.63 274.17,33.96 272.72,33.96 271.76,32.99 271.76,32.76 270.88,31.89 269.41,31.89 269.4,31.87 268.03,31.87 267.77,32.13 264.39,32.13 263.86,31.59 261.84,31.59 261.09,30.85 261.09,30.46 260.11,29.49 256.24,29.49 255.45,30.27 254.49,30.27 253.42,29.21 253.42,28.62 251.91,27.11 251.84,27.11 250.92,26.19 250.92,25.03 250.65,24.76 249.46,24.76 249.13,25.09 247.82,25.09 247.32,24.59 247.32,24.49 246.68,23.85 246.02,23.85 245.62,23.45 v1(245.04,23.45) 243.33,23.45 242.84,22.96 242.11,22.96 241.92,22.77 240.99,22.77 240.81,22.59 240.48,22.59 239.78,23.29 239.78,24.2 238.97,25.01 238.11,25.01 237.65,25.47 234.9,25.47 234.89,25.49 229.74,25.49 229.65,25.4 226,25.4 225.65,25.04 224.36,25.04 224.09,24.76 222.45,24.76 222.22,24.53 220.74,24.53 220.5,24.76 218.53,24.76 216.57,22.8 215.91,22.8 v1(215.42,22.3) 212.68,22.3 v1(212.4,22.02)
  IN3 w0.122: v1(266.25,1.95) 266.04,1.75 247.07,1.75 246.63,2.19 246.63,11.26 246.1,11.78 246.1,13.46 245.86,13.7 244.11,13.7 243.72,14.09 242.47,14.09 240.92,15.65 240.92,17.01 241.1,17.19 241.1,17.7 240.85,17.95 240.21,17.95 239.83,18.33 239.83,18.93 240.59,19.69 240.59,20.49 241.08,20.98 241.58,20.98 242.24,21.64 242.24,22.02 242.63,22.4 243.98,22.4 v1(245.04,23.45)
  BOTTOM w0.102: v1(266.25,1.95) 266.25,3.09 266.68,3.53 267.72,3.53 267.85,3.4 JNGFF3.54 ; v1(212.4,22.02) 212.39,22.03 212.39,24.77 212.11,25.05 211.03,25.05 210.98,25 JNGFF1.55 ; v1(274.63,33.63) 274.27,33.63 272.41,35.48 272.18,35.48 272,35.66 JNGFF2.54 272,37.55 271.55,38 v1(271.55,40.38) ; v1(215.42,22.3) 215.91,22.3 216.96,21.25 JNGFF1.70
