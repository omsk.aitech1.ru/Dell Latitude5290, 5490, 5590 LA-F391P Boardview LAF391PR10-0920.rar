# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS#7: length 98.1
  IN4 w0.076: v1(128.34,55.08) 128.34,55.19 128.12,55.41 128,55.41 127.88,55.28 127.88,54.75 127.97,54.65 127.97,53.64 131.01,50.6 131.01,50.25 131.22,50.04 131.23,50.04 131.26,50.01 131.27,50.01 131.28,50
  IN4 w0.091: 131.28,50 131.78,49.5 132.19,49.5 132.92,50.24 140.26,50.24 141.19,49.31 142.05,49.31 142.55,48.81 143.36,48.81 147.15,45.03 153.9,45.03 154.14,45.28 159.44,45.28 159.5,45.21 168.3,45.21 168.76,44.75 174.12,44.75 189.87,29.01 190.56,29.01 191.91,27.65 191.91,25.68 192.77,24.82 192.77,20.82 194.37,19.23 194.37,17.32 194.24,17.19 194.24,16.05 193.92,15.73 193.92,15.4 193.73,15.21 193.73,14.46 193.97,14.22 194.19,14.22 194.45,14.48 194.45,14.69 v1(194.38,14.76)
  BOTTOM w0.076: UC1.AR22 127.98,55.44 v1(128.34,55.08)
  BOTTOM w0.099: v1(194.38,14.76) 194.08,14.46 193.92,14.46 193.48,14.02 193.48,13.57 193.92,13.12 193.92,11.8 JDIMM2.240
DDR_B_MA0: length 91.4
  IN4 w0.076: v1(111.68,41.45) 110.8,40.57 110.8,40.13
  IN4 w0.142: v1(168.16,13.13) 167.52,12.49 165.59,12.49 165.03,13.05 165.03,14.4 165.54,14.91 165.54,15.52 165.28,15.77 165.28,16.3 164.62,16.97 164.62,18.52 162.94,20.2 162.14,20.2 160.55,21.79 156.03,21.79 155.77,22.05 155.77,22.46 155.55,22.68 151.96,22.68 151.47,23.17 139.4,23.17 138.96,22.73 132.36,22.73 127.43,27.65 119.57,27.65 113.99,33.24 112.32,33.24 111.52,34.05 111.52,35.77 110.8,36.48 110.8,40.13
  BOTTOM w0.076: UC1.BA46 114.82,51.5 115.09,51.23 115.09,50.01 114.61,49.53 114.61,47.3 114.35,47.04 114.35,45.52
  BOTTOM w0.168: JDIMM2.144 167.92,12.9 v1(168.16,13.13) ; 114.35,45.52 114.35,43.5 112.3,41.45 v1(111.68,41.45)
DDR_B_MA1: length 91.9
  IN4 w0.142: v1(112.42,43.74) 112.57,43.89 112.75,43.89 112.88,43.76 112.88,41.6 111.64,40.36 111.64,36.83 112.7,35.77 112.7,35.57 112.38,35.25 112.38,35.05 112.58,34.85 112.78,34.85 113.1,35.17 113.3,35.17 113.51,34.97 113.51,34.77 113.22,34.48 113.22,34.25 113.39,34.08 113.62,34.08 113.91,34.37 114.11,34.37 119.98,28.5 128.29,28.5 133.21,23.57 137.24,23.57 137.72,24.05 138.1,24.05 138.4,23.75 138.78,23.75 139.08,24.05 151.78,24.05 152.31,23.53 160.01,23.53 160.28,23.26 160.74,23.26 161,23.53 161.36,23.53 161.69,23.2 161.69,22.93 161.62,22.85 161.62,22.65 161.82,22.44 162.03,22.44 162.11,22.53 162.35,22.53 162.6,22.29 162.6,22 162.19,21.59 162.19,21.35 162.36,21.18 162.66,21.18 163.31,21.82 163.55,21.82 163.73,21.64 163.73,21.25 163.5,21.03 163.5,20.83 163.94,20.39 164.15,20.39 164.32,20.57 164.32,20.93 164.55,21.15 164.88,21.15 165.24,20.8 165.24,20.52 165.05,20.33 165.05,20.08 165.24,19.89 165.24,19.09 165.57,18.76 v1(165.57,18.49)
  BOTTOM w0.076: UC1.AY46 114.72,52.07 114.62,51.97 114.56,51.78 114.56,51.59 114.59,51.46 114.59,51.21 114.56,51.13 114.56,50.87 114.73,50.69 114.73,50.15 114.1,49.52 114.1,47.54 113.59,47.04 113.59,45.8 113.32,45.53 113.32,45.52
  BOTTOM w0.168: v1(165.57,18.49) 165.57,18.32 164.95,17.7 164.77,17.7 164.6,17.88 164.6,18.49 165.17,19.07 JDIMM2.133 ; v1(112.42,43.74) 112.65,43.51 112.88,43.51 113.32,43.95 113.32,45.52
DDR_B_MA2: length 91.8
  IN4 w0.076: v1(112.42,44.37) 112.42,44.3 112.02,43.9 112.02,42.8 111.15,41.93 111.15,41.38 110.38,40.6 110.38,40.13
  IN4 w0.142: 110.38,40.13 110.38,36.31 111.09,35.59 111.09,34.76 110.78,34.44 110.78,34.19 112.15,32.82 113.81,32.82 119.4,27.23 127.26,27.23 132.18,22.31 139.13,22.31 139.55,22.73 151.32,22.73 151.78,22.26 152.85,22.26 152.99,22.12 152.99,21.54 153.15,21.37 153.48,21.37 153.64,21.54 153.64,22.1 153.81,22.26 154.05,22.26 154.21,22.1 154.21,21.54 154.38,21.37 154.61,21.37 154.78,21.54 154.78,22.1 154.95,22.26 155.18,22.26 155.35,22.1 155.35,21.54 155.52,21.37 160.37,21.37 162,19.74 162.79,19.74 164.19,18.34 164.19,15.27 164.42,15.05 164.66,15.05 v1(164.92,15.31)
  BOTTOM w0.076: 112.86,45.52 112.86,45.61 113.33,46.08 113.33,47.16 113.9,47.72 113.9,49.56 114.57,50.23 114.57,50.62 114.39,50.8 114.39,51.17 114.41,51.2 114.43,51.25 114.43,51.43 114.39,51.55 114.39,51.81 114.43,51.91 114.43,52.34 UC1.AY47
  BOTTOM w0.168: v1(112.42,44.37) 112.86,44.82 112.86,45.52 ; v1(164.92,15.31) JDIMM2.132
DDR_B_MA3: length 90.4
  IN4 w0.076: 111.22,40.13 111.22,40.46 112.29,41.53 v1(112.29,42.47)
  IN4 w0.142: v1(165.57,16.96) 165.04,17.49 165.04,18.69 164.62,19.11 164.62,19.35 164.75,19.49 164.75,19.78 164.57,19.96 164.37,19.96 164.16,19.76 163.98,19.76 163.11,20.62 162.32,20.62 160.73,22.21 159.77,22.21 159.61,22.38 159.61,22.94 159.44,23.11 159.21,23.11 159.04,22.94 159.04,22.38 158.87,22.21 158.64,22.21 158.47,22.38 158.47,22.94 158.3,23.11 158.07,23.11 157.9,22.94 157.9,22.38 157.73,22.21 157.5,22.21 157.33,22.38 157.33,22.94 157.17,23.11 156.93,23.11 156.76,22.94 156.76,22.38 156.6,22.21 156.36,22.21 156.19,22.38 156.19,22.94 156.03,23.11 152.13,23.11 151.63,23.61 139.24,23.61 138.78,23.15 138.38,23.15 138.1,23.44 137.7,23.44 137.42,23.15 133.04,23.15 128.11,28.08 119.75,28.08 114.16,33.66 112.5,33.66 111.94,34.22 111.94,35.94 111.22,36.66 111.22,40.13
  BOTTOM w0.076: UC1.BB46 114.93,50.92 114.93,50.1 114.36,49.53 114.36,49.32
  BOTTOM w0.168: JDIMM2.131 164.68,19.07 164.27,18.66 164.27,17.34 164.65,16.96 v1(165.57,16.96) ; v1(112.29,42.47) 112.44,42.61 112.58,42.61 113.84,43.88 113.84,45.52 113.97,45.65 113.97,47.04 114.36,47.42 114.36,49.32
DDR_B_MA4: length 91.3
  IN4 w0.076: v1(112.46,45.82) 112.21,45.57 112.2,45.57 111.56,44.93 111.56,43.1 110.49,42.03 110.49,41.25 109.53,40.29 109.53,40.13
  IN4 w0.142: 109.53,40.13 109.46,40.06 109.46,38.08 109.47,38.07 109.47,34.3 111.8,31.97 113.46,31.97 119.05,26.39 126.91,26.39 131.83,21.47 139.52,21.47 139.91,21.85 151,21.85 152.33,20.53 160.02,20.53 161.72,18.82 162.24,18.82 162.62,18.45 162.62,14.78 162.78,14.62 162.78,12.21 162.92,12.07 163.25,12.07 163.39,12.21 163.39,13.67 v1(163.75,14.03)
  BOTTOM w0.076: v1(112.46,45.82) 113.03,46.39 113.03,47.24 113.67,47.88 113.67,50.49 113.93,50.75 113.93,51.16 113.89,51.25 113.89,51.45 113.93,51.53 113.93,51.54 113.93,51.54 113.94,51.55 113.94,51.77 UC1.BA47
  BOTTOM w0.168: v1(163.75,14.03) 164.3,13.47 164.3,13.08 163.92,12.71 JDIMM2.128
DDR_B_MA5: length 91.5
  IN4 w0.076: v1(112.62,47.07) 112.89,46.8 112.89,45.73 112.56,45.4 112.27,45.4 111.79,44.92 111.79,42.95 110.93,42.08 110.93,41.41 109.95,40.44 109.95,40.13
  IN4 w0.142: 109.95,40.13 109.95,35.64 110.03,35.56 110.53,35.56 110.67,35.42 110.67,35.18 110.53,35.04 110.03,35.04 109.89,34.89 109.89,34.48 111.97,32.39 113.64,32.39 119.22,26.81 127.08,26.81 132.01,21.89 139.31,21.89 139.7,22.28 151.16,22.28 152.5,20.95 160.2,20.95 160.94,20.2 160.94,20.2 161.79,19.35 161.84,19.31 162.63,19.31 163.32,18.62 163.32,18.35 163.04,18.07 163.04,17.84 163.3,17.58 163.3,17.33 163.04,17.07 163.04,16.77 163.35,16.46 163.35,16.21 163.04,15.9 163.04,15.41 163.23,15.22 163.63,15.22 163.75,15.34 v1(163.75,15.86)
  BOTTOM w0.076: v1(112.62,47.07) 112.62,47.14 113.47,47.99 113.47,50.57 113.76,50.87 113.76,51.12 113.73,51.21 113.73,51.48 113.76,51.57 113.76,51.77 113.73,51.86 113.7,51.96 113.7,52.12 UC1.AY48
  BOTTOM w0.168: JDIMM2.126 163.42,12.74 163.29,12.88 163.29,14.26 162.89,14.65 162.89,15.44 163.31,15.86 v1(163.75,15.86)
DDR_B_MA6: length 90.9
  IN4 w0.142: v1(112.62,48.95) 112.81,49.13 112.81,49.32 112.6,49.53 112.27,49.53 111.36,48.61 111.36,48.32 111.5,48.17 111.88,48.17 112.02,48.03 112.02,47.79 111.88,47.65 111.07,47.65 110.94,47.52 110.94,47.16 111.11,47 111.62,47 111.79,46.83 111.79,46.59 111.62,46.43 111.11,46.43 110.94,46.26 110.94,43.22 109.99,42.26 109.99,41.53 108.34,39.88 108.34,34.24 111.45,31.13 113.11,31.13 118.7,25.55 126.56,25.55 131.53,20.58 149.79,20.58 150.04,20.33 150.94,20.33 151.59,19.68 159.66,19.68 161.05,18.29 161.05,17.37 161.75,16.68 161.75,16.31 v1(162.17,15.88)
  BOTTOM w0.076: UC1.BA48 113.5,51.44 112.98,50.92 112.98,50.73 113.06,50.65 113.06,50.1 112.96,50 112.96,49.28 v1(112.62,48.95)
  BOTTOM w0.168: JDIMM2.127 163.68,19.06 163.22,18.6 163.2,18.6 163.2,18.6 163.2,18.08 163.4,17.88 163.4,16.86 162.42,15.88 v1(162.17,15.88)
DDR_B_MA7: length 94.5
  IN4 w0.076: 112.55,50.37 112.55,52.86 112.32,53.09 112.32,53.85 112.6,54.13 112.95,54.13 113.16,54.34 113.16,55.98 v1(112.79,56.35)
  IN4 w0.142: v1(162.17,14.36) 162.17,13.29 162.06,13.18 161.65,13.18 161.32,13.5 161.32,16.5 160.63,17.2 160.63,18.11 159.48,19.26 151.41,19.26 150.77,19.9 149.84,19.9 149.58,20.16 131.35,20.16 126.38,25.12 118.52,25.12 112.94,30.71 111.28,30.71 107.92,34.06 107.92,40.07 109.7,41.85 109.7,47.52 112.55,50.37
  BOTTOM w0.076: v1(112.79,56.35) 113.05,56.09 UC1.AP48
  BOTTOM w0.168: JDIMM2.122 162.42,14.1 v1(162.17,14.36)
DDR_B_MA8: length 89.3
  IN4 w0.076: 109.04,40.13 110.21,41.3 110.21,42.13 111.36,43.28 111.36,45.23 112.15,46.02 112.15,47.31 v1(112.62,47.77)
  IN4 w0.142: v1(162.17,17.58) 161.91,17.32 161.7,17.32 161.47,17.55 161.47,18.47 159.84,20.1 151.76,20.1 151.42,20.44 151.42,20.83 151.26,21 150.91,21 150.65,20.75 150.22,20.75 149.97,21 149.66,21 149.49,21.17 149.49,21.26 149.32,21.43 149.09,21.43 148.92,21.26 148.92,21.17 148.75,21 148.52,21 148.35,21.17 148.35,21.26 148.19,21.43 147.95,21.43 147.78,21.26 147.78,21.17 147.62,21 147.38,21 147.21,21.17 147.21,21.26 147.05,21.43 146.81,21.43 146.65,21.26 146.65,21.17 146.48,21 146.24,21 146.08,21.17 146.08,21.26 145.91,21.43 145.67,21.43 145.51,21.26 145.51,21.17 145.34,21 145.1,21 144.94,21.17 144.94,21.26 144.77,21.43 144.54,21.43 144.37,21.26 144.37,21.17 144.2,21 143.97,21 143.8,21.17 143.8,21.26 143.63,21.43 143.4,21.43 143.23,21.26 143.23,21.17 143.06,21 142.83,21 142.66,21.17 142.66,21.26 142.5,21.43 142.26,21.43 142.09,21.26 142.09,21.17 141.93,21 141.69,21 141.52,21.17 141.52,21.26 141.36,21.43 141.12,21.43 140.96,21.26 140.96,21.17 140.79,21 131.7,21 126.73,25.97 118.87,25.97 113.29,31.55 111.62,31.55 108.76,34.41 108.76,34.84 109.05,35.12 109.05,35.51 108.76,35.79 108.76,36.04 109.05,36.32 109.05,36.67 108.76,36.96 108.76,37.23 109.05,37.51 109.05,37.82 108.76,38.1 108.76,38.35 109.03,38.62 109.03,39.04 108.76,39.31 108.76,39.71 109.01,39.96 109.01,40.1 109.04,40.13
  BOTTOM w0.076: v1(112.62,47.77) 113.26,48.42 113.26,50.6 113.5,50.83 UC1.BB48
  BOTTOM w0.168: v1(162.17,17.58) 162.17,17.38 162.59,16.96 162.84,16.96 163,17.12 163,17.8 162.78,18.02 162.78,18.84 163.17,19.24 JDIMM2.125
DDR_B_MA9: length 90.4
  IN4 w0.076: v1(111.88,55.71) 112.25,55.34 112.25,54.29 111.91,53.95 111.91,52.7 110.62,51.41
  IN4 w0.142: v1(160.44,16.19) 159.74,16.88 159.74,17.53 158.86,18.42 151.06,18.42 150.42,19.06 149.41,19.06 149.16,19.31 131,19.31 126.03,24.28 118.17,24.28 112.59,29.86 110.93,29.86 107.08,33.71 107.08,41.08 108.34,42.34 108.34,47.36 110.62,49.64 110.62,51.41
  BOTTOM w0.076: UC1.AP50 v1(111.88,55.71)
  BOTTOM w0.168: JDIMM2.121 162.17,19.12 161.52,18.47 161.52,17.26 160.44,16.19 v1(160.44,16.19)
DDR_B_MA10: length 91.2
  IN4 w0.076: v1(115.13,45.56) 114.76,45.19 114.76,44.69 114.6,44.52 114.6,40.43 114.3,40.13
  IN4 w0.142: v1(169.89,13.08) 170.28,13.08 170.49,12.87 170.49,12.62 170.22,12.35 168.98,12.35 168.63,12.7 168.63,14.23 168.41,14.44 168.41,16.51 168.82,16.92 168.82,18.51 168.17,19.16 168.17,22.22 164.33,26.06 154.4,26.06 153.85,26.61 135.54,26.61 134.45,27.7 132.84,27.7 129.52,31.02 121.12,31.02 114.27,37.87 114.27,40.11 114.3,40.13
  BOTTOM w0.076: 114.68,45.87 114.68,46.98 114.86,47.16 114.86,49.55 115.26,49.94 115.26,51.66 115.02,51.9 115.02,52.39 114.91,52.6 114.72,52.79 UC1.AW46
  BOTTOM w0.102: 114.68,45.87 114.99,45.56 v1(115.13,45.56)
  BOTTOM w0.168: v1(169.89,13.08) 170.43,12.55 JDIMM2.146
DDR_B_MA11: length 93.8
  IN4 w0.076: v1(112.8,57.12) 112.41,56.74 112.41,54.2 112.15,53.94 112.15,53.02 112.16,53.01 112.16,52.57 111.64,52.05
  IN4 w0.142: v1(160.72,14.77) 160.9,14.95 160.9,16.33 160.21,17.02 160.21,17.94 159.3,18.84 151.24,18.84 150.59,19.48 149.66,19.48 149.41,19.73 131.18,19.73 126.21,24.7 118.35,24.7 112.76,30.29 111.1,30.29 107.5,33.89 107.5,40.9 108.76,42.17 108.76,47.22 111.04,49.5 111.04,50.66 111.33,50.95 112.04,50.95 112.25,51.15 112.25,51.41 112.07,51.58 111.76,51.58 111.64,51.71 111.64,52.05
  BOTTOM w0.076: UC1.AN48 113.19,56.74 v1(112.8,57.12)
  BOTTOM w0.168: JDIMM2.120 161.93,12.57 161.58,12.92 161.58,14.47 161.27,14.77 v1(160.72,14.77)
DDR_B_MA12: length 94.8
  IN4 w0.076: 110.55,53.39 110.6,53.44 110.6,55.86 111.73,57 v1(111.88,57)
  IN4 w0.142: 110.55,53.39 110.04,52.88 110.04,52.24 108.57,50.78 108.57,49.77 106.48,47.67 106.48,42.61 105.81,41.94 105.81,33.19 110.45,28.55 112.11,28.55 118.25,22.42 119.04,22.42 120.71,20.75 120.71,20.67 123.66,17.72 128.18,17.72 128.85,17.05 132.53,17.05 132.9,16.68 132.9,16.18 133.41,15.67 136.81,15.67 137.23,15.25 145.34,15.25 145.87,15.77 150.37,15.77 150.93,16.34 154.66,16.34 155.47,17.15 157.11,17.15 157.7,16.56 158.55,16.56 159.26,15.85 v1(159.55,15.85)
  BOTTOM w0.076: UC1.AN50 112.14,56.74 v1(111.88,57)
  BOTTOM w0.168: v1(159.55,15.85) 159.55,16.13 161.1,17.68 161.1,18.68 161.68,19.26 JDIMM2.119
DDR_B_MA13: length 89.9
  IN4 w0.142: v1(116.66,47.08) 117.87,47.08 118.16,46.79 118.16,43.26 118.87,42.55 118.87,41.59 118.99,41.47 118.99,39.77 122.76,36 132.76,36 137.48,31.29 145.58,31.29 145.84,31.55 155.53,31.55 156.34,30.74 167.33,30.74 169.14,28.93 169.65,28.93 174.65,23.92 174.65,17.06 174.19,16.6 174.19,16.16 174.43,15.92 174.43,14.35 v1(173.9,13.83)
  BOTTOM w0.076: UC1.BA43 116.75,51.77 116.75,51.53 116.76,51.5 116.8,51.4 116.8,51.29 116.75,51.16 116.75,50.9 116.75,50.9 116.75,50.77 116.88,50.63 116.88,50.25 116.51,49.88 116.51,49.7 116.1,49.29 116.1,47.93 116.3,47.73 116.3,47.44
  BOTTOM w0.102: 116.3,47.44 v1(116.66,47.08)
  BOTTOM w0.168: v1(173.9,13.83) 173.43,13.35 JDIMM2.158
DDR_B_MA14: length 92.3
  IN4 w0.142: v1(116.69,45.03) 117.04,45.39 117.28,45.39 117.47,45.19 117.47,44.82 117.15,44.5 117.15,44.19 117.47,43.86 117.47,42.8 117.97,42.3 117.97,41.35 118.15,41.17 118.15,39.42 122.45,35.12 132.45,35.12 137.13,30.44 145.93,30.44 146.19,30.7 151.13,30.7 151.4,30.44 155.44,30.44 155.99,29.89 166.99,29.89 168.79,28.08 169.3,28.08 173.81,23.58 173.81,22.14 173.54,21.87 173.54,21.46 173.81,21.19 173.81,19.04 173.54,18.77 173.54,18.4 173.81,18.13 173.81,17.84 173.31,17.34 173.31,16.23 173.08,16 172.75,16 172.21,16.54 171.85,16.54 v1(171.63,16.76)
  BOTTOM w0.076: UC1.AY44 115.95,52.08 116.05,51.98 116.05,51.97 116.13,51.75 116.13,51.62 116.06,51.39 116.06,51.25 116.12,51.13 116.12,50.86 115.92,50.66 115.92,49.6 115.77,49.45 115.77,47.64 115.93,47.48 115.93,45.97 116.01,45.89
  BOTTOM w0.168: 116.01,45.89 116.01,44.88 116.13,44.75 116.41,44.75 v1(116.69,45.03) ; JDIMM2.151 171.68,19.18 172.14,18.72 172.14,16.99 171.91,16.76 v1(171.63,16.76)
DDR_B_MA15: length 94.1
  IN4 w0.142: v1(172.39,14.73) 172.9,14.22 173.38,14.22 173.74,14.58 173.74,16.83 174.23,17.32 174.23,23.75 169.47,28.51 168.97,28.51 167.16,30.31 156.17,30.31 155.35,31.13 155.15,31.13 154.89,30.86 154.72,30.86 154.45,31.13 154.22,31.13 153.95,30.86 153.67,30.86 153.41,31.13 153.15,31.13 152.89,30.86 152.63,30.86 152.36,31.13 152.09,31.13 151.83,30.86 151.57,30.86 151.31,31.13 146.02,31.13 145.76,30.86 137.3,30.86 132.62,35.54 122.62,35.54 118.57,39.6 118.57,41.29 118.34,41.52 118.34,42.62 117.76,43.2 117.76,46.5 117.58,46.68 117.33,46.68 117.15,46.5 117.15,46.02 116.87,45.75 v1(116.68,45.75)
  BOTTOM w0.076: UC1.AY43 116.32,52.36 116.32,52.25 116.25,52.1 116.25,51.91 116.3,51.76 116.3,51.61 116.24,51.39 116.24,51.28 116.28,51.16 116.28,50.79 116.1,50.6 116.1,49.52 115.93,49.36 115.93,47.77 116.11,47.59 116.11,47.23
  BOTTOM w0.102: v1(116.68,45.75) 116.11,46.32 116.11,47.23
  BOTTOM w0.168: v1(172.39,14.73) 172.92,14.2 172.92,11.8 JDIMM2.156
DDR_B_MA16: length 91.8
  IN4 w0.076: 115.55,41.42 115.55,46.44 v1(115.13,46.86)
  IN4 w0.142: v1(172.35,13.19) 172.72,13.19 172.93,12.98 172.93,12.65 172.72,12.44 171.68,12.44 171.47,12.65 171.47,13.22 170.47,14.22 170.47,15.4 170.21,15.67 170.21,19.08 170.58,19.45 170.58,23.18 168.79,24.96 168.29,24.96 165.92,27.33 154.93,27.33 154.38,27.88 136.06,27.88 134.98,28.96 133.37,28.96 129.78,32.56 121.38,32.56 115.55,38.39 115.55,41.42
  BOTTOM w0.076: UC1.AW44 115.95,52.81 115.79,52.65 115.68,52.43 115.66,52.37 115.66,51.9 115.42,51.66 115.42,49.85 115.13,49.56 v1(115.13,46.86)
  BOTTOM w0.168: v1(172.35,13.19) 171.92,12.76 171.92,11.8 JDIMM2.152
DDR_B_ODT0: length 94.1
  IN4 w0.142: v1(172.88,16.94) 172.55,17.27 171.54,17.27 171.28,17.52 171.28,18.64 171.65,19.01 171.65,23.62 169.23,26.04 168.73,26.04 166.37,28.4 155.37,28.4 154.82,28.95 136.51,28.95 135.42,30.03 133.81,30.03 130.22,33.63 121.83,33.63 116.65,38.8 116.65,41.87 116.39,42.14 116.39,42.79 115.97,43.21 115.97,49.67 116.26,49.96 116.64,49.96 117.1,50.42 117.8,50.42 118.13,50.08 118.13,48 117.93,47.8 117.35,47.8 117.15,48 117.15,48.55 v1(116.54,49.16)
  BOTTOM w0.076: v1(116.54,49.16) 116.79,49.41 116.79,49.91 117.05,50.17 117.05,50.7 116.91,50.84 116.91,50.92 116.91,50.92 116.91,51.13 116.95,51.23 117.18,51.46 UC1.BA42
  BOTTOM w0.168: v1(172.88,16.94) 172.65,16.94 172.44,17.14 172.44,18.77 172.68,19 JDIMM2.155
DDR_B_ODT1: length 95.4
  IN4 w0.076: 115.78,42.57 115.73,42.62 115.73,50.34 116.32,50.93 116.32,52.43 116.43,52.54 116.43,53.09 116.29,53.23 v1(116.29,53.72)
  IN4 w0.142: v1(173.03,15.54) 172.78,15.29 171.89,15.29 171.76,15.16 171.76,14.49 171.57,14.3 171.31,14.3 171.12,14.49 171.12,15.79 170.86,16.06 170.86,18.81 171.23,19.18 171.23,23.45 169.06,25.61 168.55,25.61 166.19,27.98 155.2,27.98 154.65,28.53 136.33,28.53 135.25,29.61 133.64,29.61 130.05,33.21 121.65,33.21 116.21,38.65 116.21,41.7 116.01,41.9 116.01,42.34 115.78,42.57
  BOTTOM w0.076: UC1.AW42 117.18,53.4 116.86,53.72 v1(116.29,53.72)
  BOTTOM w0.168: v1(173.03,15.54) 174.18,16.69 JDIMM2.161
DDR_B_PARITY: length 95.3
  IN4 w0.076: v1(115.57,55.73) 115.57,55.68 115.92,55.33 115.92,50.94 115.45,50.47 115.45,47.78 114.6,46.92 114.6,44.84 114.43,44.68 114.43,40.6 113.84,40
  IN4 w0.142: 113.84,40 113.84,37.71 120.94,30.6 129.35,30.6 132.67,27.28 134.28,27.28 134.55,27.01 134.55,26.82 134.01,26.28 134.01,26 134.2,25.81 134.48,25.81 134.86,26.19 153.68,26.19 154.23,25.64 162.62,25.64 162.79,25.47 162.79,25.07 162.96,24.9 163.19,24.9 163.36,25.07 163.36,25.47 163.53,25.64 164.15,25.64 164.43,25.36 164.43,25.13 163.84,24.53 163.84,24.3 164.01,24.13 164.24,24.13 164.83,24.72 165.07,24.72 165.24,24.56 165.24,24.32 165.14,24.23 165.14,23.99 165.31,23.83 165.55,23.83 165.64,23.92 165.88,23.92 166.04,23.75 166.04,23.52 165.95,23.42 165.95,23.19 166.12,23.02 166.35,23.02 166.44,23.11 166.68,23.11 166.85,22.95 166.85,22.71 166.72,22.59 166.72,22.35 166.89,22.18 167.12,22.18 167.25,22.31 167.48,22.31 167.56,22.24 167.56,22.23 167.75,22.04 167.75,21.29 167.61,21.15 167.51,21.15 167.37,21.01 167.37,20.77 167.51,20.63 167.61,20.63 167.75,20.48 167.75,20.24 167.57,20.06 167.57,19.86 167.75,19.68 167.75,18.98 168.39,18.34 v1(168.39,17.95)
  BOTTOM w0.076: v1(115.57,55.73) 115.93,56.09 UC1.AP43
  BOTTOM w0.168: JDIMM2.143 167.68,19.24 168.05,18.87 168.05,18.61 167.5,18.06 167.5,17.77 167.78,17.48 168.07,17.48 168.39,17.8 v1(168.39,17.95)
DDR_DRAMRST#: length 133
  TOP w0.102: RD12.2 51.3,12.55 50.94,12.2 RD11.2 50.81,11.69 v1(49.92,11.69) v2(49.41,11.69)
  IN1 w0.089: v1(65.46,39.04) 65.46,36.62 52,23.16 51.03,23.16 47.15,19.28 47.15,13.36 48.82,11.69 v1(49.92,11.69)
  IN2 w0.122: v1(133.86,54.46) 133.73,54.46 133.37,54.82 133.37,55.33 133.09,55.61 132.77,55.61 132.45,55.29 132.45,54.9 132.01,54.45 132.01,53.82 131.98,53.79 131.98,51.1 131.78,50.9 131.78,49.07 136.33,44.52 136.33,41.96 135.82,41.45 135.82,40.69 131.63,36.5 74.6,36.5 72.06,39.04 v1(65.46,39.04)
  BOTTOM w0.076: UC1.AT13 133.7,54.46 v1(133.86,54.46)
DDR_DRAMRST#_R: length 121.6
  TOP w0.102: v1(49.75,12.32) 49.18,12.32 v2(48.47,13.04) ; CD61.1 142.79,10.67 v1(142.79,10.44)
  TOP w0.305: v1(49.75,12.32) 50.05,12.32 50.38,12.66 RD12.1 50.38,12.91 51.01,13.54 51.01,13.9 CD29.1
  IN3 w0.122: v1(159.12,10.49) 158.57,11.04 143.39,11.04 v1(142.79,10.44) 142.13,11.1 126.67,11.1 125.79,10.21 122.36,10.21 121.47,11.1 120.45,11.1 119.94,10.59 117.28,10.59 116.41,11.45 116.01,11.45 115.35,12.11 90.73,12.11 90.12,11.5 78.34,11.5 v1(77.18,10.34) 76.49,11.03 51.31,11.03 50.01,12.32 v1(49.75,12.32)
  BOTTOM w0.102: JDIMM2.108 158.93,10.69 v1(159.12,10.49)
  BOTTOM w0.305: v1(77.18,10.34) 77.18,10.67 76.93,10.93 JDIMM1.108
DDR_VTT_CTRL: length 79.6
  TOP w0.102: UD1.2 48.84,29.2 48.62,28.97 47.52,28.97 v1(47.43,28.88) ; v1(96.5,52.47) 96.95,52.02 99.41,52.02 99.64,51.78 99.64,50.6 97.48,48.44 97.48,47.62 97.31,47.44 97.31,44.37 96.3,43.35 90.96,43.35 88.5,45.82 v2(75.65,45.82) 75.29,45.46 v1(70.92,45.46)
  IN1 w0.089: v1(70.92,45.46) 70.57,45.11 69.24,45.11 62.92,38.78 62.92,37.13 54.67,28.88 v1(47.43,28.88)
  BOTTOM w0.076: 96.75,52.22 97.75,52.22 97.82,52.29 98.21,52.29 98.75,52.83 99.59,52.83 99.85,53.09 101.19,53.09 101.22,53.07 101.85,53.07 101.95,52.97 UC1.AW67
  BOTTOM w0.102: 96.75,52.22 v1(96.5,52.47)
DDR_XDP_WAN_SMBCLK: length 511.6
  TOP w0.102: QC2.1 158.24,66.03 158.94,66.73 158.94,68.65 RC319.1 158.91,68.74 163.85,68.74 165.06,67.53 166.97,67.53 168.08,66.43 168.08,65.58 167.62,65.12 167.62,63.25 167.21,62.85 167.21,61.38 166.68,60.85 166.68,52.73 165.18,51.23 161.68,51.23 160.05,49.6 160.05,45.46 161.12,44.4 164.62,44.4 166.3,42.72 v3(173.11,42.72) 179.25,42.72 181.13,40.84 182.58,40.84 182.81,41.07 v1(182.81,41.3)
  IN1 w0.089: v1(198.28,14.99) 197.95,14.99 195.54,12.58 131.61,12.58 126.53,17.65 117.3,17.65 116.84,17.19 116.45,17.19 v1(116.02,17.63)
  IN3 w0.122: v1(90.49,99.93) 90.53,99.97 90.53,100.53 89.34,101.72 84.74,101.72 81.36,105.11 69.64,105.11 67.48,102.95 66.74,102.95 66.13,102.34 64.83,102.34 62.31,99.82 55.63,99.82 54.04,98.22 49.59,98.22 47.17,95.8 47.17,93.26 42.73,88.82 42.73,82.22 42.12,81.61 40.67,81.61 39.38,80.32 32.88,80.32 29.83,77.27 25.69,77.27 24.46,78.5 21.56,78.5 21.13,78.07 21.13,76.47 20.45,75.79 20.45,68.19 18.21,65.95 18.21,56.41 19.99,54.63 19.99,42.8 20.68,42.11 20.95,42.11 v1(21.01,42.18)
  IN4 w0.089: v1(21.01,42.18) 20.96,42.13 20.13,42.13 19.26,41.25 19.26,35.66 18.25,34.66 18.25,22.87 19.58,21.55 22.72,21.55 26.64,17.63 26.64,16.62 30.59,12.66 46.85,12.66 48.95,10.56 51.37,10.56 52.03,11.22 73.01,11.22 73.46,10.77 102.61,10.77 102.83,10.99 117.08,10.99 119.46,13.38 119.46,16.91 118.74,17.63 v1(116.02,17.63) ; v1(245.03,12.2) 244.7,12.2 243.31,13.59 240.97,13.59 240.68,13.88 233.23,13.88 232.52,14.59 229.76,14.59 228.85,15.5 220.97,15.5 218.68,13.22 215.35,13.22 215.02,12.89 201.37,12.89 199.26,14.99 v1(198.28,14.99) 197.77,15.5 197.77,19.55 198.66,20.44 198.66,22.93 197.97,23.62 197.39,23.62 196.32,24.69 196.32,27.81 189.23,34.91 187.85,34.91 186.17,36.58 186.17,37.3 185.34,38.13 185.34,39.28 184.31,40.31 183.39,40.31 182.81,40.89 v1(182.81,41.3)
  BOTTOM w0.102: JDIMM2.253 197.18,19.07 197.27,18.98 197.27,16.9 198.28,15.9 v1(198.28,14.99) ; LGA1.1 244.76,11.93 v1(245.03,12.2) ; JXDP1.53 90.14,99.17 90.16,99.19 90.16,99.44 90.49,99.77 v1(90.49,99.93) ; JDIMM1.253 115.18,18.47 v1(116.02,17.63)
DDR_XDP_WAN_SMBDAT: length 513.3
  TOP w0.102: QC2.4 155.9,67.42 155.9,68.08 RC318.1 156.61,68.8 156.99,68.8 157.42,69.22 164.05,69.22 165.26,68.02 167.17,68.02 168.56,66.63 168.56,65.38 168.1,64.92 168.1,63.05 167.7,62.65 167.7,61.18 167.16,60.65 167.16,52.53 165.38,50.75 161.88,50.75 160.53,49.4 160.53,45.66 161.32,44.88 164.82,44.88 166.5,43.2 179.45,43.2 181.33,41.32 v1(182.2,41.32)
  IN1 w0.089: v1(116.2,16.32) 116.6,16.72 117.03,16.72 117.5,17.18 126.34,17.18 131.41,12.11 195.74,12.11 198,14.37 v1(198.28,14.37)
  IN3 w0.122: v1(91.07,99.93) 91.03,99.96 91.03,100.74 89.54,102.23 84.95,102.23 81.56,105.61 69.44,105.61 67.28,103.45 66.53,103.45 65.92,102.84 64.62,102.84 62.1,100.32 55.42,100.32 53.83,98.73 49.38,98.73 46.67,96.01 46.67,93.47 42.22,89.03 42.22,82.42 41.91,82.11 40.47,82.11 39.18,80.82 32.67,80.82 29.62,77.77 25.9,77.77 24.67,79 21.35,79 20.63,78.28 20.63,76.68 19.95,76 19.95,68.4 17.71,66.16 17.71,56.21 19.49,54.42 19.49,42.59 20.47,41.61 20.99,41.61 v1(21.01,41.59)
  IN4 w0.089: v1(21.01,41.59) 20.94,41.66 20.33,41.66 19.73,41.06 19.73,35.47 18.72,34.46 18.72,23.06 19.77,22.02 22.92,22.02 27.11,17.83 27.11,16.81 30.79,13.13 47.05,13.13 49.14,11.03 51.17,11.03 51.83,11.69 73.21,11.69 73.66,11.24 102.42,11.24 102.64,11.46 116.88,11.46 118.99,13.57 118.99,16.72 118.54,17.16 116.38,17.16 116.2,16.97 v1(116.2,16.32) ; v1(246.56,12.19) 246,11.63 244.6,11.63 243.12,13.12 240.78,13.12 240.48,13.41 233.04,13.41 232.33,14.12 229.57,14.12 228.66,15.03 221.16,15.03 218.87,12.75 215.55,12.75 215.22,12.42 201.17,12.42 199.22,14.37 v1(198.28,14.37) 198.23,14.37 197.3,15.31 197.3,19.75 198.19,20.64 198.19,22.74 197.78,23.15 197.2,23.15 195.85,24.49 195.85,27.62 189.03,34.44 187.66,34.44 185.7,36.39 185.7,37.1 184.87,37.94 184.87,39.09 184.12,39.84 183.2,39.84 182.2,40.84 v1(182.2,41.32)
  BOTTOM w0.102: v1(246.56,12.19) 246.26,11.88 LGA1.4 ; v1(198.28,14.37) 197.43,13.52 JDIMM2.254 ; JXDP1.51 90.64,99.24 90.97,99.57 90.97,99.83 v1(91.07,99.93) ; v1(116.2,16.32) 116.2,14.94 115.43,14.17 JDIMM1.254
DEBUG_TX: length 4.9
  TOP w0.102: RE30.2 233.02,11.79 RE74.2 233.84,11.62 233.84,11.9 v1(233.66,12.07) 233.66,12.33 v3(234.21,12.87)
  BOTTOM w0.102: v1(233.66,12.07) 233.42,12.32 JDEG1.9
DEW1: length 4.8
  TOP w0.102: UN7.16 227.56,19.43 227.89,19.1 227.89,18.44 RN17.2 RN16.2 228.38,16.67 v2(229.16,15.88)
DEW2: length 6
  TOP w0.102: UN7.6 223,23.12 RN14.2 222.38,24.65 222.42,24.65 RN15.2 222.59,25.32 222.5,25.32 222.03,25.79 v2(222.03,26.17)
DGPU_PWROK: length 5.5
  TOP w0.076: UE1.M4 261.62,45.41 v1(261.98,45.77)
  BOTTOM w0.102: v1(261.98,45.77) 262.58,45.77 264.54,43.81 264.54,42.54 T147.1
DIMM1_SA0: length 6.6
  TOP w0.102: RD4.2 RD5.1 117.79,13.9 v1(117.65,14.04) 116.89,14.04 v2(116.7,13.85)
  BOTTOM w0.102: v1(117.65,14.04) 116.18,14.04 115.8,13.66 115.8,12.98 115.93,12.86 115.93,11.8 JDIMM1.256
DIMM1_SA1: length 4.6
  TOP w0.102: RD6.2 RD7.1 117.99,13.03 v1(117.66,13.36) 117.4,13.1 v2(117.4,12.44)
  BOTTOM w0.102: v1(117.66,13.36) 117.66,13.31 116.93,12.57 JDIMM1.260
DIMM1_SA2: length 5.3
  TOP w0.102: v2(95.27,10.1) 94.95,10.1 v1(94.73,10.32) 94.73,10.95 RD8.2 RD9.1
  BOTTOM w0.102: JDIMM1.166 93.43,10.72 93.83,10.32 v1(94.73,10.32)
DIMM2_SA0: length 15.8
  BOTTOM w0.102: JDIMM2.256 197.93,10.84 198.43,10.33 199.92,10.33 201.1,11.51 201.1,13.13 202.4,14.44 205.24,14.44 205.91,15.11 205.91,15.53 RD20.2 206.45,16.16 207.27,16.98 RD21.1 207.31,17.36 v2(206.72,17.95)
DIMM2_SA1: length 12
  BOTTOM w0.102: v2(205.43,15.11) 205.57,15.25 RD22.2 205.57,16.06 RD23.1 203.52,16.06 200.73,13.27 200.73,11.59 199.72,10.59 199.18,10.59 198.93,10.84 JDIMM2.260
DIMM2_SA2: length 4.5
  TOP w0.102: v2(174.97,11.36) RD25.1 ; RD25.1 175.99,10.67 v1(175.73,10.42) ; RD25.1 RD24.2
  BOTTOM w0.102: JDIMM2.166 175.43,10.72 v1(175.73,10.42)
DISP_ON: length 6.1
  TOP w0.102: v1(70.03,93.57) 70.61,93 70.61,92.5 DV2.1 69.6,92.5 RV2.1
  BOTTOM w0.102: JEDP1.22 69.84,94.85 v2(70.1,94.6) 70.1,93.63 v1(70.03,93.57)
DMIC0: length 352.9
  TOP w0.102: UA1.4 261.34,21.05 v1(260.82,20.53) 260.71,20.42 258.42,20.42 RA62.2 ; CA6.1 67.36,102.28 v1(67.29,102.35)
  IN2 w0.122: v1(220.02,31.14) 219.68,30.8 217.7,30.8 217,31.5 212.25,31.5 210.55,33.19 205.67,33.19 205.5,33.03 184.17,33.03 180.76,29.63 174,29.63 173.37,30.25 155.2,30.25 153.01,28.07 143.74,28.07 137.09,34.72 97.64,34.72 97.08,34.16 72.11,34.16 71.16,35.11 66.02,35.11 59.69,41.45 v1(59.62,41.45)
  IN3 w0.122: v1(59.62,41.45) 53.78,35.61 48.19,35.61 46.54,37.26 45.85,37.26 42.54,40.57 42.54,41.8 42.42,41.93 39.63,41.93 38.03,43.53 38.03,48.13 37.68,48.48 37.68,57.97 42.88,63.17 44.87,63.17 47.15,65.45 50.35,65.45 52.57,67.67 52.57,70.47 53.21,71.11 53.21,80.12 53.67,80.59 53.67,83.38 55.14,84.85 55.14,85.96 50.09,91 50.09,94.15 51.49,95.55 54.75,95.55 56.68,97.48 62.04,97.48 62.5,97.94 63.89,97.94 65.46,99.51 65.46,100.96 66.85,102.35 v1(67.29,102.35)
  IN4 w0.089: v1(260.82,20.53) 260.89,20.6 260.89,20.67 263.71,23.49 263.71,24.15 265.71,26.16 266.07,26.16 267.01,27.1 267.01,28.24 265.61,29.64 262.56,29.64 261.7,30.5 261.18,30.5 260.62,29.94 254.36,29.94 254.13,29.71 253.19,29.71 252.65,30.26 250.52,30.26 249.92,29.66 249.31,29.66 248.56,28.91 248.19,28.91 247.69,28.41 244.98,25.7 242.87,25.7 242.58,25.99 242.15,25.99 239.58,28.57 239.58,29.76 238.43,30.91 235.77,30.91 235.3,30.44 232.43,30.44 232.01,30.86 223.47,30.86 223.19,31.14 v1(220.02,31.14)
  BOTTOM w0.102: JEDP1.7 v1(67.29,102.35)
DMIC_CLK0: length 313.1
  TOP w0.102: CA5.1 67.84,101.35 v1(67.29,101.35) ; v1(258.88,19.73) 258.78,19.83 CA54.1 258.64,19.33 259.16,19.33 RA14.1 ; v1(196.73,33.88) v2(197.26,33.88)
  IN2 w0.122: v1(196.73,33.88) 196.13,33.28 184.06,33.28 180.69,29.9 174.07,29.9 173.48,30.5 155.1,30.5 152.91,28.32 144.1,28.32 137.39,35.02 71.95,35.02 71.47,35.51 66.53,35.51 59.75,42.29 59.11,42.29 54.21,47.19 52.83,47.19 52.12,47.9 48.42,47.9 46.79,49.53 46.79,56.59 44.68,58.7 44.05,58.7 42.68,60.07 41.1,60.07 39.6,61.57 39.6,67.1 39.17,67.53 39.17,69.63 v1(39.54,70)
  IN4 w0.089: v1(196.73,33.88) 198.81,31.8 200.13,31.8 202.32,29.61 202.32,28.88 206.05,25.14 209.45,25.14 210.63,23.97 212.44,23.97 213.78,25.3 219.21,25.3 219.96,24.55 221.45,24.55 223.6,22.4 226.75,22.4 227.8,21.34 234.21,21.34 234.37,21.51 238.87,21.51 240.73,19.65 247.2,19.65 248.54,18.31 248.9,18.31 249.2,18 250.02,18 250.16,17.87 253.14,17.87 254.49,19.21 258.36,19.21 v1(258.88,19.73) ; v1(39.54,70) 39.84,70 44.18,74.34 46.07,74.34 50.64,78.91 55.81,78.91 57.84,80.95 57.84,82.28 60.38,84.82 60.38,98.34 64.19,102.15 66.6,102.15 67.29,101.47 v1(67.29,101.35)
  BOTTOM w0.102: JEDP1.9 v1(67.29,101.35)
DMIC_CLK0_CODEC: length 3.6
  TOP w0.102: UA1.5 261.55,20.65 260.79,19.88 RA14.2 260.63,19.83 260.1,19.3 259.45,19.3 v2(259.07,18.92)
EC_FPM_EN: length 72.3
  TOP w0.102: JUSH1.22 261.6,10.96 261.59,10.98 v1(261.59,11.01) ; v1(263.55,52.12) 263.22,51.78 UE1.D6
  IN2 w0.122: v1(261.59,11.01) 261.59,11.83 259.99,13.43 259.99,15.65 261.48,17.14 261.48,18.3 262.71,19.53 263.25,19.53 263.66,19.94 263.66,24.52 267.86,28.73 272.88,28.73 273.35,29.19 274.69,29.19 277.37,31.87 277.37,32.83 277.61,33.07 279.42,33.07 280.95,34.6 280.95,36.21 280.37,36.79 v1(280.32,36.79)
  BOTTOM w0.102: v1(280.32,36.79) 280.21,36.79 277.94,39.05 277.94,41.8 278.85,42.7 278.85,44.27 276.81,46.3 276.81,49.55 274.25,52.12 269.3,52.12 v3(269.04,51.86) 268.61,51.86 268.23,51.48 266.88,51.48 266.4,51.96 265.97,51.96 265.41,52.52 263.96,52.52 v1(263.55,52.12)
EDP_AUXN: length 68.1
  IN4 w0.089: v1(114.4,71.4) 114.63,71.17 114.79,71.17 114.94,71.32 114.94,71.73 113.78,72.88 109.46,72.88 108.72,73.63 107.78,73.63 107.34,74.06 107.34,74.42 103.79,77.98 103.79,78.64 103.15,79.27 103.15,81.76 102.83,82.08 102.83,88.65 100.48,91 93.76,91 93.43,91.33 93.43,91.34 92.67,92.09 89.21,92.09 88.45,91.33 86.31,91.33 84.26,89.28 76.64,89.28 76.08,88.72 74.83,88.72 74.6,88.49 72.47,88.49 71.76,89.2 71.76,93.14 72.5,93.87 v1(73.26,93.87)
  BOTTOM w0.076: UC1.E45 114.87,70.93 v1(114.4,71.4)
  BOTTOM w0.094: v1(73.26,93.87) 73.04,93.65 72.82,93.65 CV1.1
EDP_AUXN_C: length 6.9
  BOTTOM w0.094: JEDP1.33 69.12,89.35 69.23,89.24 69.37,89.24 69.46,89.33 69.46,92.28 70.09,92.9 70.09,92.95 v4(70.38,93.24) 70.82,93.68 71.18,93.68 CV1.2
EDP_AUXP: length 68
  IN4 w0.089: v1(114.59,70.54) 114.59,70.72 115.12,71.25 115.12,71.8 113.86,73.06 109.54,73.06 108.79,73.81 107.85,73.81 107.52,74.14 107.52,74.49 103.97,78.05 103.97,78.71 103.33,79.35 103.33,81.83 103.01,82.15 103.01,88.72 100.55,91.18 93.83,91.18 93.61,91.41 92.74,92.27 89.13,92.27 88.37,91.51 86.24,91.51 84.18,89.46 76.56,89.46 76,88.9 74.76,88.9 74.53,88.67 72.55,88.67 71.94,89.28 71.94,93.06 72.57,93.69 72.83,93.69 72.97,93.56 72.97,93.38 73.11,93.24 v1(73.26,93.24)
  BOTTOM w0.076: UC1.F45 v1(114.59,70.54)
  BOTTOM w0.094: CV2.1 72.78,93.47 73.03,93.47 v1(73.26,93.24)
EDP_AUXP_C: length 7
  BOTTOM w0.094: JEDP1.34 69.12,88.85 69.32,89.05 69.44,89.05 69.65,89.25 69.65,92.2 70.32,92.87 70.32,92.87 70.74,93.3 70.74,93.3 70.77,93.32 70.77,93.37 70.9,93.49 71.18,93.49 CV2.2
EDP_BIA_PWM: length 106.5
  TOP w0.102: v1(71.72,95.47) 72.12,95.87 DV1.3
  IN1 w0.076: 124.96,66.72 122.99,66.72
  IN1 w0.089: 124.96,66.72 125.35,66.72 126.37,65.7 126.37,64.13 126.83,63.67 127.66,63.67 127.85,63.86 132.83,63.86 133.58,64.61 134.13,64.61 134.2,64.68 134.44,64.68 134.92,65.17 v1(134.92,65.24) ; 122.99,66.72 115.16,66.72 114.32,67.56 114.32,68.4 113.91,68.8 107.19,68.8 106.48,69.52 106.48,70.4 105.95,70.94 105.95,71.34 106.54,71.94 106.54,75.18 103.64,78.09 103.64,78.53 103.04,79.13 103.04,82.15 101.77,83.42 101.77,88.33 100.08,90.01 86.57,90.01 83.51,86.95 82.14,86.95 81.1,85.92 75.29,85.92 75,85.62 74.62,85.62 71.68,82.69 v1(70.2,82.69)
  IN2 w0.122: v1(70.2,82.69) 70.62,82.69 70.93,83 70.93,84.38 71.94,85.38 71.94,86.05 73.87,87.98 73.87,91.97 71.72,94.12 v1(71.72,95.47)
  BOTTOM w0.076: UC1.R11 134.62,65.54 v1(134.92,65.24)
EDP_COMP: length 14.3
  TOP w0.127: v1(111.04,70.57) 110.55,71.07 110.55,71.42 108.95,73.01 108.95,75.28 108.84,75.39 108.84,76.3 109.37,76.83 110.78,76.83 111.18,77.23 111.18,78.64 v2(111.83,79.29) 111.83,80.25 RC2.1
  BOTTOM w0.076: UC1.E52 111.4,70.93 v1(111.04,70.57)
EDP_HPD: length 108.4
  TOP w0.102: RV7.1 66.6,92.25 v1(65.97,92.88) 64.7,91.61 64.7,90.66 65.54,89.82 65.56,89.82 66.48,88.91 66.48,88.88 67.49,87.87 67.49,85.11 68.18,84.43 68.18,83.44 v2(68.58,83.03) 69.75,83.03 70.93,84.2 v1(71.52,84.2) ; v1(135.59,67.22) 135.17,66.8 RC1.1
  IN1 w0.089: v1(135.59,67.22) 135.38,67.22 134.82,66.67 134.82,66.17 134.58,65.93 133.59,65.93 133.21,65.55 127.93,65.55 125.84,67.65 123.31,67.65 123.11,67.85 123.11,68.76 122.38,69.49 116.92,69.49 116.13,70.28 116.13,71.41 115.78,71.76 115.05,71.76 114.89,71.93 113.64,71.93 113.31,71.6 112.78,71.6 112.64,71.74 108.96,71.74 107.62,73.07 107.62,75.43 104.56,78.49 104.56,78.88 103.9,79.54 103.9,82.51 102.63,83.78 102.63,88.71 100.44,90.9 93.32,90.9 92.74,91.47 89.4,91.47 88.71,90.79 86.02,90.79 83.43,88.2 82.46,88.2 80.85,86.58 75.04,86.58 74.73,86.27 74.35,86.27 72.28,84.2 v1(71.52,84.2)
  BOTTOM w0.076: UC1.L10 v1(135.59,67.22)
  BOTTOM w0.102: v1(65.97,92.88) 66.45,92.4 66.76,92.4 67.2,92.85 JEDP1.26
EDP_TXN0: length 64.2
  IN4 w0.089: v1(73.13,91.49) 72.88,91.74 72.7,91.74 72.57,91.62 72.57,89.58 72.91,89.24 74.16,89.24 75.06,90.14 75.87,90.14 75.97,90.04 83.95,90.04 86.01,92.1 88.15,92.1 88.91,92.86 92.97,92.86 94.06,91.77 100.78,91.77 103.6,88.95 103.6,82.51 103.92,82.19 103.92,79.57 104.55,78.94 104.55,78.28 108.03,74.8 108.88,74.8 109.97,73.71 111.55,73.71 112.26,74.42 113.42,74.42 113.56,74.57 113.56,74.7 v1(113.33,74.93)
  BOTTOM w0.076: UC1.C47 113.81,72.19 113.91,72.19 114,72.28 114,72.44 113.9,72.54 113.9,72.79 113.94,72.84 113.94,73.78 113.51,74.21 113.51,74.75 v1(113.33,74.93)
  BOTTOM w0.094: v1(73.13,91.49) 72.92,91.7 72.78,91.7 CV4.1
EDP_TXN0_C: length 6.6
  BOTTOM w0.094: CV4.2 71.18,91.71 70.89,91.71 70.86,91.68 70.38,91.68 70.29,91.58 v4(70.29,90.57) 70.29,90.25 70.28,90.24 70.28,88.68 69.61,88.01 69.35,88.01 69.19,87.85 JEDP1.36
EDP_TXN1: length 65.1
  IN4 w0.089: v1(113.53,76.43) 113.75,76.65 113.75,76.89 113.67,76.96 113.04,76.96 112.7,76.63 112.7,75.89 112.02,75.21 108.18,75.21 105.36,78.02 105.36,78.84 105.06,79.14 104.91,79.14 104.32,79.73 104.32,80.46 104.53,80.67 104.53,83.03 104,83.55 104,89.1 102.41,90.69 102.41,91.84 102.09,92.17 94.21,92.17 93.13,93.25 87.32,93.25 86.57,92.5 85.86,92.5 83.8,90.45 76.23,90.45 75.6,91.08 74.83,91.08 73.66,89.91 73.49,89.91 v1(73.28,89.71)
  BOTTOM w0.076: 113.9,75.8 113.91,75.79 114.25,75.79 114.25,75.79 114.29,75.75 114.3,75.75 114.44,75.61 114.46,75.61 114.61,75.47 114.61,74.55 115.04,74.11 115.04,73.54 115.01,73.44 115.01,73.19 115.04,73.1 115.04,72.91 114.98,72.73 114.91,72.66 114.67,72.66 114.43,72.42 114.43,72.24 UC1.D46
  BOTTOM w0.094: CV6.1 72.88,89.96 73.03,89.96 v1(73.28,89.71) ; v1(113.53,76.43) 113.72,76.24 113.72,75.98 113.9,75.8
EDP_TXN1_C: length 5.6
  BOTTOM w0.094: JEDP1.38 69.19,86.85 69.35,87.01 69.62,87.01 v4(70.32,87.71) 70.93,88.33 70.93,88.62 70.98,88.67 70.98,89.26 70.93,89.32 70.93,89.89 70.98,89.94 71.23,89.94 CV6.2
EDP_TXP0: length 64.2
  IN4 w0.089: v1(73.13,92.07) 72.98,91.92 72.62,91.92 72.39,91.69 72.39,89.51 72.84,89.06 74.24,89.06 75.14,89.96 75.8,89.96 75.9,89.86 84.03,89.86 86.08,91.92 88.22,91.92 88.98,92.68 92.89,92.68 93.98,91.59 100.71,91.59 103.42,88.88 103.42,82.43 103.74,82.12 103.74,79.5 104.37,78.86 104.37,78.2 107.95,74.62 108.81,74.62 109.9,73.53 111.62,73.53 112.34,74.24 113.49,74.24 113.74,74.49 113.74,74.76 v1(113.91,74.93)
  BOTTOM w0.076: UC1.C46 114.11,72.78 114.11,73.85 113.68,74.28 113.68,74.69 v1(113.91,74.93)
  BOTTOM w0.094: v1(73.13,92.07) 72.94,91.89 72.81,91.89 CV3.1
EDP_TXP0_C: length 6.6
  BOTTOM w0.094: CV3.2 71.18,91.89 v4(70.57,91.89) 70.3,91.89 70.1,91.69 70.1,90.9 70.07,90.87 70.07,90.27 70.1,90.24 70.1,88.76 69.53,88.19 69.35,88.19 69.19,88.35 JEDP1.35
EDP_TXP1: length 65.1
  IN4 w0.089: v1(114.11,76.45) 114.11,76.57 113.93,76.75 113.93,76.96 113.75,77.14 112.96,77.14 112.52,76.7 112.52,75.97 111.94,75.39 108.26,75.39 105.54,78.1 105.54,78.91 105.13,79.32 104.98,79.32 104.5,79.8 104.5,80.39 104.71,80.59 104.71,83.1 104.18,83.62 104.18,89.18 102.59,90.77 102.59,91.92 102.16,92.35 94.29,92.35 93.21,93.43 87.24,93.43 86.49,92.68 85.78,92.68 83.72,90.63 76.3,90.63 75.67,91.26 74.75,91.26 73.59,90.09 73.48,90.09 v1(73.28,90.29)
  BOTTOM w0.076: 114.51,75.8 114.77,75.54 114.77,74.62 115.21,74.18 115.21,73.51 115.17,73.42 115.17,73.22 115.21,73.13 115.21,72.89 115.08,72.46 115.08,72.22 115.02,72.16 114.84,72.16 114.78,72.22 UC1.C45
  BOTTOM w0.094: v1(73.28,90.29) 73.14,90.15 72.81,90.15 CV5.1 ; 114.51,75.8 114.44,75.87 114.44,75.88 114.35,75.98 113.99,75.98 113.91,76.06 113.91,76.25 v1(114.11,76.45)
EDP_TXP1_C: length 5.5
  BOTTOM w0.094: JEDP1.37 69.19,87.35 69.35,87.19 69.54,87.19 69.95,87.61 69.95,87.65 70.74,88.44 70.74,88.69 v4(70.74,88.95) 70.74,89.96 70.9,90.12 71.23,90.12 CV5.2
EDRAM_OPIO_RCOMP: length 11.5
  TOP w0.381: v1(102.36,69.31) 101.95,69.31 99.05,66.41 99.05,64.88 v3(98.33,64.16) 97.42,63.24 RC90.1
  BOTTOM w0.254: UC1.H66 102.62,69.04 v1(102.36,69.31)
EMMC_RCOMP: length 11.3
  BOTTOM w0.203: UC1.AT1 140.81,54.89 140.98,55.06 141.28,55.06
  BOTTOM w0.381: 141.28,55.06 142.75,55.06 142.93,54.89 144.29,54.89 144.87,54.31 v2(148.4,54.31) 151.15,54.31 RC4.1
EN_0.6V: length 10.3
  TOP w0.102: v1(58.01,57.01) 58.22,56.8 58.22,56.34 v2(58.28,56.28) 58.6,55.95 PC222.1 58.6,54.46 PR212.1 58.6,54.03 58.79,53.83 58.79,52.56 58.67,52.43 58.67,51.48 58.54,51.36 PR210.2
  BOTTOM w0.102: v1(58.01,57.01) 57.75,57.01 56.78,57.98 PU200.2
EN_1.0V_PRIM_COREP: length 5.4
  TOP w0.102: PR406.2 174.63,96.64 v2(174.92,96.35)
  TOP w0.254: v1(173.44,96.64) 173.23,96.64 172.85,97.02 PC411.1 172.88,97.33 PR407.1 PR406.2
  BOTTOM w0.254: v1(173.44,96.64) 173.45,96.65 PU402.13
EN_1.2V: length 6
  TOP w0.102: PR208.2 59.57,55.87 60.18,55.27 v2(60.46,55.27)
  TOP w0.203: PR208.2 59.22,56.1 PR209.1 59.21,56.74 PC221.1 59.09,57.6 v1(58.6,57.12)
  BOTTOM w0.203: v1(58.6,57.12) 58.25,57.48 57.74,57.48 57.23,57.99 PU200.1
EN_1.8VALW: length 4.8
  TOP w0.102: v2(174.58,105.64) v1(174.58,106.15) 173.61,107.11 PR504.2 173.31,107.11 PC505.1 172.42,107.1 PR505.1
  BOTTOM w0.102: v1(174.58,106.15) PU501.1
EN_1VS_VCCIO: length 4.6
  TOP w0.102: PR402.2 PR403.1 PC402.1 176.89,48.74 v1(176.46,48.31) 176.08,48.31 v2(175.75,48.64)
  BOTTOM w0.102: v1(176.46,48.31) 176.15,48.31 175.97,48.49 PU401.13
EN_2.5V: length 4.7
  TOP w0.102: v2(217.63,10.97) 217.77,11.11 PR513.2
  TOP w0.254: PR513.2 PR514.1 PC513.1 220.59,11.74 220.09,12.25 PU503.5
EN_+1VALWP: length 2.9
  TOP w0.102: v2(162.51,106.41) 162.78,106.14 v1(163.22,106.14)
  TOP w0.254: v1(163.22,106.14) 163.49,106.14 PR302.1 164.16,107.69 PR312.2
EN_INVPWR: length 234.3
  TOP w0.076: 257.23,55.09 257.64,54.68 258.22,54.68 259.09,53.81 259.55,53.81 UE1.B2
  TOP w0.102: 257.23,55.09 RE55.1 256.58,55.74 256.58,57.21 v1(255.07,58.72) ; QV2.2 80,95.92 80.75,95.92 82.33,97.49 v1(82.33,99.49)
  IN1 w0.089: v1(82.33,99.49) 82.88,100.05 84.81,100.05 85.38,99.48 92.86,99.48 93.32,99.95 99.34,99.95 99.81,99.48 103.27,99.48 103.56,99.77 104.32,99.77 104.8,99.28 104.8,98.93 105.53,98.21 107.03,98.21 110.09,95.14 122.2,95.14 124,96.95 156.68,96.95 157.92,95.7 163.35,95.7 169.04,90.01 175.72,90.01 v1(175.87,90.17)
  IN3 w0.122: v1(175.87,90.17) 178.21,87.83 178.21,77.58 185.46,70.32 185.46,64.02 186.27,63.21 186.27,60.13 199.37,47.02 203.14,47.02 207.53,42.64 208.97,42.64 208.98,42.65 216.85,42.65 217.97,41.53 219.78,41.53 220.9,42.64 225.72,42.64 226.51,43.44 229.46,43.44 230.03,44 235.12,44 237.67,46.55 238.99,46.55 240.28,47.84 241.47,47.84 242.42,48.79 242.42,49.04 242.9,49.53 243.11,49.53 244.76,51.18 247.17,51.18 247.83,51.84 249.08,51.84 251.26,54.02 251.26,54.3 255.07,58.11 v1(255.07,58.72)
  BOTTOM w0.102: v1(255.07,58.72) v2(256.17,58.72)
EN_LCDPWR: length 8.3
  TOP w0.102: v2(75.99,88.46) 74.81,88.46 74.64,88.63 UV24.4 74.64,89.55 74.25,89.94 74.25,90.55 RV3.2 75.77,90.98 75.89,91.1 75.89,92.37 75.18,93.08 DV3.1
EN_PD_HV_1: length 66.9
  TOP w0.102: RT70.2 32.9,66.47 v1(33.33,66.47) ; PR1211.1 40.9,74.97 v1(40.9,74.47) 41.23,74.8 41.77,74.8 PQ1214.5 42.26,74.04 42.52,73.78 42.72,73.78 PR1210.1 ; PR1250.2 v1(48.2,72.3) ; v1(48.14,49.04) 48.16,49.02 v2(49.24,49.02) 50.37,49.02 51.01,49.65 51.01,51.4 PR1254.1 51.31,52.12 PR1260.1
  IN2 w0.122: v1(40.9,74.47) 40.24,73.81 39.35,73.81 39.04,73.5 39.04,71.32 40.09,70.28 40.09,69.74 39.76,69.41 39.76,67.66 40.49,66.93 40.49,65.99 40.11,65.6 40.11,61.95 41.36,60.7 42.78,60.7 44.05,59.43 44.68,59.43 47.29,56.82 47.29,49.76 48.01,49.04 v1(48.14,49.04)
  IN4 w0.089: v1(40.9,74.47) 40.82,74.47 39.43,73.07 38.66,73.07 35.36,69.77 35.36,68.75 34.41,67.8 34.41,66.43 34.19,66.21 33.58,66.21 v1(33.33,66.47)
  BOTTOM w0.102: v1(48.2,72.3) 47.67,72.3 46.92,71.55 43.36,71.55 42.35,72.56 42.35,73.53 41.41,74.47 v1(40.9,74.47)
EN_PD_HV_1#: length 3.2
  TOP w0.102: v2(43.06,77.78) 42.48,77.21 PR1253.2
  TOP w0.254: PR1253.2 41.61,77 PQ1214.3 PQ1214.2
EN_PD_HV_1_R: length 5.3
  TOP w0.076: UT5.C2 28.44,64.06 28.44,64.43 28.78,64.76 28.78,65.22 29.01,65.45 30.22,65.45 v2(30.47,65.71) 30.92,66.15 30.92,66.21
  TOP w0.102: 30.92,66.21 31.36,66.66 RT70.1
ENABLE_DS#: length 7.7
  TOP w0.076: UE1.L2 260.02,45.89 259.64,45.51 259.64,44.24 259.14,43.73 258.88,43.73 258.23,43.09 v2(257.8,43.09) 257.36,42.64
  TOP w0.102: RE549.2 256.85,40.86 RE550.1 257.36,42.64
ENLDO_3V5V: length 165.8
  IN3 w0.254: v1(40.01,43.25) 40.01,43.25 40.01,45.97 39.85,46.13 39.85,48.27 38.87,49.25 38.87,57.08 43.67,61.89 45.1,61.89 47.33,64.12 52.06,64.12 54.79,66.85 54.79,76.37 59.35,80.93 59.35,84.96 60.76,86.37 60.76,94.11 62.21,95.55 62.78,95.55 65.63,98.4 67.92,98.4 69.11,99.58 74.36,99.58 75.88,98.07 77.09,98.07 79.3,95.86 83.73,95.86 84.57,95.02 90.96,95.02 93.3,92.68 97.5,92.68 99.07,94.25 102.75,94.25 103.39,94.88 104.94,94.88 106.04,95.98 106.95,95.98 107.58,96.61 111.38,96.61 111.66,96.88 112.32,96.88 113.85,98.41 115.03,98.41 116.51,99.89 130.36,99.89 133.26,97 138.09,97 144.35,103.26 v1(144.35,103.48)
  BOTTOM w0.102: v2(40.26,41.98) 40.01,42.24 v1(40.01,43.25)
  BOTTOM w0.254: PU100.11 143.83,103.64 143.18,102.99 PR103.1 PR102.1 144.35,103.15 v1(144.35,103.48) ; v1(40.01,43.25) 40.01,43.48 40.26,43.74 PU102.11
ENVDD_PCH: length 101.7
  TOP w0.102: v1(75.09,93.93) 75.06,93.95 74.4,93.95 73.85,94.5 DV3.3
  IN1 w0.089: v1(71.5,83.35) 72.04,83.35 74.53,85.84 74.91,85.84 75.2,86.13 81.01,86.13 82.05,87.17 83.42,87.17 86.61,90.36 88.89,90.36 89.58,91.04 92.56,91.04 93.16,90.45 100.26,90.45 102.2,88.51 102.2,83.6 103.47,82.33 103.47,79.34 104.1,78.7 104.1,78.32 107.18,75.24 107.18,72.25 107.75,71.67 107.75,69.77 108.31,69.21 115.86,69.21 115.97,69.09 121.44,69.09 122.05,68.48 122.05,67.79 122.55,67.29 125.44,67.29 127.56,65.17 133.69,65.17 v1(133.76,65.24)
  IN2 w0.122: v1(71.5,83.35) 71.83,83.35 72.19,83.71 72.19,85.36 77.22,90.39 77.22,91.26 76.86,91.61 75.85,91.61 75.09,92.38 v1(75.09,93.93)
  BOTTOM w0.076: v1(133.76,65.24) 133.32,64.8 UC1.U13
EOPIO_RCOMP: length 13
  TOP w0.381: v1(103.4,69.29) 103.15,69.29 102.54,69.9 101.27,69.9 v3(100.19,68.81) 99.43,68.81 98.15,67.53 98.15,65.38 96.92,64.15 RC91.1
  BOTTOM w0.254: v1(103.4,69.29) 103.54,69.29 103.79,69.04 UC1.H65
ESPI_ALERT#: length 178.6
  TOP w0.102: UE1.H7 v1(264.41,48.93) ; RC21.1 154.42,47.35 v1(154.16,47.1)
  IN1 w0.089: v1(245.01,21.61) 244.35,22.27 242.4,22.27 242.19,22.07 241.26,22.07 241.09,21.9 240.15,21.9 238.03,24.02 232.59,24.02 231.68,23.12 228.22,23.12 227.3,24.04 224.83,24.04 224.03,23.24 220.07,23.24 219.61,23.69 218.74,23.69 216.94,21.9 216.29,21.9 215.79,21.4 214.08,21.4 213.13,20.46 210.81,20.46 210.44,20.82 210.44,22.83 209.36,23.91 209.36,24.57 209,24.94 207.59,24.94 206.87,25.66 205.07,25.66 204.42,26.31 204.42,26.31 203.71,27.02 203.71,27.1 202.42,28.39 201.58,28.39 200.61,29.36 198.99,29.36 196.42,31.92 195.89,31.92 195.18,32.64 188.93,32.64 184.37,37.19 181.65,37.19 176.98,41.87 170,41.87 169.4,42.48 161.52,42.48 161.04,42.96 161.04,44.55 157.23,48.36 155.29,48.36 154.16,47.23 v1(154.16,47.1)
  IN2 w0.076: 265.61,46.91 265.61,47.54 265.43,47.72 264.99,47.72 264.77,47.94 264.77,48.56 v1(264.41,48.93)
  IN2 w0.122: v1(245.01,21.61) 245.7,20.93 248.61,20.93 250.13,22.45 251.31,22.45 252.26,23.4 252.26,24.07 252.73,24.54 252.73,26.25 253.09,26.62 253.09,32.28 257.99,37.18 259.82,37.18 260.33,37.69 261.65,37.69 262.24,38.28 262.24,38.29 262.49,38.53 262.5,38.53 263.2,39.23 263.2,40.01 264.79,41.6 264.79,44.25 265.49,44.95 265.49,46.02 265.61,46.15 265.61,46.91 ; v1(138.74,47.57) 139.03,47.87 139.06,47.87 139.61,48.41 143.93,48.41 146.98,45.36 152.48,45.36 153.77,46.65 154.05,46.65 154.17,46.78 154.17,47.09 v1(154.16,47.1)
  BOTTOM w0.076: v1(138.74,47.57) 138.48,47.83 138.33,47.83 137.86,48.29 136.76,48.29 134.57,50.48 134.36,50.48 134.04,50.8 134.04,51.76 134.15,51.87 UC1.AY11
ESPI_CLK: length 12.8
  TOP w0.102: v1(140.82,46.8) 141.35,46.27 141.35,45.87 v2(142.2,45.02) 142.3,44.93 RC16.1
  BOTTOM w0.076: 138.61,49.45 138.42,49.64 137.22,49.64 135.97,50.89 135.97,51.18 135.79,51.36 135.59,51.36 135.44,51.52 135.44,52.51 135.53,52.8 UC1.AW9
  BOTTOM w0.102: 138.61,49.45 138.92,49.45 140.82,47.54 v1(140.82,46.8)
ESPI_CLK_5105: length 170.2
  TOP w0.102: v1(254.69,35.86) 254.69,36.01 254.99,36.32 255.15,36.32 RE350.1 ; v1(263.65,48.92) 263.65,48.96 UE1.G7 ; RC16.2 CC316.1 144.89,41.53 v2(145.26,41.53) v1(151.9,41.53)
  IN1 w0.089: v1(151.9,41.53) 160.15,33.27 182.88,33.27 188.31,27.83 190.73,27.83 192.99,25.57 198.56,25.57 198.63,25.65 199.7,25.65 199.95,25.4 199.95,24.81 201.38,23.39 202.08,23.39 204.93,20.53 204.93,20.18 208.19,16.92 210.32,16.92 211.15,16.09 213.46,16.09 214.09,16.72 216.15,16.72 217.77,18.34 217.77,20.45 218.32,21 221.68,21 221.82,20.86 225.13,20.86 225.19,20.92 231.35,20.92 231.44,21 234.09,21 234.57,20.52 238.48,20.52 v1(238.66,20.34)
  IN2 w0.076: 264.8,46.86 264.85,46.91 264.85,47.54 264.67,47.72 264.22,47.72 263.99,47.95 263.99,48.31 263.65,48.65 v1(263.65,48.92)
  IN2 w0.122: v1(238.66,20.34) 239.93,21.61 240.85,21.61 241.53,22.3 243.72,22.3 243.99,22.03 245.2,22.03 245.83,21.4 247.72,21.4 248.34,22.02 248.34,22.35 248.77,22.78 249.79,22.78 252.1,25.09 252.1,26.29 252.66,26.85 252.66,32.56 253.97,33.87 253.97,34.98 254.69,35.71 v1(254.69,35.86) 254.69,35.88 255.1,36.29 256.04,36.29 257.89,38.15 261.47,38.15 262.77,39.44 262.77,40.18 263.66,41.08 263.66,43.08 264.2,43.61 264.2,44.26 264.8,44.87 264.8,46.86
  BOTTOM w0.102: v1(254.69,35.86) 254.32,36.23 254.32,37.38 253.12,38.59 JESPI.10
ESPI_CS#: length 175.2
  TOP w0.102: UE1.H6 v1(262.82,48.13)
  IN1 w0.089: v1(251.54,26.25) 251.74,26.04 251.74,25.19 250.5,23.95 247.8,23.95 247.24,23.39 247.24,23.37 246.73,22.87 243.41,22.87 243.03,22.49 242.31,22.49 242.12,22.3 241.18,22.3 241,22.12 240.29,22.12 238.15,24.25 232.49,24.25 231.57,23.33 228.31,23.33 227.38,24.27 224.58,24.27 224.39,24.08 222.74,24.08 222.51,23.85 220.45,23.85 220.22,24.08 218.82,24.08 216.85,22.11 216.2,22.11 215.7,21.62 213.99,21.62 213.04,20.67 211.18,20.67 210.85,21 210.85,22.98 209.76,24.07 209.76,24.41 209.76,24.73 209.16,25.33 207.76,25.33 207.03,26.06 205.23,26.06 204.59,26.7 204.59,26.7 204.11,27.18 204.11,27.26 202.08,29.28 201.38,29.28 200.89,29.76 199.14,29.76 196.52,32.38 196.02,32.38 195.3,33.09 188.78,33.09 184.28,37.59 181.82,37.59 177.32,42.08 170.09,42.08 169.49,42.69 161.88,42.69 v1(161.47,43.1)
  IN3 w0.122: v1(262.82,48.13) 262.41,47.72 261.83,47.72 261.29,47.19 261.29,45.97 257.18,41.86 257.18,39.26 255.69,37.78 253.28,37.78 252.48,36.98 252.48,35.28 v1(252.91,34.84) 252.91,34.21 250.75,32.05 250.75,31.22 251.03,30.94 251.03,27.25 251.54,26.74 v1(251.54,26.25)
  BOTTOM w0.076: UC1.BA12 133.88,51.97 133.88,50.73 134.29,50.32 134.5,50.32 136.98,47.84 137.9,47.84 138.72,47.02 139.13,46.6 139.13,46.14
  BOTTOM w0.102: JESPI.7 249.43,37.09 250.37,36.14 251.62,36.14 v1(252.91,34.84) 253.08,34.84 v2(253.43,35.2) ; v1(161.47,43.1) 160.81,42.44 148.16,42.44 145.26,45.34 139.93,45.34 139.13,46.14
ESPI_IO0: length 134.8
  TOP w0.102: v1(262.84,46.53) 262.83,46.53 UE1.K5 ; v1(182.3,39.14) 182.17,39.01 179.38,39.01 177.93,40.46 v2(171.68,40.46) RC366.2
  IN2 w0.122: v1(182.3,39.14) 182.3,39.92 182.48,40.1 183.34,40.1 183.62,40.38 185.04,40.38 185.58,39.85 185.58,36.04 186.71,34.91 190.72,34.91 191.39,35.58 205.68,35.58 206.56,34.7 211.34,34.7 213,33.04 214.25,33.04 214.89,33.68 225.2,33.68 225.95,34.42 228.6,34.42 228.74,34.56 232.33,34.56 233.56,35.79 234.57,35.79 236.02,37.24 236.81,37.24 239.12,39.55 239.12,40.13 240.67,41.68 241.66,41.68 242.07,42.08 242.47,42.08 v1(242.93,42.54)
  IN4 w0.089: v1(242.93,42.54) 242.93,42.74 241.16,44.52 241.16,45.32 241.41,45.56 241.99,45.56 244.27,43.28 248.59,43.28 249.64,44.33 251.73,44.33 252.79,45.39 255.83,45.39 256.72,44.5 257.36,44.5 257.79,44.93 261.93,44.93 262.51,44.34 262.51,43.91 262.44,43.84 262.44,43.23 262.56,43.1 263.04,43.1 263.58,43.64 263.58,45.79 v1(262.84,46.53)
  BOTTOM w0.102: JESPI.3 248.34,35.09 245.6,37.82 244.99,37.82 244.41,38.39 240.6,38.39 239.7,39.29 239.7,40.76 241.24,42.3 242.69,42.3 v1(242.93,42.54)
