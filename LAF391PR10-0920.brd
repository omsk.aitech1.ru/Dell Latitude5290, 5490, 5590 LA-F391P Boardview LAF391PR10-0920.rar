# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_WAKE#_R: length 4.2
  TOP w0.076: 269.87,43.42 268.82,44.46 UE1.N13
  TOP w0.102: RE275.2 RE35.1 270.13,42.29 v2(270.13,43) 270.13,43.15 269.87,43.42
PD1_GPIO2: length 5.5
  TOP w0.076: 28.15,58.89 27.99,59.06 27.94,59.1 27.94,59.56 UT5.D10
  TOP w0.102: 28.15,58.89 28.22,58.82 28.22,58.61 29.39,57.44 29.39,55.77 RT71.1
PD1_GPIO6: length 4.4
  TOP w0.076: UT5.G10 26.44,59.56 26.44,58.89 26.44,58.89
  TOP w0.102: 26.44,58.89 26.44,58.14 26.19,57.89 26.19,56.33 RT75.1
PD1_GPIO7: length 13.2
  TOP w0.076: UT5.D7 28.33,61.31 28.5,61.47 v1(28.68,61.47)
  TOP w0.102: RT339.1 31.26,54.47 31.26,53.63 31.7,53.18 v2(32.24,53.18)
  TOP w0.127: RT339.1 32.91,56.12 32.91,59.3 v1(31.72,60.5)
  IN1 w0.089: v1(28.68,61.47) 30.74,61.47 v1(31.72,60.5)
PD1_GPIO8: length 13.3
  TOP w0.076: v1(25.67,61.64) 25.84,61.81 UT5.H6
  TOP w0.102: v1(23.98,53.49) 23.91,53.56 RT76.1 RT377.1
  BOTTOM w0.102: v1(23.98,53.49) 23.04,54.43 v2(23.04,56.96) 23.04,58.34 22.53,58.85 22.53,60.24 22.85,60.56 24.6,60.56 v1(25.67,61.64)
PD#: length 10.6
  TOP w0.102: UA1.2 261.44,21.85 261.27,22.02 259.97,22.02 259.3,22.69 CA31.2 259.3,23.19 258.77,22.66 257.55,22.66 RA50.2 RA48.2 257.2,23.56 DA8.2 255.1,23.56 RA18.2 255.07,23.2 255.39,22.88 255.95,22.88 v2(256.15,22.68)
PDA_RESET#_R: length 2.4
  TOP w0.076: UT5.F11 27.19,59.17 27.4,58.97 27.4,58.89
  TOP w0.102: RT110.2 27.4,57.38 27.4,58.89
PECI_EC: length 268.9
  TOP w0.102: v1(273.4,46.02) 272.85,46.02 272.84,46.01 RE60.2
  IN2 w0.122: v1(273.4,46.02) 274.76,46.02 275.01,46.27 275.01,53.01 269.17,58.85 267.9,58.85 267.26,59.48 265.99,59.48 264.21,61.27 262.81,61.27 262.31,61.77 261.5,61.77 260.95,61.21 257,61.21 256.21,60.43 254.51,60.43 249.32,55.24 247.76,55.24 244.52,51.99 242.94,51.99 242.43,51.48 240.87,51.48 239.34,49.96 238.88,49.96 237.54,48.62 236.85,48.62 235.7,47.47 234.98,47.47 234.1,46.58 233.14,46.58 232.73,46.17 231.18,46.17 230.34,45.34 228.77,45.34 227.9,44.46 225.08,44.46 224.56,43.94 212.52,43.94 211.89,44.57 210.12,44.57 209.43,45.26 206.14,45.26 204.31,47.09 201.66,47.09 192.22,56.53 192.22,57.05 188.65,60.63 188.65,63.15 186.55,65.25 186.55,69.8 180.57,75.78 180.57,80.67 178.31,82.93 178.31,84.83 175.29,87.85 174.58,87.85 172.94,89.49 172.94,90.05 172.32,90.67 172.32,92.33 171.89,92.76 171.89,94.03 172.98,95.12 172.98,97.32 169.13,101.16 169.13,104.61 168.08,105.66 165.63,105.66 164.69,106.6 161.04,106.6 159.59,108.05 155.92,108.05 155.45,107.58 155.45,103.88 153.04,101.47 148.95,101.47 144.71,105.71 141.71,105.71 138.97,102.97 135.26,102.97 134.51,102.22 133.97,102.22 133.4,102.78 130.83,102.78 130.38,103.24 128.39,103.24 127.12,104.51 127.12,106.79 v1(126.1,107.81)
  BOTTOM w0.076: UC1.A54 109.67,73.8 109.67,74.73 109.96,75.03 109.96,78.53 110.36,78.93
  BOTTOM w0.102: v1(126.1,107.81) 126.55,107.36 126.55,105.58 125.79,104.82 124.13,104.82 121.59,102.28 121.59,97.33 120.2,95.93 120.2,88.46 116.76,85.03 116.76,80.18 v2(116.07,79.49) 115.8,79.22 110.65,79.22 110.36,78.93
PECI_EC_R: length 3.2
  TOP w0.102: UE1.K13 269.02,46.93 269.63,46.33 v2(270.63,46.33) 271.28,46.33 RE60.1
PGOOD_3V: length 5.1
  BOTTOM w0.254: PU100.9 145.03,106.15 145.28,105.9 v2(145.28,103.89) 145.28,103.55 145.85,102.98 PR107.2 PR119.1
PGOOD_5V: length 165.2
  TOP w0.102: PR113.2 40.32,42.7 v1(40.47,42.85) 40.62,43 v3(40.62,43.4)
  IN3 w0.122: v1(40.47,42.85) 40.47,45.96 40.17,46.26 40.17,48.4 39.18,49.38 39.18,56.95 43.8,61.58 45.23,61.58 47.33,63.67 52.25,63.67 55.3,66.72 55.3,68.53 56.06,69.29 56.06,74 56.32,74.25 56.32,77.39 59.66,80.74 59.66,84.83 61.27,86.43 61.27,93.87 62.46,95.07 63.06,95.07 64.84,96.85 67.49,96.85 69.92,99.27 74.23,99.27 77.06,96.44 77.88,96.44 80.32,94 82.35,94 83.09,93.26 83.93,93.26 84.97,94.31 91.23,94.31 93.17,92.37 97.63,92.37 98.61,93.34 100.51,93.34 100.91,92.94 104.41,92.94 107.01,95.55 108.83,95.55 109.51,96.23 111.45,96.23 111.79,96.57 112.51,96.57 113.91,97.96 115.37,97.96 116.9,99.49 130.32,99.49 133.13,96.68 142.41,96.68 v1(145.85,100.12)
  BOTTOM w0.102: PR120.1 145.8,100.17 v1(145.85,100.12) ; v1(40.47,42.85) 40.47,42.81 40.84,42.44 41.08,42.44 41.42,42.78 PU102.9
PLTRST_LAN#: length 128.1
  TOP w0.102: v1(253.8,70.4) 253.67,70.54 UL1.36 ; v1(209.43,43.46) 206.38,40.41 206.38,39.37 206.02,39.01 203.53,39.01 203,38.48 201.78,38.48 200.13,40.13 194.16,40.13 193.73,40.56 188.37,40.56 188.17,40.36 180.9,40.36 179.04,42.22 v3(178.3,42.22) 166.1,42.22 164.41,43.91 160.9,43.91 159.57,45.25 159.57,50.02 160.98,51.43 RC62.2
  IN3 w0.122: v1(254.94,59.74) 254.56,59.36 254.56,58.21 249.86,53.51 248.75,53.51 246.84,51.61 244.58,51.61 243.69,50.72 242.27,50.72 240.59,49.04 240.34,49.04 239.83,48.54 239.83,48.42 238.69,47.28 237.43,47.28 234.85,44.7 233.03,44.7 232.41,45.31 230.34,45.31 230.03,44.99 228.86,44.99 228.04,44.18 225.15,44.18 224.7,43.72 209.7,43.72 v1(209.43,43.46)
  BOTTOM w0.102: v1(253.8,70.4) 253.8,60.88 v1(254.94,59.74)
PLTRST_TPM#: length 9
  TOP w0.102: UZ12.17 161.79,62.38 162.58,63.17 163.22,63.17 163.5,63.45 164.14,63.45 164.24,63.55 164.24,63.76 164.34,63.86 RC325.2 165.5,64.11 RC60.2 166.3,64.11 166.98,63.42 167.07,63.42 v2(167.16,63.33)
PM_LANPHY_ENABLE: length 165.2
  TOP w0.102: RL7.1 261.64,62.7 v1(261.64,62.6)
  IN3 w0.122: v1(261.64,62.6) 261.04,63.19 258.91,63.19 257.46,61.74 255.99,61.74 255.5,61.26 255.5,58.01 253.22,55.72 253.22,52.68 253.04,52.5 252.53,52.5 251.77,51.74 250.94,51.74 250.3,51.1 248.14,51.1 247.63,50.59 246.08,50.59 245.56,50.07 244.98,50.07 244.5,49.6 244.5,49 242.42,46.91 240.97,46.91 239.93,45.87 239.93,44.79 236.72,41.58 234.76,41.58 233.45,40.26 232.3,40.26 231.81,40.75 229.22,40.75 228.43,39.95 227.49,39.95 226.4,38.86 220.57,38.86 220.07,38.36 217.31,38.36 216.97,38.02 212.51,38.02 211.93,38.6 210.01,38.6 208.72,39.9 204.45,39.9 202.72,41.63 187.46,41.63 185.98,43.1 177.09,43.1 v1(171.89,37.89)
  BOTTOM w0.076: 132.26,47.72 130.62,49.35 130.62,50.61 130.43,50.8 130.43,51.16 130.47,51.25 130.47,51.43 130.43,51.55 130.43,51.81 130.47,51.91 130.47,52 130.68,52.7 130.86,52.88 UC1.AW17
  BOTTOM w0.102: v1(171.89,37.89) 169.51,35.52 145.69,35.52 144.5,36.71 144.5,37.65 143.76,38.4 138.69,38.4 136.7,40.4 136.11,40.4 134.29,42.21 133.79,42.21 133.51,42.49 133.51,43.89 132.69,44.71 132.69,47.29 132.26,47.72
PME#: length 1.3
  TOP w0.102: v1(133.84,53.81) 134.23,53.41 T115.1
  BOTTOM w0.076: v1(133.84,53.81) 134.17,54.14 UC1.AU11
POA_WAKE#: length 111.7
  TOP w0.076: UE1.E4 261.62,51.15 261.13,51.64 261.13,52.76 261.05,52.85 260.06,52.85 259.77,53.13 259.77,53.15 259.71,53.21 259.71,53.32 259.38,53.65 258.88,53.65 258.37,54.15 257.23,54.15
  TOP w0.102: v1(262.18,10.99) 261.6,11.58 RZ364.1 ; 257.23,54.15 RE324.1 256.51,54.36 256.09,54.78 255.83,54.78 255.58,55.04 255.58,56.94 254.18,58.34 254.18,61.77 v3(254.46,62.04) 254.92,62.51 v1(254.94,62.51)
  IN2 w0.122: v1(262.18,10.99) 262.18,11.71 260.33,13.56 260.33,15.39 261.92,16.98 261.92,18.38 262.45,18.91 264.02,18.91 264.14,19.04 264.14,24.48 266.04,26.39 266.35,26.39 267.26,27.3 268.25,27.3 269.07,28.11 272.72,28.11 273.17,28.56 275.7,28.56 276.27,29.12 279.74,29.12 279.95,28.91 280.35,28.91 281.41,29.97 281.41,30.68 281.83,31.1 281.83,35.71 282.58,36.45 282.58,41.62 283.09,42.13 283.09,43.15 281.74,44.5 281.74,48.69 280.04,50.39 280.04,54.56 279.48,55.11 279.48,55.29 276.38,58.39 273.69,58.39 269.8,62.28 264.09,62.28 261.83,64.54 260.86,64.54 260.38,64.05 256.49,64.05 v1(254.94,62.51)
POWER_SW#_MB: length 169.6
  TOP w0.102: v1(278.62,53.01) CE10.1 RE33.2 ; v1(294.44,88.31) 295.2,89.07 SW3.2 SW3.4
  IN1 w0.089: v1(278.62,53.01) 277.66,53.97 277.66,63.76 277.42,63.99 277.42,67.24 279.52,69.33 279.52,81.4 285.28,87.17 287.46,87.17 288.6,88.31 v1(294.44,88.31)
  IN2 w0.122: v1(248.18,31.42) 248.4,31.2 248.4,28.19 248.49,28.09 248.49,25.67 248.22,25.39 247.75,25.39 247.16,24.8 247.16,24.39 246.91,24.14 245.54,24.14 245.51,24.16 244.75,24.16 244.45,23.87 243.44,23.87 243.14,24.16 239.57,24.16 238.07,22.65 234.9,22.65 232.58,20.34 223.65,20.34 223.19,20.8 221.29,20.8 220.86,21.23 218.33,21.23 217.46,20.37 213.24,20.37 213.03,20.16 213.03,19.08 211.08,17.13 210.13,17.13 v1(209.37,16.37)
  IN4 w0.089: v1(278.62,53.01) 281.13,50.49 281.13,47.62 282.81,45.94 284.87,45.94 287.43,43.38 287.43,41.55 284.13,38.25 283.34,38.25 281.13,36.04 281.13,34.87 279.2,32.94 276.03,32.94 275.65,32.56 274.76,32.56 274.25,33.07 274.25,33.19 273.99,33.45 273.51,33.45 272.5,32.43 271.2,32.43 270.57,33.07 261.68,33.07 261.29,33.45 258.5,33.45 258.37,33.32 256.85,33.32 255.93,32.41 249.17,32.41 v1(248.18,31.42)
  BOTTOM w0.102: JAPS1.11 209.7,16.03 v1(209.37,16.37)
POWER_SW_IN#: length 25.1
  TOP w0.102: RE31.2 CE12.1 RE33.1 v1(276.71,53.08) 276.89,52.9 v2(277.33,52.9) ; UE1.D5 v1(262.04,51.36)
  IN1 w0.089: v1(276.71,53.08) 276.53,53.26 276.53,56.69 276.03,57.2 272.98,57.2 271.66,55.88 270.08,55.88 268.54,54.34 265.96,54.34 264.44,52.83 262.77,52.83 262.44,52.5 262.44,51.75 v1(262.04,51.36)
PROCHOT#: length 382.2
  TOP w0.102: PR678.1 61.73,64.6 61.67,64.66 PC605.2 60.49,65.05 58.2,65.05 v1(57.54,65.71) ; v1(275.96,48.05) 275.81,48.21 RE288.2
  IN1 w0.089: v1(275.96,48.05) 274.33,46.42 272.88,46.42 272.66,46.64 272.66,48.04 271.24,49.47 269.63,49.47 267.84,47.67 267.52,47.67 267.24,47.95 267.24,48.31 267.01,48.53 264.26,48.53 264.04,48.75 264.04,49.11 263.82,49.32 259.77,49.32 258.88,50.21 257.23,50.21 255.88,51.56 254.18,51.56 253.39,50.76 252.15,50.76 251.57,50.19 248.72,50.19 247.88,49.35 247.88,48.99 247.71,48.81 247.12,48.81 246.92,48.61 246.18,48.61 v1(245.72,48.15) ; v1(25.5,46.38) 26.34,46.38 30.79,50.82 30.79,53.18 34.36,56.75 34.36,60.41 35.46,61.51 43.24,61.51 45.99,64.27 53.55,64.27 54.29,65.01 56.84,65.01 v1(57.54,65.71)
  IN2 w0.122: v1(105.3,108.04) 105.89,108.63 108.36,108.63 109.24,109.51 110.95,109.51 112.97,107.49 117.91,107.49 126.22,99.18 128.58,99.18 128.59,99.17 128.6,99.17 129.07,98.7 130.79,98.7 131.25,98.24 136.21,98.24 136.68,98.7 137.64,98.7 138.1,98.24 141.13,98.24 142.96,96.41 152.64,96.41 157.51,91.54 159.21,91.54 164.04,86.71 164.04,81.96 167.32,78.68 169.05,78.68 171.51,76.21 171.51,73.3 181.47,63.34 181.47,62.88 183.47,60.88 183.47,58.24 187.01,54.69 187.01,49.94 190.99,45.97 191.88,45.97 197.6,40.25 200.16,40.25 201.56,38.84 204.43,38.84 205.78,37.5 209.95,37.5 210.34,37.11 211.68,37.11 212.61,36.17 213.63,36.17 214.08,35.73 216.78,35.73 217.23,36.17 225.93,36.17 227.01,37.26 233.28,37.26 234.5,38.48 234.88,38.48 237.65,41.25 238.33,41.25 241.27,44.19 241.96,44.19 243.58,45.81 244.51,45.81 245.72,47.02 v1(245.72,48.15)
  IN4 w0.089: v1(105.3,108.04) 104.81,108.53 98.89,108.53 95.47,111.95 77.59,111.95 69.88,104.24 69.88,103.18 70.32,102.74 70.32,98.51 71.1,97.73 71.1,92.84 63.45,85.19 62.79,85.19 58.86,81.25 v1(58.86,81.17)
  BOTTOM w0.102: v1(105.3,108.04) v2(104.69,107.43) 103.69,106.43 103.69,97.74 103.54,97.59 103.54,96.73 103.41,96.59 103.41,94.97 104.09,94.29 104.09,91.79 103.43,91.13 103.43,90.55 CC310.1 104.3,89.79 105.21,88.87 RC83.1 RC84.1 ; v1(25.5,46.38) 25.52,46.39 PR926.1 ; v1(58.86,81.17) 58.42,80.74 58.42,67.49 57.54,66.6 v1(57.54,65.71)
PROCHOT#_ISL9538: length 13.6
  IN4 w0.254: v1(34.57,47.11) 34.6,47.11 34.6,47.27 34.45,47.42 34.45,47.53 33.85,48.13 29.33,48.13 28.12,46.92 v1(28.12,45.27)
  BOTTOM w0.254: v1(34.57,47.11) 34.6,47.11 34.6,47.27 34.45,47.42 34.45,47.45 PQ1216.1 ; PU901.23 28.36,45.04 v1(28.12,45.27) 27.96,45.44 v2(27.96,46.05) 27.61,46.39 PR926.2
PROCHOT#_R: length 17.3
  BOTTOM w0.076: 101.78,79.94 101.78,79.09 101.6,78.91 ; UC1.C65 103.55,72.66 103.51,72.79 103.47,72.91 103.47,73.08 103.49,73.16 103.49,73.5 103.47,73.54 103.47,73.81 103.59,73.93 103.59,74.6 102.54,75.65 102.54,76.2 101.6,77.14 101.6,78.07
  BOTTOM w0.102: 101.78,79.94 101.78,80.95 102.87,82.04 102.87,83.36 v2(103.66,84.15) 105.59,86.08 RC84.2 ; 101.6,78.07 101.6,78.91
PROCHOT#_R1: length 5.7
  TOP w0.102: UE1.H13 269.04,48.53 269.37,48.21 270.57,48.21 270.62,48.15 v2(271.23,48.15) 274.25,48.15 RE288.1
PS_ID: length 291.4
  TOP w0.076: v1(264.42,47.34) 264.82,47.73 UE1.J8
  TOP w0.254: PR4.1 48.55,85.49 PR5.2 49.09,86.86 49.09,87.61 48.44,88.26 v2(48.44,88.39) v1(48.44,89.33)
  IN1 w0.089: v1(262.82,41.65) 261.65,42.82 261.07,42.82 260.86,43.02 260.86,43.61 260.48,43.99 254.75,43.99 253.36,45.39 252.4,45.39 251.64,44.62 250.88,44.62 250.12,45.39 248.56,45.39 247.61,46.34 v1(247.61,46.37)
  IN2 w0.122: v1(264.42,47.34) 264.42,47.31 264.55,47.19 264.55,45.67 263.63,44.75 263.63,43.75 263.22,43.34 263.22,42.06 v1(262.82,41.65) ; v1(247.61,46.37) 247.57,46.41 246.32,46.41 244.86,44.95 243.98,44.95 241.39,42.36 240.65,42.36 238.43,40.15 237.96,40.15 236.99,39.18 236.99,38.91 234.36,36.29 232.99,36.29 232.61,35.91 226.86,35.91 226.23,35.27 225.55,35.27 224.74,34.46 213.02,34.46 211.68,35.8 207.33,35.8 206.49,36.64 205.42,36.64 204.12,37.94 196.09,37.94 193.86,40.18 193.86,41.83 186.12,49.57 186.12,54.38 181.74,58.76 181.74,61.29 180.09,62.94 180.09,63.62 168.71,75 168.71,76.58 168.08,77.21 168.08,77.97 167.87,78.18 166.56,78.18 163.98,80.76 163.4,80.76 161.68,82.48 161.68,87.67 159.08,90.26 156.98,90.26 152.2,95.04 142.4,95.04 140.49,96.95 130.83,96.95 130.61,96.72 124.49,96.72 121.82,99.39 121.82,101.68 117.61,105.89 109.35,105.89 108.69,106.55 105.97,106.55 105.67,106.85 104.13,106.85 104.01,106.74 100.48,106.74 97.45,109.77 93.92,109.77 92.52,108.37 84.43,108.37 81.82,105.76 79.91,105.76 78.91,106.76 69.04,106.76 68.64,106.35 68.25,106.35 67.37,105.46 67.37,103.17 65.71,101.52 65.71,97.46 63.56,95.3 62.74,95.3 60.83,93.38 54.57,93.38 54.01,93.38 52.86,92.23 52.86,89.7 52.18,89.02 48.75,89.02 v1(48.44,89.33)
PWM1_IA: length 29.3
  TOP w0.203: v1(74.62,61.54) 74.62,61.38 74.35,61.11 73.74,61.11 73.54,61.31 73.54,61.82 72.18,63.18 v2(72.18,63.37) 72.3,63.49 72.3,64.89 72.09,65.1 71.81,65.1 71.31,65.61 PU602.12
  IN1 w0.254: v1(74.62,61.54) 74.62,61.14 73.35,59.87 73.35,54.85 73.86,54.34 76.01,54.34 78.89,57.22 83.7,57.22 v1(84.85,58.38)
  BOTTOM w0.254: PR687.1 85.55,57.68 v1(84.85,58.38)
PWM2_IA: length 14.5
  TOP w0.203: v1(72.17,65.55) 71.83,65.55 71.37,66.01 PU602.13
  IN1 w0.254: v1(70.68,75.21) 71.94,73.94 71.94,70.32 70.97,69.36 70.97,66.27 71.69,65.55 v1(72.17,65.55)
  BOTTOM w0.102: v1(70.68,75.21) v2(70.68,74.29)
  BOTTOM w0.254: v1(70.68,75.21) PR692.1
PWM_FAN1: length 146.5
  TOP w0.076: UE1.L10 v1(266.84,45.72)
  TOP w0.102: v1(175.85,74.35) v3(175.85,73.33)
  IN2 w0.122: v1(246.05,49.02) 245.55,49.02 245.09,48.56 244.48,48.56 242.04,46.12 241.61,46.12 240.53,45.04 238.4,42.91 237.63,42.91 234.85,40.13 234.01,40.13 233.78,39.89 232.84,39.89 232.62,39.68 229.78,39.68 228.47,38.36 226.55,38.36 225.7,37.51 213.27,37.51 212.05,38.73 206.89,38.73 206.33,39.29 206.33,39.52 205.67,40.18 203.47,40.18 202.3,41.35 198.33,41.35 188.14,51.54 188.14,55.13 184.57,58.7 184.57,61.34 182.57,63.33 182.57,65.41 175.85,72.14 v1(175.85,74.35)
  IN4 w0.089: v1(179.18,89.38) 179.18,88.34 179.46,88.06 179.46,82.99 175.85,79.38 v1(175.85,74.35) ; v1(246.05,49.02) 246.46,49.42 246.82,49.42 247.04,49.21 247.04,48.97 247.2,48.81 249.23,48.81 249.86,48.18 253.29,48.18 254.69,49.58 255.58,49.58 256.62,48.54 262.16,48.54 262.44,48.81 262.44,49.96 262.59,50.11 263.81,50.11 264.02,49.9 264.02,48.47 263.96,48.41 263.96,47.16 264.24,46.88 265.67,46.88 v1(266.84,45.72)
  BOTTOM w0.102: JFAN1.2 178.69,88.49 RE48.2 179.18,89.96 v1(179.18,89.38)
PWM_GT: length 39.5
  TOP w0.102: v2(70.98,71.32) 70.64,71.32 70.29,70.96 v1(70.21,70.96)
  TOP w0.203: v1(70.21,70.96) 70.21,70.4 69.77,69.96 PU602.22
  IN2 w0.254: v1(70.21,70.96) 70.48,71.23 71.04,71.23 71.73,70.53 71.73,70.33 73,69.06 73,68.23 73.31,67.92 73.31,64.69 68.06,59.44 68.06,57.83 69.89,56 69.89,53.02 70.62,52.29 70.62,49.1 69.22,47.71 v1(63.68,47.71)
  BOTTOM w0.254: v1(63.68,47.71) 62.63,47.71 62.2,48.14 PR664.1
PWM_SA: length 3.7
  BOTTOM w0.102: PR606.1 88.3,88.41 88.69,88.79 88.69,90.19 v2(88.8,90.31)
  BOTTOM w0.254: PU614.3 87.86,88.17 PR606.1
PWM_VSA: length 49
  TOP w0.102: v1(65.84,70.4) 65.38,70.4 v2(64.75,69.77)
  TOP w0.203: PU602.30 66.57,69.68 v1(65.84,70.4)
  IN3 w0.254: v1(65.84,70.4) 65.99,70.56 65.99,73.07 62.36,76.7 62.36,79.45 62.92,80.01 62.92,81.68 63.89,82.65 68.81,82.65 71.71,85.54 80.13,85.54 81.68,84.11 82,83.79 v1(82.2,83.79)
  BOTTOM w0.254: v1(82.2,83.79) 82.2,84.2 83.91,85.91 83.91,89.69 84.67,90.23 87.85,90.23 88.1,89.98 PR606.2
RD1_A_DE0: length 2.6
  TOP w0.102: RN38.1 244.28,21.74 RN25.2 244.72,22.18 UN4.6
RD1_A_DE1: length 5.2
  TOP w0.102: UN4.8 247.1,21.13 246.71,20.75 245.42,20.75 RN39.1 RN26.2 243.48,19.69 v2(242.74,19.69)
RD1_A_EQ0: length 34.5
  TOP w0.102: UN4.23 247.1,25.82 247.46,26.18 v1(247.46,26.27) ; v1(228.78,26.87) v2(228.78,27.48) 228.5,27.76 227.54,27.76 RN42.2 RN179.1
  IN4 w0.089: v1(247.46,26.27) 247.46,25.85 245.63,24.02 241.67,24.02 241.27,24.43 241.27,25.08 240.94,25.41 238.4,25.41 238.1,25.7 238.1,27.15 238.48,27.53 238.48,29.23 237.71,30.01 236.34,30.01 235.87,29.54 228.15,29.54 227.79,29.18 227.79,27.83 228.78,26.84 v1(228.78,26.87)
RD1_A_EQ1: length 32.5
  TOP w0.102: UN4.22 247.6,25.82 v1(248.06,26.29) ; v1(229.93,29) 229.93,29.23 229.7,29.46 v2(228.93,29.46) 228.53,29.46 227.99,29.99 227.16,29.99 RN43.2 RN176.1
  IN4 w0.089: v1(248.06,26.29) 248.04,26.27 248.04,25.67 247.36,24.99 247.36,24.19 247.07,23.9 246.45,23.9 245.58,23.03 243.69,23.03 243.03,23.69 241.66,23.69 241.05,24.3 241.05,24.99 240.85,25.19 238.13,25.19 237.74,25.59 237.74,27.29 238.23,27.78 238.23,29.18 237.62,29.79 236.43,29.79 235.84,29.21 232.16,29.21 231.96,29 v1(229.93,29)
RD1_A_EQ2: length 34.5
  TOP w0.102: v1(229.79,30.43) 229.68,30.53 RN174.1 RN44.2 v2(230.61,32.37) ; v1(250.6,29.56) 251.01,29.16 251.01,28.67 250.75,28.42 250.55,28.42 250.19,28.06 250.19,26.54 249.84,26.19 249.25,26.19 249.1,26.04 UN4.19
  IN4 w0.089: v1(229.79,30.43) 230.24,29.97 235.59,29.97 236.06,30.44 237.89,30.44 239.07,29.26 239.07,28.41 241.96,25.52 242.39,25.52 242.71,25.21 245.89,25.21 246.07,25.38 246.34,25.38 246.84,25.89 246.84,26.55 248.69,28.39 249.38,28.39 250.55,29.56 v1(250.6,29.56)
RD1_B_DE0: length 6.2
  TOP w0.102: UN4.13 250.21,22.18 250.37,22.02 250.37,21.8 249.76,21.19 249.76,20.24 RN40.1 250.47,19.53 250.47,18.33 v2(250.17,18.03) 249.41,18.03 RN27.2
RD1_B_DE1: length 6.9
  TOP w0.102: UN4.9 247.6,20.92 247.43,20.75 247.04,20.75 246.82,20.52 245.83,20.52 245.55,20.24 RN41.1 246,19.53 246,18.11 RN28.2 245.32,17.62 244.97,17.97 v2(244.57,17.97)
RD1_B_EQ0: length 5.4
  TOP w0.102: UN4.11 248.6,20.88 248.21,20.49 247.91,20.49 RN52.1 247.86,19.53 247.86,18.68 RN49.2 246.94,18.21 v2(246.45,17.72)
RD1_B_EQ1: length 4.2
  TOP w0.102: UN4.21 248.1,25.74 248.49,26.13 248.49,26.54 RN50.2 RN53.1 249.85,28.79 v2(249.85,28.97)
RD1_B_EQ2: length 5.9
  TOP w0.102: v2(252.4,19.35) 252.4,20.62 RN51.2 RN54.1 251.38,22.53 251.38,23.07 250.76,23.68 UN4.16
RD1_REXT: length 2.4
  TOP w0.102: RN30.1 246.61,19.99 247.15,20.52 247.6,20.52 248.1,21.02 UN4.10
RD2_A_DE0: length 3.2
  TOP w0.102: RN55.2 RN59.1 233.06,19.86 v1(233.4,20.2) 233.4,20.73 233.51,20.83 UN5.6
RD2_A_DE1: length 6
  TOP w0.102: UN5.8 235.39,19.3 235.06,18.97 234.03,18.97 RN56.2 232.96,17.9 RN60.1 232.17,17.9 231.25,16.98 v2(231.25,16.81)
RD2_A_EQ0: length 2.3
  TOP w0.102: RN225.2 235.39,24.61 UN5.23
RD2_A_EQ0_R: length 2.3
  TOP w0.102: RN63.2 234.55,27.66 234.41,27.8 QN5.3 233.88,27.03 RN225.1
RD2_A_EQ1: length 2.1
  TOP w0.102: RN224.2 235.01,25.54 235.89,24.66 UN5.22
RD2_A_EQ1_R: length 7.4
  TOP w0.102: QN5.6 232.58,29.88 232.9,30.2 234.34,30.2 v2(234.97,29.56) 235.53,29 236.28,29 236.4,28.88 236.4,28.16 RN64.2 235.03,26.79 RN224.1
RD2_A_EQ2: length 26.8
  TOP w0.102: v1(237.59,24.94) 237.39,24.74 UN5.19 ; v1(222.68,25.71) 223.35,26.38 v2(223.35,26.62) 223.35,27 223.7,27.35 223.7,28.55 223.35,28.9 223.35,29.84 220.98,32.2 220.98,32.98 RN223.2
  BOTTOM w0.102: v1(237.59,24.94) 234.1,24.94 232.64,23.48 226.05,23.48 223.82,25.71 v1(222.68,25.71)
RD2_A_EQ2_R: length 2.2
  TOP w0.102: QN4.3 223.14,32.66 RN223.1 RN65.2
RD2_B_DE0: length 2.5
  TOP w0.102: UN5.13 239.71,20.83 RN57.2 RN61.1
RD2_B_DE1: length 2.8
  TOP w0.102: RN58.2 RN62.1 235.89,18.92 UN5.9
RD2_B_EQ0: length 2.9
  TOP w0.102: RN69.2 RN72.1 236.89,18.93 UN5.11
RD2_B_EQ1: length 4.1
  TOP w0.102: v2(238.02,25.88) RN73.1 RN70.2 235.89,25.61 236.39,25.12 UN5.21
RD2_B_EQ2: length 2.9
  TOP w0.102: RN74.1 RN71.2 239,22.27 238.94,22.33 UN5.16
RD2_REXT: length 1.6
  TOP w0.102: UN5.10 RN31.1
RED: length 12.3
  TOP w0.102: LV16.2 285.03,60.76 CV129.1 286.44,60.75 DV5.2 290.43,61.08 v2(291.6,59.91) 291.9,59.61 291.9,58.78 JCRT1.1
RED_CRT: length 13.5
  TOP w0.102: UV6.23 282.77,51.52 v2(281.67,52.62) 280.9,53.39 280.9,59.66 281.84,60.6 282,60.6 RV116.1 CV126.1 283.8,61.51 LV16.1
REM_DIODE1_N: length 247.2
  TOP w0.254: v1(109.06,59.17) 109.08,59.14 109.08,58.64 CE35.1 108.83,58.13 108.02,58.13 107.43,58.72 QE3.3 ; UE1.A8 264.56,54.4 264.56,54.66 264.89,54.99 264.89,55.67 264.98,55.76 264.98,56.29 CE24.1 264.98,56.76 264.98,58.17 v2(264.32,58.83) 264.02,59.13 262.99,59.13 v1(262.95,59.17)
  IN3 w0.254: v1(109.06,59.17) 109.07,59.15 109.07,58.93 108.86,58.72 107.83,58.72 107.7,58.86 107.7,59.15 107.05,59.8 105.78,59.8 104.74,60.84 101.97,60.84 101.33,60.19 99.79,58.66 98.84,58.66 97.53,57.34 97.53,56.14 96.73,55.34 96.73,54.26 95.86,53.39 93.78,53.39 93.27,53.89 88.77,53.89 86.42,51.54 86.42,47.27 99.97,33.71 172.03,33.71 174.34,36.03 178.24,36.03 179.97,37.77 189.54,37.77 191.62,35.68 197.26,35.68 198.38,36.8 200.36,36.8 201.48,35.68 207.03,35.68 208.18,34.54 213.16,34.54 213.53,34.17 217.27,34.17 218.68,35.58 221.86,35.58 222.46,36.19 227.4,36.19 228.52,37.31 233.49,37.31 234.6,38.42 234.73,38.42 235.14,38.84 235.91,38.84 236.61,39.54 237.29,39.54 241.54,43.79 241.63,43.79 242.71,44.88 243.42,44.88 245.07,46.53 246.14,46.53 246.65,47.04 247.48,47.04 248.49,48.05 248.49,49.55 248.75,49.81 251.32,49.81 251.83,50.32 253.02,50.32 254.49,51.79 254.49,54.73 255.48,55.72 255.48,56.21 256.72,57.45 256.72,59.84 257.21,60.33 262.85,60.33 263.5,59.68 263.5,59.29 263.34,59.13 262.97,59.13 262.95,59.15 v1(262.95,59.17)
REM_DIODE1_P: length 250
  TOP w0.254: v1(109.66,59.17) 109.89,58.93 109.89,58.25 109.38,57.74 109.35,57.74 CE35.2 109.19,57.63 107.43,57.63 QE3.2 106.18,57.63 QE3.1 ; v1(262.95,58.58) 262.99,58.62 263.81,58.62 263.96,58.47 264.47,57.96 v2(264.47,57.49) 264.47,56.7 CE24.2 264.47,56.35 264.47,55.76 264.55,55.67 264.55,55.14 264.22,54.8 264.22,54.33 UE1.A7
  IN3 w0.254: v1(262.95,58.58) 262.95,58.59 262.97,58.62 263.55,58.62 264.01,59.08 264.01,59.89 263.06,60.84 257,60.84 256.21,60.05 256.21,57.66 254.97,56.42 254.97,55.93 253.98,54.94 253.98,52 252.81,50.83 251.62,50.83 251.11,50.31 248.54,50.31 247.98,49.76 247.98,48.26 247.27,47.54 246.44,47.54 245.93,47.04 244.86,47.04 243.21,45.39 242.5,45.39 241.41,44.3 241.33,44.3 237.08,40.05 236.4,40.05 235.7,39.35 234.93,39.35 234.52,38.93 234.39,38.93 233.27,37.82 228.31,37.82 227.19,36.7 222.25,36.7 221.64,36.09 218.47,36.09 217.06,34.68 213.74,34.68 213.37,35.05 208.39,35.05 207.24,36.19 201.69,36.19 200.57,37.31 198.17,37.31 197.05,36.19 191.83,36.19 189.75,38.27 179.76,38.27 178.03,36.54 174.13,36.54 171.82,34.22 100.18,34.22 86.92,47.48 86.92,51.33 88.98,53.39 93.06,53.39 93.57,52.88 96.07,52.88 97.24,54.05 97.24,55.13 98.04,55.93 98.04,57.13 99.05,58.15 100,58.15 102.18,60.33 104.53,60.33 105.57,59.29 106.84,59.29 107.19,58.94 107.19,58.64 107.62,58.21 109.07,58.21 109.58,58.72 109.58,59.09 v1(109.66,59.17)
REM_DIODE2_N: length 184.1
  TOP w0.254: QE5.3 211.15,26.73 CE37.2 211.15,25.68 211.95,24.88 v1(211.95,24.63) ; UE1.A10 266.13,54.43 266.13,55.2 266.16,55.23 v2(266.16,55.63) 266.48,55.94 266.48,57.41 CE26.1 266.46,57.81 266.46,58.21 v1(266.53,58.28)
  IN3 w0.254: v1(211.95,24.63) 211.89,24.57 211.89,23.92 208.22,20.25 208.22,19.82 207.15,18.75 204.89,18.75 201.44,22.2 199.89,22.2 198.7,23.38 198.16,23.38 197.62,23.92 v1(197.62,24.04) ; v1(266.53,58.28) 266.5,58.25 266.5,56.95 263.58,54.02 262.56,54.02 261.65,54.94 260.99,54.94 260.58,54.53 260.58,53.16 259.29,51.86 259.29,49.47 258,48.18 257.03,48.18 255.78,46.94 255,46.94 253.57,45.51 253.19,45.51 252.57,44.9 252.57,44.72 251.99,44.14 251.81,44.14 248.56,40.89 247.46,40.89 247.32,40.75 246.82,40.75 246.18,40.12 245.54,40.12 244.2,38.78 244.2,37.63 237.43,30.86 237.43,29.37 v1(237.47,29.33)
  IN4 w0.254: v1(211.95,24.63) 211.9,24.68 211.9,24.99 212.89,25.98 218.2,25.98 218.48,26.26 221.31,26.26 221.64,25.93 221.64,25.34 222.78,24.2 226.22,24.2 227.97,22.45 232.16,22.45 234.45,24.74 234.45,26.11 236.54,28.2 236.97,28.2 237.47,28.7 v1(237.47,29.33)
  BOTTOM w0.254: CE46.2 123.85,25.86 QE7.2 125.19,26.72 125.83,26.72 125.99,26.55 QE7.1 126.35,26.27 126.67,26.59 127.16,26.59 130.18,23.57 138.59,23.57 140.11,25.09 195.69,25.09 196.17,24.61 197.41,24.61 197.67,24.34 197.67,24.09 v1(197.62,24.04)
REM_DIODE2_P: length 184.6
  TOP w0.254: v1(211.36,24.63) 211.36,24.64 CE37.1 210.24,26.61 QE5.2 210.63,27.51 QE5.1 ; UE1.A9 265.62,55.41 265.65,55.45 265.65,55.84 265.97,56.16 265.97,57.39 CE26.2 265.96,57.8 265.96,58.27 v1(265.95,58.28)
  IN3 w0.254: v1(198.22,24.04) 198.37,23.89 198.91,23.89 200.1,22.7 201.65,22.7 205.1,19.26 206.94,19.26 207.71,20.03 207.71,20.46 211.38,24.13 211.38,24.61 v1(211.36,24.63) ; v1(236.88,29.33) 236.92,29.37 236.92,31.07 243.69,37.84 243.69,38.99 245.33,40.62 245.97,40.62 246.75,41.4 248.35,41.4 251.6,44.65 251.78,44.65 252.06,44.93 252.06,45.11 252.98,46.02 253.36,46.02 254.78,47.44 255.57,47.44 256.82,48.69 257.79,48.69 258.78,49.68 258.78,52.07 260.07,53.37 260.07,54.74 260.78,55.44 261.86,55.44 262.77,54.53 263.37,54.53 266,57.16 266,58.23 v1(265.95,58.28)
  IN4 w0.254: v1(236.88,29.33) 236.88,28.83 236.76,28.71 236.33,28.71 233.94,26.32 233.94,24.95 231.95,22.96 228.18,22.96 226.43,24.71 222.99,24.71 222.15,25.55 222.15,26.14 221.52,26.77 218.27,26.77 217.99,26.49 212.68,26.49 211.39,25.2 211.39,24.65 v1(211.36,24.63)
  BOTTOM w0.254: v1(198.22,24.04) 198.18,24.08 198.18,24.55 197.62,25.12 196.38,25.12 195.9,25.59 139.89,25.59 138.38,24.08 130.39,24.08 127.37,27.1 126.34,27.1 126.22,27.22 124.98,27.22 124.67,26.92 QE7.3 123.95,26.78 CE46.1
REM_DIODE4_N: length 298.8
  TOP w0.076: UE1.A11 267.32,54.24 267.32,54.73
  TOP w0.254: 267.32,54.73 267.32,54.84 267.8,55.32 267.8,56.12 CE27.1 268.1,56.42 v2(268.1,57.26) 268.1,58.34 v1(268.18,58.42)
  IN3 w0.254: v1(68.38,81.56) 68.36,81.53 68.36,80.84 69.14,80.05 69.14,75.95 70,75.1 70,72.93 73.13,69.8 73.13,68.3 73.44,67.99 73.44,67.12 73.16,66.84 73.16,64.45 67.94,59.23 67.94,57.97 68.55,57.36 68.68,57.36 70.06,55.99 70.06,49.65 72.23,47.48 72.23,45.38 72.6,45 85.48,45 98.09,32.39 146.52,32.39 146.73,32.61 172.46,32.61 173.94,34.08 177.39,34.08 179.8,36.5 188.73,36.5 190.56,34.67 194.24,34.67 194.49,34.92 206.72,34.92 207.89,33.75 209.66,33.75 210.39,33.03 213.62,33.03 214.47,32.18 216.72,32.18 218.22,33.68 220.16,33.68 220.82,34.34 224.62,34.34 225.47,35.19 227.98,35.19 228.91,36.11 232.47,36.11 232.9,36.55 234.25,36.55 235.71,38.01 236.26,38.01 236.78,38.53 237.89,38.53 238.37,39.01 238.37,39.54 241.3,42.46 241.58,42.46 241.94,42.82 241.94,43.01 243.05,44.12 243.77,44.12 243.95,44.29 244.2,44.29 245.29,45.39 246.06,45.39 246.62,44.83 247.19,44.83 250.99,48.62 252.87,48.62 254.33,50.09 254.75,50.09 254.99,50.08 255.83,50.93 255.83,53.51 256.98,54.66 256.98,56.14 258.34,57.5 262.47,57.5 262.66,57.31 264.12,57.31 264.72,57.92 264.72,58.78 265.82,59.88 267.2,59.88 268.13,58.95 268.13,58.44 268.15,58.42 v1(268.18,58.42)
  IN4 w0.254: v1(92.12,80.84) 90.85,80.84 89.83,81.87 88.97,81.87 88.29,82.55 88.29,84.1 87.74,84.65 86.01,84.65 85.63,85.04 74.32,85.04 70.74,81.45 68.49,81.45 v1(68.38,81.56)
  BOTTOM w0.254: CE39.1 90.34,80.69 90.73,80.69 QE6.3 91.84,81.13 v1(92.12,80.84)
REM_DIODE4_P: length 301.8
  TOP w0.076: 266.82,54.73 266.8,54.72 266.8,53.72 UE1.B10
  TOP w0.254: 266.82,54.73 266.82,55.1 267.29,55.58 267.29,56.16 CE27.2 267.59,56.83 v1(267.59,58.43)
  IN3 w0.254: v1(67.8,81.56) 67.85,81.51 67.85,80.63 68.64,79.84 68.64,75.74 69.49,74.89 69.49,72.72 72.62,69.59 72.62,68.09 72.93,67.78 72.93,67.33 72.65,67.05 72.65,64.66 67.43,59.44 67.43,57.76 68.34,56.86 68.47,56.86 69.55,55.77 69.55,49.44 71.72,47.27 71.72,45.17 72.39,44.5 85.27,44.5 97.88,31.89 146.73,31.89 146.94,32.1 172.67,32.1 174.15,33.57 177.6,33.57 180.01,35.99 188.52,35.99 190.35,34.16 194.45,34.16 194.7,34.41 206.51,34.41 207.68,33.24 209.45,33.24 210.18,32.52 213.41,32.52 214.26,31.67 216.93,31.67 218.43,33.17 220.37,33.17 221.04,33.83 224.83,33.83 225.68,34.68 228.19,34.68 229.12,35.61 232.68,35.61 233.11,36.04 234.46,36.04 235.92,37.5 236.47,37.5 236.99,38.02 238.1,38.02 238.88,38.8 238.88,39.33 241.51,41.96 241.79,41.96 242.45,42.61 242.45,42.8 243.26,43.61 243.98,43.61 244.16,43.79 244.41,43.79 245.5,44.88 245.85,44.88 246.41,44.32 247.4,44.32 251.2,48.12 253.08,48.12 254.54,49.58 255.2,49.58 256.34,50.72 256.34,53.3 257.48,54.45 257.48,55.93 258.55,56.99 262.26,56.99 262.45,56.8 264.33,56.8 265.23,57.7 265.23,58.57 266.03,59.37 266.99,59.37 267.59,58.76 v1(267.59,58.43)
  IN4 w0.254: v1(92.13,80.2) 92.12,80.2 91.98,80.34 90.64,80.34 89.62,81.37 88.76,81.37 87.79,82.34 87.79,83.89 87.53,84.14 85.8,84.14 85.42,84.53 74.53,84.53 70.95,80.95 68.28,80.95 67.84,81.38 67.84,81.52 v1(67.8,81.56)
  BOTTOM w0.254: CE39.2 90.16,80.18 90.81,80.18 QE6.2 91.76,79.83 v1(92.13,80.2) 92.79,80.2 QE6.1
RES_BIAS: length 7.3
  TOP w0.102: RL13.1 261.97,79.14 v2(261.5,79.61) 260.78,79.61 259.73,78.57 259.73,76.95 260.36,76.33 260.36,75.76 260.12,75.52 UL1.12
RESET_IN#: length 6.3
  TOP w0.076: 256.8,52.73 257.37,52.73 257.6,52.96 258.36,52.96 258.59,52.73 258.78,52.73 258.97,52.53 UE1.C1
  TOP w0.102: RE362.1 RE361.1 254.69,52.75 254.77,52.75 254.79,52.73 256.8,52.73
RESET_OUT: length 11.5
  TOP w0.102: v1(261.23,48.91) 261.23,48.94 UE1.G4 ; v1(254.51,44.85) 254.51,44.5 254.06,44.04 RE548.2
  IN2 w0.122: v1(261.23,48.91) 261.13,48.81 260.02,48.81 259.52,48.31 256.86,48.31 255.48,46.92 255.3,46.92 254.69,46.31 254.69,45.03 v1(254.51,44.85)
  BOTTOM w0.102: v2(254.11,45.31) 254.51,44.9 v1(254.51,44.85)
RESET_OUT#_R: length 5.6
  BOTTOM w0.102: JXDP1.47 91.64,97.04 v2(90.64,96.05) 90.21,95.61 CC33.1 90.21,93.92 RC129.2 RC128.2
RING2: length 2.5
  IN2 w1.016: 271.76,17.5 271.02,17.5 270.18,18.33 270.18,18.94
  vias: v1(268.91,19.76) v1(269.3,19.3) v1(272.29,16.91) v1(272.88,16.91) v2(272.58,17.33)
RING2_R: length 22
  TOP w1.016: 276.41,15.54 276.41,14.68 276.76,14.32 276.76,14.09 278.82,12.03 278.82,10.69 279.65,9.86
  IN2 w1.016: 295.33,13.2 295.3,13.23 285.53,13.23 283.27,10.97 282.88,10.97 281.74,9.83
  vias: v1(280.45,8.86) v1(281.03,8.89) v3(276.76,16.25)
RJ45_MDIN0: length 28.9
  BOTTOM w0.229: JLOM1.2 285.71,79.44 284.54,79.44 284.1,79 283.71,79 283.27,79.44 282.88,79.44 274.58,87.75 v4(274.58,89.29) 274.58,91.01 270.93,94.66 270.37,94.66 270.13,94.9 270.13,95.44 269.9,95.67 269.41,95.67 269.27,95.8 269.27,96.31 268.94,96.64 268.74,96.64 268.58,96.48 268.58,96.16 268.45,96.03 TL1.14
RJ45_MDIN1: length 27.5
  TOP w0.229: JLOM1.6 284.06,77.14 280.67,77.14 v4(276.16,81.64) 271.39,86.42 271.39,89.7 270.43,90.66 270.11,90.66 269.71,90.27 v1(269.71,90.18)
  BOTTOM w0.229: TL1.20 268.61,90.03 268.79,90.2 268.79,90.41 268.92,90.54 269.49,90.54 269.71,90.31 v1(269.71,90.18)
RJ45_MDIN2: length 28.3
  BOTTOM w0.229: TL1.17 270.3,93.03 272.99,90.33 272.99,87.09 v4(274.6,85.49) 283.64,76.45 JLOM1.5
RJ45_MDIN3: length 26.1
  BOTTOM w0.229: TL1.23 268.67,87.03 268.81,87.17 268.81,87.57 268.93,87.68 269.43,87.68 269.78,87.33 269.78,85.78 v4(275.82,79.74) 280.04,75.52 282.32,75.52 283.7,74.14 285.47,74.14 285.83,73.78 285.83,73.45 JLOM1.8
RJ45_MDIP0: length 28.9
  BOTTOM w0.229: JLOM1.1 285.51,80.53 284.77,79.79 283.03,79.79 274.92,87.89 274.92,91.16 v4(273.78,92.29) 269.05,97.03 TL1.13
RJ45_MDIP1: length 27.5
  TOP w0.229: v1(269.72,91.03) 270.55,91.03 271.73,89.84 271.73,86.56 v4(273.91,84.38) 280.81,77.48 284.14,77.48 285.15,78.49 JLOM1.3
  BOTTOM w0.229: v1(269.72,91.03) TL1.19
RJ45_MDIP2: length 28.3
  BOTTOM w0.229: JLOM1.4 285.83,77.41 285.83,77.01 285.61,76.79 283.78,76.79 v4(276.99,83.58) 273.33,87.24 273.33,90.47 270.44,93.37 268.93,93.37 268.79,93.51 268.79,93.9 268.66,94.03 TL1.16
RJ45_MDIP3: length 26.1
  BOTTOM w0.229: JLOM1.7 286.8,74.48 283.84,74.48 282.46,75.87 280.18,75.87 v4(273.54,82.51) 270.12,85.92 270.12,87.47 269.57,88.03 TL1.22
RTCRST_ON: length 18.4
  TOP w0.076: UE1.F11 v1(266.86,49.77)
  TOP w0.102: RE565.2 263.5,60.19 QE12.2 263.51,60.38 v1(263.97,60.84) 264.27,60.55 264.27,59.85 264.99,59.13 RE93.1
  IN4 w0.089: v1(263.97,60.84) 264.11,60.7 264.11,56.79 264.19,56.71 264.19,54.9 264.84,54.25 264.84,51.13 265.03,50.94 266.26,50.94 266.45,50.75 266.45,50.19 v1(266.86,49.77)
  BOTTOM w0.102: v1(263.97,60.84) v2(263.97,60.28)
RTCRST_ON_R: length 24.4
  TOP w0.102: RE543.1 v1(276.53,66.09) ; DE2.2 257.31,60.97 CE65.1 258.06,61.92 QE17.2 v1(258.92,61.65)
  BOTTOM w0.102: v1(258.92,61.65) 258.92,61.88 260.13,63.09 265.41,63.09 265.94,62.56 270.36,62.56 271.1,63.29 274.96,63.29 v2(275.99,64.33) 276.53,64.87 v1(276.53,66.09)
RTD3_CIO_PWR_EN: length 5.1
  BOTTOM w0.076: UC1.AC2 140.02,61.13 140.78,61.13 140.8,61.11 141.91,61.11 142.57,60.45
  BOTTOM w0.102: 142.57,60.45 143.01,60.45 143.81,59.65 T18.1
RUN_ON: length 277
  TOP w0.102: v1(177.64,62.23) 177.61,62.23 177.59,62.2 UZ3.5 ; v1(136.08,91.63) 136.88,92.43 v2(137.62,92.43) 138.21,93.01 151.24,93.01 v1(151.95,92.29) ; v1(184.23,49.07) 181.69,46.53 178.67,46.53 PR402.1 ; RE280.2 RE292.1 275.66,39.23 276.26,39.83 UE5.4 277.64,39.83 279.33,41.53 279.33,44.24 278.34,45.23 v1(278.34,45.89) ; v1(216.62,27.07) 216.55,27.14 216.55,28.21 216.16,28.61 216.16,29.08 217.48,30.4 217.48,32.48 216.84,33.12 215.7,33.12 215.68,33.14 UZ4.3 ; QE2.2 248.94,49.38 v1(249,49.32) ; v1(238.03,44.88) 237.8,44.88 237.37,44.45 237.37,43.98 237.37,43.96 236.1,42.69 236.1,39.47 236.28,39.29 RZ345.1
  IN1 w0.089: v1(238.03,44.88) 238.05,44.88 239.07,45.89 240.97,45.89 241.61,46.53 242.63,46.53 243.43,47.33 246.65,47.33 246.84,47.52 247.93,47.52 248.85,48.43 248.85,49.17 v1(249,49.32) 249.1,49.22 249.1,48.89 249.43,48.56 253.55,48.56 254.88,47.23 254.88,46.21 255.33,45.77 256.47,45.77 257.05,46.35 260.99,46.35 261.19,46.15 262.82,46.15 263.07,45.89 265.65,45.89 265.88,46.12 270.62,46.12 272.37,44.37 276.66,44.37 278.19,45.89 v1(278.34,45.89) ; v1(233.84,28.49) 233.52,28.18 229.81,28.18 229.52,28.47 224.04,28.47 223.41,29.1 222.59,29.1 221.79,28.31 218.21,28.31 216.98,27.07 v1(216.62,27.07) 216.62,26.89 216.29,26.56 212.9,26.56 209.37,30.1 207.42,30.1 205.01,32.51 201.81,32.51 200.84,33.47 199.47,33.47 197.21,35.73 194.67,35.73 194.26,36.14 190.3,36.14 184.1,42.34 v1(182.3,42.34)
  IN2 w0.122: v1(182.3,42.34) 184.23,44.27 v1(184.23,49.07) 184.23,54.51 179.93,58.81 179.93,60.6 178.3,62.23 v1(177.64,62.23) 177.18,62.23 165.3,74.11 162.21,74.11 161.28,75.04 161.28,75.93 162.52,77.16 162.52,77.58 159.76,80.34 159.76,80.83 158.96,81.62 158.47,81.62 155.5,84.6 155.5,88.95 153.18,91.27 152.98,91.27 v1(151.95,92.29)
  BOTTOM w0.102: v1(233.84,28.49) 232.5,27.16 231.7,27.16 229.1,24.56 226.72,24.56 225.29,25.99 224.1,25.99 223.4,26.69 223.4,27.2 227.84,31.65 227.84,38.07 225.86,40.05 225.86,41.3 228.17,43.61 230.18,43.61 230.84,44.27 235.54,44.27 236.02,44.75 237.93,44.75 238.05,44.88 v1(238.03,44.88) ; UZ35.2 139.12,88.1 138.9,88.31 136.68,88.31 RZ320.1 136.37,88.67 136.9,89.19 136.9,90.82 v1(136.08,91.63)
RUN_ON#: length 12.2
  TOP w0.102: RE68.1 250.25,51.1 250.25,50.43 250.24,50.42 QE2.6 251.06,50.03 251.23,49.86 v2(251.23,49.47) 251.14,49.38 QE2.5 250.87,48.75 250.87,48.49 250.71,48.33 247.98,48.33 247.53,48.79 246.41,48.79 246.23,48.61 244.92,48.61 QZ4.2
RUN_ON_1.8V: length 8.5
  TOP w0.102: v2(237.48,42.62) 237.34,42.48 237.34,41.75 236.66,41.07 CZ197.1 RZ345.2 237.61,40.2 238.28,39.53 238.28,39.06 237.7,38.48 236.22,38.48 235.91,38.16 UZ8.3
RUN_ON_EC: length 45.3
  TOP w0.102: v1(277.52,40.34) 277.5,40.36 276.28,40.36 274.74,38.82 RE292.2 274.1,39.45 274.1,40.23 274.36,40.48 UE5.2 ; v1(264.11,37.77) 264.23,37.65 RPE10.4 ; v1(265.24,51.33) 264.85,50.93 UE1.E8
  IN4 w0.089: v1(277.52,40.34) 275.69,38.5 272.06,38.5 271.58,38.02 270.67,38.02 269.75,37.11 266.02,37.11 264.85,38.27 264.62,38.27 v1(264.11,37.77)
  BOTTOM w0.102: v1(277.52,40.34) 277.52,41.7 277.99,42.17 277.99,44.8 276.58,46.21 276.58,48.51 276.03,49.07 275.39,49.07 273.84,50.62 269.4,50.62 268.76,51.25 266.73,51.25 266.25,51.74 265.65,51.74 v1(265.24,51.33)
RUNPWROK: length 224.5
  TOP w0.102: v1(104.14,97.25) 104.15,97.25 UC8.4 ; UC8.13 v1(103.15,101.47) 101.24,101.47 99.95,100.18 99.95,99.23 100.36,98.83 101.89,98.83 102.17,99.11 UC8.1 ; 247.86,49.7 247.83,49.68 245.99,49.68 245.28,48.97 243.81,48.97 243.21,49.56 v1(243.21,50.24) ; 247.86,49.7 247.86,50.34 RE67.1 ; 247.86,49.7 247.86,49.04 248.17,48.73 QE2.3 ; UC8.10 v1(104.65,101.47) ; v1(261.24,49.77) 260.82,49.36 UE1.G3
  IN1 w0.089: v1(103.15,101.47) v1(104.65,101.47) 104.72,101.47 105.74,100.45 107.07,100.45 109.28,98.24 123.35,98.24 124.43,97.16 157.07,97.16 158.3,95.93 163.55,95.93 169.24,90.24 175.37,90.24 v1(175.87,90.75)
  IN3 w0.122: v1(175.87,90.75) 176.29,90.75 176.59,90.46 176.59,89.96 178.49,88.06 178.49,77.65 186.24,69.9 186.24,63.85 186.52,63.57 186.52,60.49 199.72,47.28 203.24,47.28 207.48,43.04 225.76,43.04 226.41,43.68 229.36,43.68 229.94,44.27 235.02,44.27 237.55,46.8 238.88,46.8 240.17,48.09 240.68,48.09 240.97,48.38 240.97,48.82 242.39,50.24 v1(243.21,50.24)
  IN4 w0.089: v1(261.24,49.77) 259.06,49.77 258.73,50.11 256.32,50.11 256.16,50.26 254.51,50.26 254.18,50.59 253.24,50.59 252.91,50.26 248.26,50.26 247.68,49.68 246.03,49.68 245.29,48.94 243.83,48.94 243.21,49.56 v1(243.21,50.24)
  BOTTOM w0.102: v2(104.27,96.36) 103.97,96.67 103.97,97.07 v1(104.14,97.25) 104.14,97.93 104.65,98.43 v1(104.65,101.47)
SA_SNUB: length 1.9
  TOP w0.102: PR627.2 94.53,84.07 v2(95.37,84.07)
SA_SW: length 10.3
  TOP w0.102: v1(94.37,87.52) v2(95.04,87.52)
  IN1 w0.508: v1(86.35,85.59) 86.35,85.48 86.9,84.93 91.14,84.93 v1(93.73,87.52)
  BOTTOM w0.381: v1(86.35,85.59) 85.67,85.59 PR619.2
SA_UGATE: length 4.2
  TOP w0.102: v1(86.29,86.23) v2(86.86,86.23)
  IN1 w0.508: v1(89.04,86.9) 87.59,86.9 86.92,86.23 v1(86.29,86.23)
  BOTTOM w0.508: PQ614.1 v1(89.04,86.9)
SATA_PRX_C_DTX_N0: length 34.4
  TOP w0.094: v1(224.25,14.49) 223.97,14.78 223.97,15.12 224.06,15.21 CN6.1
  BOTTOM w0.094: v1(224.25,14.49) 223.85,14.89 223.85,15.31 225.73,17.19 227.27,17.19 228.79,18.72 235.52,18.72 236.91,17.32 236.91,16.75 237.42,16.24 237.81,16.24 238.31,15.74 238.31,14.53 239.39,13.45 240.05,13.45 240.53,12.97 240.53,12.92 240.95,12.51 240.99,12.51 v4(242.48,11.02) 244.81,8.7 245.43,8.7 245.56,8.82 246.12,8.82 246.68,8.82 247.13,8.37 247.28,8.37 247.96,8.37 248.09,8.23 248.09,8.02 247.9,7.82 JSATA1.5
SATA_PRX_C_DTX_P0: length 34.4
  TOP w0.094: CN7.1 223.78,14.94 223.78,14.61 v1(223.66,14.49)
  BOTTOM w0.094: JSATA1.6 248.4,7.82 248.28,7.94 248.28,8.31 248.04,8.55 247.88,8.55 247.88,8.55 247.21,8.55 246.75,9.01 245.48,9.01 245.36,8.88 244.88,8.88 242.85,10.92 242.85,10.96 242.42,11.38 242.38,11.38 v4(240.89,12.87) 240.13,13.64 239.47,13.64 238.5,14.61 238.5,15.82 237.88,16.43 237.49,16.43 237.1,16.83 237.1,17.4 235.59,18.9 228.71,18.9 227.19,17.38 225.66,17.38 223.66,15.38 v1(223.66,14.49)
SATA_PRX_C_RD_DTX_N0: length 2.6
  TOP w0.094: UN7.4 224.47,22.82 224.31,22.98 224.31,23.45 224.27,23.49 224.27,24.1 224.24,24.13 224.24,24.45 CN14.2
SATA_PRX_C_RD_DTX_P0: length 2.6
  TOP w0.094: UN7.5 223.97,22.82 224.13,22.98 224.13,23.34 224.05,23.41 v4(224.05,23.73) 224.05,24.45 CN15.2
SATA_PRX_DTX_N0: length 140.4
  TOP w0.094: v1(225.22,26.88) 225.02,26.68 225.02,26.51 224.59,26.08 CN14.1
  IN4 w0.076: 129.3,71.66 129.3,71.65 129.31,71.64 129.31,71.59 129.31,71.58 129.31,70.76 129.57,70.51 v1(130.18,70.51) ; 129.3,73.33 129.31,73.34 129.31,73.39 129.3,73.4 129.3,73.41
  IN4 w0.089: v1(225.22,26.88) 225.22,27.48 225,27.71 224.79,27.71 223.27,29.23 222.26,29.23 222.13,29.11 218.16,29.11 217.81,29.46 210.19,29.46 207.24,32.41 207.24,33.09 204.35,35.99 202.75,35.99 199.42,39.32 197.95,39.32 192.18,45.08 190.81,45.08 188.22,47.67 188.22,52.96 182.5,58.67 182.5,59.92 181.41,61.01 181.41,61.31 179.62,63.1 179.62,64.24 176.85,67.02 174,67.02 172.91,68.11 172.19,68.11 168.24,72.05 168.24,72.05 167.6,72.69 164.52,72.69 163.04,74.17 160.48,74.17 160.2,74.45 155.88,74.45 151.51,78.81 147.58,78.81 145.3,76.53 141.87,76.53 141.1,77.3 139.79,77.3 138.41,75.92 137.39,75.92 136.86,76.45 136.86,78.84 136.12,79.57 134.4,79.57 132.59,81.38 132.06,81.38 130.87,80.19 130.87,76.78 129.3,75.21 129.3,73.41 ; 129.3,71.66 129.3,73.33
  BOTTOM w0.076: v1(130.18,70.51) 129.95,70.28 UC1.F20
SATA_PRX_DTX_P0: length 140.5
  TOP w0.094: CN15.1 224.2,26.21 224.46,26.21 224.81,26.57 224.81,26.7 v1(224.64,26.88)
  IN4 w0.076: v1(130.2,71.17) 130.2,71.06 129.81,70.67 129.64,70.67 129.48,70.83 129.48,71.66
  IN4 w0.089: v1(224.64,26.88) 225.04,27.28 225.04,27.41 224.92,27.53 224.72,27.53 223.2,29.05 222.33,29.05 222.21,28.93 218.09,28.93 217.74,29.28 210.11,29.28 207.06,32.33 207.06,33.02 204.27,35.81 202.67,35.81 199.34,39.14 197.87,39.14 192.1,44.9 190.73,44.9 188.04,47.6 188.04,52.88 182.32,58.6 182.32,59.84 181.23,60.93 181.23,61.24 179.44,63.02 179.44,64.17 176.77,66.84 173.93,66.84 172.84,67.93 172.11,67.93 168.17,71.87 167.52,72.51 164.44,72.51 162.97,73.99 160.41,73.99 160.13,74.27 155.81,74.27 151.44,78.63 147.65,78.63 145.37,76.35 141.8,76.35 141.03,77.12 139.87,77.12 138.49,75.74 137.32,75.74 136.68,76.38 136.68,78.76 136.05,79.39 134.32,79.39 132.52,81.2 132.13,81.2 131.05,80.11 131.05,76.71 129.48,75.14 129.48,71.66
  BOTTOM w0.076: UC1.E20 129.96,70.93 v1(130.2,71.17)
SATA_PRX_RD_DTX_N0: length 2.7
  TOP w0.094: UN7.12 224.47,17.92 224.32,17.77 224.32,17.58 224.35,17.56 224.35,16.96 224.32,16.93 224.32,16.87 224.31,16.86 224.31,16.84 224.05,16.58 224.05,16.48 CN6.2
SATA_PRX_RD_DTX_P0: length 2.7
  TOP w0.094: UN7.11 223.97,17.92 224.13,17.76 v4(224.13,17.26) 224.13,16.92 223.86,16.65 223.86,16.48 CN7.2
SATA_PTX_C_DRX_N0: length 25.8
  TOP w0.094: v1(227.33,14.49) 227.49,14.64 227.49,14.92 CN5.1
  BOTTOM w0.094: v1(227.33,14.49) 227.33,15.07 227.55,15.29 229.48,15.29 230.69,14.08 230.69,12.75 232.03,11.41 239.68,11.41 239.72,11.44 240.48,11.44 240.51,11.41 241.22,11.41 v4(242.92,9.71) 244.33,8.3 245.61,8.3 245.74,8.42 246.35,8.42 246.51,8.42 246.77,8.16 246.77,8.16 246.82,8.11 246.82,7.92 246.9,7.84 JSATA1.3
SATA_PTX_C_DRX_P0: length 25.7
  TOP w0.094: CN4.1 227.72,15.21 227.67,15.17 227.67,14.71 227.89,14.49 v1(227.92,14.49)
  BOTTOM w0.094: v1(227.92,14.49) 227.8,14.49 227.74,14.55 227.74,14.66 227.52,14.88 227.52,14.99 227.63,15.1 229.4,15.1 230.5,14 230.5,12.67 231.95,11.22 v4(240.01,11.22) 241.14,11.22 242.56,9.81 242.56,9.76 242.98,9.34 243.02,9.34 244.26,8.11 245.68,8.11 245.81,8.24 246.44,8.24 246.59,8.09 246.59,7.95 246.4,7.76 JSATA1.2
SATA_PTX_C_RD_DRX_N0: length 2.7
  TOP w0.094: UN7.2 225.47,22.87 225.63,23.03 225.63,23.18 225.96,23.51 v4(225.96,23.8) 225.96,24.45 CN13.2
SATA_PTX_C_RD_DRX_P0: length 2.8
  TOP w0.094: CN12.2 226.14,24.45 226.14,24.13 226.17,24.1 226.17,23.47 225.81,23.11 225.81,23.03 225.97,22.87 UN7.1
SATA_PTX_DRX_N0: length 142.1
  TOP w0.094: CN13.1 226.1,26.21 226.3,26.21 226.36,26.27 226.51,26.27 226.51,26.27 226.79,26.27 226.89,26.37 226.89,26.48 v1(226.49,26.88)
  IN4 w0.089: v1(226.49,26.88) 226.9,27.28 226.9,27.46 224.67,29.69 220.88,29.69 220.55,30.02 217.86,30.02 217.71,29.87 212.35,29.87 210.67,31.54 210.67,32.13 209.22,33.57 207.32,33.57 204.4,36.5 202.95,36.5 199.72,39.72 198.1,39.72 192.31,45.51 190.93,45.51 188.73,47.72 188.73,53.01 183.01,58.72 183.01,60.93 182.5,61.44 181.87,61.44 180.02,63.29 180.02,64.41 177.01,67.41 174.16,67.41 173.08,68.5 172.35,68.5 167.65,73.2 164.6,73.2 162.18,75.61 156.65,75.61 155.46,76.8 155.46,78.22 154.38,79.29 152.97,79.29 151.99,80.27 151.04,80.27 149.99,79.22 147.3,79.22 145.44,77.36 143.67,77.36 143.09,77.95 141.13,77.95 139.58,79.5 138.28,79.5 137.65,80.13 134.4,80.13 132.41,82.12 132.16,82.12 130.98,80.95 130.48,80.95 127.74,78.2 127.74,76.88 127.94,76.68 128.06,76.68 v1(128.4,77.02)
  BOTTOM w0.076: v1(128.4,77.02) 128.64,76.77 128.87,76.77 129.15,76.49 129.15,75.29 129.15,74.29 128.97,74.12 128.97,73.32 128.8,73.15 128.66,73.15 UC1.B21
SATA_PTX_DRX_P0: length 142.1
  TOP w0.094: v1(227.08,26.88) 227.08,26.29 226.87,26.08 226.43,26.08 226.34,25.99 226.34,25.86 226.48,25.71 CN12.1
  IN4 w0.089: v1(128.4,76.35) 128.25,76.5 127.87,76.5 127.56,76.81 127.56,78.28 130.41,81.13 130.91,81.13 132.08,82.3 132.48,82.3 134.47,80.31 137.72,80.31 138.36,79.68 139.65,79.68 141.2,78.13 143.16,78.13 143.74,77.54 145.37,77.54 147.22,79.4 149.91,79.4 150.97,80.45 152.06,80.45 153.04,79.47 154.46,79.47 155.64,78.29 155.64,76.88 156.72,75.79 162.26,75.79 164.67,73.38 167.73,73.38 172.42,68.68 173.15,68.68 174.24,67.59 177.08,67.59 180.2,64.48 180.2,63.36 181.94,61.62 182.58,61.62 183.19,61.01 183.19,58.8 188.91,53.08 188.91,47.8 191.01,45.69 192.38,45.69 198.17,39.9 199.8,39.9 203.02,36.68 204.47,36.68 204.79,36.36 207.39,33.76 209.3,33.76 210.85,32.2 210.85,31.62 212.42,30.05 217.63,30.05 217.78,30.2 220.63,30.2 220.96,29.87 224.74,29.87 227.08,27.53 v1(227.08,26.88)
  BOTTOM w0.076: v1(128.4,76.35) 128.65,76.61 128.8,76.61 128.98,76.42 128.98,75.25 128.98,74.36 128.81,74.19 128.81,73.39 128.73,73.31 128.51,73.31 128.45,73.38 128.45,73.58 UC1.A21
SATA_PTX_RD_DRX_N0: length 4.1
  TOP w0.094: UN7.14 225.47,17.79 225.63,17.63 225.63,17.46 225.89,17.2 v4(226.79,17.2) 227.25,17.2 227.55,16.9 227.55,16.48 CN5.2
SATA_PTX_RD_DRX_P0: length 4.1
  TOP w0.094: CN4.2 227.73,16.48 227.73,16.98 227.32,17.4 227.09,17.4 227.07,17.42 226.51,17.42 226.49,17.4 225.96,17.4 225.81,17.54 225.81,17.63 225.97,17.79 UN7.15
SATALED#: length 236.8
  TOP w0.102: RN101.2 260.13,32.23 v1(260.07,32.18) ; v1(146.59,70.53) 146.59,70.05 146.93,69.7 150.68,69.7 150.85,69.87 151.28,69.87 151.54,70.13 151.89,70.13 152.69,70.94 154.49,70.94 154.76,70.67 RPC4.2 155.44,70.67 155.63,70.86 155.63,71.32 155.95,71.64 157.18,71.64 159.12,69.69 164.23,69.69 165.45,68.47 167.56,68.47 169.78,66.26 169.78,65.1 169.18,64.51 169.18,62.65 168.15,61.62 168.15,61 167.68,60.53 167.68,54.04 168.12,53.6 168.12,50.36 166.63,48.87 163.74,48.87 163.38,48.5 163.38,47.7 163.05,47.37 163.05,46.56 164.09,45.51 164.83,45.51 166.69,43.66 182.88,43.66 185.29,41.25 199.59,41.25 v2(200.26,40.59) 201.93,38.91 202.85,38.91 203.36,39.42 v1(205.77,39.42) ; v1(280.2,38.38) 280.44,38.61 QZ2.4 ; v1(232.16,34.97) 232.19,34.95 232.19,34.29 234.85,31.62 v1(234.85,31.34)
  IN1 w0.089: v1(234.85,31.34) 234.88,31.31 237.88,31.31 241.02,34.46 245.51,34.46 245.74,34.24 250.27,34.24 251.79,32.71 256.9,32.71 257.23,32.38 258.8,32.38 259.08,32.65 259.6,32.65 v1(260.07,32.18) 261.01,33.12 262.89,33.12 263.15,33.37 263.15,33.52 263.88,34.26 265.99,34.26 266.37,33.88 268.2,33.88 270.23,35.91 276.05,35.91 276.38,36.25 278.08,36.25 v1(280.2,38.38)
  IN3 w0.122: v1(260.07,32.18) 260.07,32.38 259.77,32.69 259.03,32.69 258.37,32.03 258.37,31.67 256.98,30.27 256.98,28.49 255.53,27.05 255.53,23.47 257.61,21.38 258.97,21.38 260.1,20.25 260.1,17.28 259.44,16.62 259.44,13.72 261.56,11.6 262.23,11.6 262.61,11.22 262.61,10.98 262.88,10.71 274.35,10.71 v1(275.26,11.63)
  IN4 w0.089: v1(232.16,34.97) 231.7,34.51 229.85,34.51 229.42,34.95 223.5,34.95 223.17,34.62 217.81,34.62 217.28,34.08 213.54,34.08 210.34,37.28 209.83,37.28 208.82,38.3 206.89,38.3 v1(205.77,39.42)
  BOTTOM w0.076: UC1.H1 140.32,69.52 140.87,69.52 141.41,70.06 141.41,70.52 142.44,71.55
  BOTTOM w0.102: v1(146.59,70.53) 146.31,70.25 146,70.25 144.43,71.83 142.72,71.83 142.44,71.55 ; RN100.2 275.77,13.13 275.31,12.67 275.31,11.68 v1(275.26,11.63)
SBIOS_TX: length 125
  TOP w0.102: v1(230.48,19.76) 230.56,19.68 v2(230.56,18.4) 230.56,16.66 230.5,16.6 RE306.1
  IN4 w0.089: v1(230.48,19.76) 230.48,20.02 230.32,20.19 222.88,20.19 220.88,22.19 217.58,22.19 216.76,23.01 213.64,23.01 213.27,22.63 208.59,22.63 207.69,21.73 202.79,21.73 200.38,24.13 200.38,25.65 199.22,26.81 199.22,28.35 195.22,32.36 193.81,32.36 187.55,38.61 187.55,39.1 181.25,45.4 181.25,51.65 178.75,54.15 173.97,54.15 173.14,53.32 173.14,52.84 172.81,52.51 172.27,52.51 170.86,53.93 167.08,53.93 165.75,55.25 164.08,55.25 163.41,55.91 163.41,56.37 162.42,57.37 161.95,57.37 161.36,57.97 159.45,57.97 159.37,57.88 155.91,57.88 155.53,58.26 155.53,59.31 154.73,60.1 154.73,61.07 154.37,61.43 153.33,61.43 153.02,61.74 152.13,61.74 151.92,61.52 151.1,61.52 150.82,61.81 145.53,61.81 145.11,61.39 143.01,61.39 v1(142.75,61.13)
  BOTTOM w0.076: v1(142.75,61.13) 142.32,61.57 141.62,61.57 141.18,62.01 140.86,62.01 140.75,61.9 140.39,61.9 140.1,62.18 UC1.AB2
SD/MMCCD#: length 17
  TOP w0.102: JSD1.9 93.07,96.33 v1(93.32,96.08) 93.68,96.44 v3(94.59,96.44)
  IN4 w0.089: v1(93.32,96.08) 92.89,96.52 91.01,96.52 90.61,96.11 86.97,96.11 83.77,92.91 v1(82.22,92.91)
  BOTTOM w0.102: UR1.30 81.98,93.15 v1(82.22,92.91)
SD/MMCCLK: length 3
  BOTTOM w0.102: UR1.17 77.97,96.1 77.2,96.87 RR5.1
SD/MMCCLK_R: length 30.1
  TOP w0.102: v3(89.79,94.46) 89.17,95.08 89.17,96.09 v1(88.72,96.54) 88.78,96.59 JSD1.5
  IN2 w0.122: v1(75.54,99.54) 75.09,99.54 74.93,99.69 74.93,100.22 75.11,100.4 75.87,100.4 76.03,100.25 76.03,99.95 76.13,99.85 76.13,98.82 76.25,98.7 76.49,98.7 76.61,98.82 76.61,99.42 76.74,99.54 76.98,99.54 77.1,99.42 77.1,98.82 77.22,98.7 77.4,98.7 78.26,97.84 78.43,97.84 79.15,98.56 79.32,98.56 79.87,98.01 79.87,97.83 79.62,97.59 79.62,97.42 79.8,97.24 79.97,97.24 80.21,97.49 80.39,97.49 81.08,96.8 81.27,96.8 81.39,96.67 81.39,96.49 81.51,96.36 81.75,96.36 81.88,96.49 81.88,96.67 82,96.8 83.06,96.8 83.18,96.67 83.18,96.13 83.3,96.01 83.55,96.01 83.67,96.13 83.67,96.67 83.79,96.8 84.03,96.8 84.24,96.58 84.24,96.02 84.38,95.88 84.73,95.88 84.84,95.98 84.84,96.29 84.99,96.44 86.11,96.44 86.26,96.29 86.26,96.03 86.42,95.88 88.86,95.88 89.01,96.03 89.01,96.26 v1(88.72,96.54)
  BOTTOM w0.102: RR5.2 CR21.1 75.65,99.44 v1(75.54,99.54)
