# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA0: length 59
  IN1 w0.076: v1(110.51,45.31) 111.48,44.34 111.48,43.15 111.31,42.97
  IN1 w0.142: v1(85.56,13.19) 83.93,14.81 83.93,19.09 85.77,20.92 85.77,21.64 86.78,22.65 87.5,22.65 90.56,25.71 98.18,25.71 109.97,37.51 109.97,38 109.97,38 109.97,40.24 110.8,41.07 110.8,42.46 111.31,42.97
  BOTTOM w0.076: 111.63,49.07 111.63,49.17 112.27,49.81 112.27,50.67 112.09,50.85 112.09,51.1 112.13,51.21 112.13,51.48 112.13,51.48 112.1,51.57 112.1,51.77 112.13,51.86 112.13,51.86 112.14,51.87 112.14,51.88 112.14,52.1 UC1.AY50
  BOTTOM w0.168: v1(85.56,13.19) 85.93,12.82 JDIMM1.144 ; 111.63,49.07 111.63,48.76 111.18,48.31 111.18,45.93 110.56,45.31 v1(110.51,45.31)
DDR_A_MA1: length 58.8
  IN1 w0.076: 109.55,39.74 109.55,40.2 110.55,41.19 110.55,42.59 111.23,43.28 111.23,43.94 v1(110.51,44.66)
  IN1 w0.142: v1(83.33,17.55) 83.14,17.55 82.85,17.84 82.85,18.87 85.34,21.37 85.34,21.47 85.34,22.32 86.72,23.7 86.95,23.7 87.33,23.32 87.57,23.32 87.73,23.48 87.73,23.72 87.36,24.1 87.36,24.34 87.52,24.5 87.76,24.5 88.14,24.12 88.37,24.12 88.54,24.29 88.54,24.53 88.16,24.9 88.16,25.14 88.33,25.31 88.56,25.31 88.94,24.93 89.18,24.93 89.34,25.09 89.34,25.33 88.96,25.71 88.96,25.94 89.17,26.15 97.98,26.15 109.55,37.72 109.55,39.74
  BOTTOM w0.076: 111.92,49.04 112.47,49.6 112.47,50.92 UC1.BB50
  BOTTOM w0.168: JDIMM1.133 83.18,19.14 83.81,18.51 83.81,18.03 v1(83.33,17.55) ; 111.92,49.04 111.92,48.54 111.61,48.23 111.61,45.76 v1(110.51,44.66)
DDR_A_MA2: length 60.1
  IN1 w0.076: v1(110.41,46.63) 110.12,46.33 110.12,41.28 108.7,39.86 108.7,39.74
  IN1 w0.142: 108.7,39.74 108.7,38.25 97.53,27.08 88.9,27.08 84.44,22.62 84.44,21.75 81.98,19.28 81.98,17.13 82.47,16.65 82.47,14.81 82.88,14.4 83.27,14.4 v1(83.49,14.63)
  BOTTOM w0.076: 111.94,49.78 112.1,49.94 112.1,50.59 111.92,50.77 111.92,51.14 111.97,51.24 111.97,51.45 111.93,51.54 111.93,51.56 111.93,51.8 111.97,51.89 111.97,52.1 111.94,52.18 111.94,52.18 111.9,52.28 111.9,52.48 UC1.AY51
  BOTTOM w0.142: 111.94,49.78 111.31,49.15 111.31,49.1 110.76,48.56 110.76,47.66
  BOTTOM w0.168: v1(110.41,46.63) 110.74,46.95 110.74,47.64 110.76,47.66 ; v1(83.49,14.63) 82.93,14.06 JDIMM1.132
DDR_A_MA3: length 59.1
  IN1 w0.076: v1(110.51,43.36) 110.34,43.18 110.34,41.24 109.12,40.03 109.12,39.74
  IN1 w0.142: 109.12,39.74 109.12,38.04 97.71,26.63 89.05,26.63 84.92,22.5 84.92,21.55 82.42,19.05 82.42,17.47 82.57,17.33 82.76,17.33 82.9,17.18 82.9,16.45 v1(83.33,16.03)
  BOTTOM w0.076: 112.2,48.94 112.2,49.04 112.65,49.5 112.65,51.38 UC1.BA50
  BOTTOM w0.168: 112.2,48.94 112.2,47.17 112.03,47.01 112.03,45.48 111.69,45.13 111.69,43.35 111.31,42.97 110.89,42.97 v1(110.51,43.36) ; JDIMM1.131 82.68,17.73 82.81,17.6 82.81,16.55 v1(83.33,16.03)
DDR_A_MA4: length 59
  IN1 w0.076: v1(109.19,47.02) 109.78,46.43 109.78,41.65 108.56,40.43 108.3,40.43 107.85,39.98 107.85,39.74
  IN1 w0.142: v1(81.5,15.5) 81.14,15.14 80.9,15.14 80.72,15.32 80.72,15.56 80.92,15.76 80.92,17.9 81.14,18.11 81.14,18.46 80.92,18.67 80.92,19.42 83.56,22.06 83.56,22.93 88.56,27.92 96.89,27.92 107.85,38.88 107.85,39.74
  BOTTOM w0.076: UC1.BB52 110.94,50.92 110.94,49.67 109.19,47.92 v1(109.19,47.02)
  BOTTOM w0.168: v1(81.5,15.5) 82.13,14.86 82.13,13.08 81.93,12.88 JDIMM1.128
DDR_A_MA5: length 59.5
  IN1 w0.076: v1(110.29,47.26) 109.94,46.92 109.94,41.51 109.9,41.46
  IN1 w0.142: v1(81.62,13.97) 81.92,13.67 82.21,13.67 82.46,13.92 82.46,14.21 82.05,14.62 82.05,16.47 81.35,17.17 81.35,17.72 81.56,17.94 81.56,18.63 81.35,18.84 81.35,19.25 83.99,21.89 83.99,22.76 88.73,27.5 97.07,27.5 108.27,38.71 108.27,39.84 109.9,41.46
  BOTTOM w0.076: UC1.BA51 111.48,51.77 111.48,51.55 111.47,51.54 111.47,51.54 111.47,51.53 111.44,51.45 111.44,51.25 111.47,51.16 111.47,50.8 111.27,50.6 111.27,49.42 110.29,48.43 v1(110.29,47.26)
  BOTTOM w0.168: JDIMM1.126 81.43,13.77 v1(81.62,13.97)
DDR_A_MA6: length 59.6
  IN1 w0.076: v1(109.22,45.82) 109.61,45.43 109.61,41.8 108.5,40.69 108.2,40.69 107.43,39.91 107.43,39.74
  IN1 w0.142: 107.43,39.74 107.43,39.06 96.71,28.35 88.38,28.35 83.14,23.1 83.14,22.24 80.5,19.6 80.5,15.95 80.3,15.75 v1(80.1,15.75)
  BOTTOM w0.076: v1(109.22,45.82) 109.19,45.82 108.83,46.19 108.83,47.82 110.77,49.77 110.77,51.18 111.04,51.45 UC1.BA52
  BOTTOM w0.168: v1(80.1,15.75) 80.35,15.75 81.34,16.73 81.34,18.71 81.68,19.05 JDIMM1.127
DDR_A_MA7: length 61.8
  IN1 w0.076: v1(109.24,45.19) 108.47,44.42 108.47,43.1 107.18,41.81
  IN1 w0.142: 107.18,41.81 106.96,41.81 96.75,31.59 88.48,31.59 79.28,22.39 79.28,21.52 78.07,20.3 78.07,17.22 79.15,16.14 79.15,14.16 80.25,13.06 v1(80.68,13.06)
  BOTTOM w0.076: UC1.AW52 111.14,52.78 110.82,52.46 110.82,51.91 110.61,51.7 110.61,49.88 108.66,47.93 108.66,45.77 v1(109.24,45.19)
  BOTTOM w0.168: v1(80.68,13.06) 80.43,12.8 JDIMM1.122
DDR_A_MA8: length 59.9
  IN1 w0.076: 106.34,39.74 106.34,39.76 108.66,42.07 v1(109.24,42.07)
  IN1 w0.142: v1(79.97,17.27) 79.73,17.27 79.51,17.49 79.51,19.93 81.11,21.54 81.11,22.27 88.03,29.19 91.17,29.19 91.33,29.36 91.33,30.16 91.5,30.33 91.73,30.33 91.9,30.16 91.9,29.36 92.07,29.19 92.3,29.19 92.47,29.36 92.47,30.16 92.64,30.33 97.28,30.33 106.34,39.38 106.34,39.74
  BOTTOM w0.076: UC1.AY52 111.24,52.22 111.24,51.96 111.28,51.86 111.28,51.86 111.31,51.77 111.31,51.57 111.27,51.48 111.27,51.23 111.27,51.21 111.31,51.12 111.31,50.87 111.11,50.67 111.11,49.5 110,48.4
  BOTTOM w0.102: 110,48.4 109.7,48.1 109.7,43.97
  BOTTOM w0.168: v1(109.24,42.07) 109.7,42.53 109.7,43.97 ; v1(79.97,17.27) 80.18,17.06 80.57,17.06 80.71,17.2 80.71,18.64 81.18,19.1 JDIMM1.125
DDR_A_MA9: length 59.3
  IN1 w0.076: 107,39.74 107,39.91 107,39.91 107,40 108.08,41.07 v1(108.3,41.07)
  IN1 w0.142: v1(79.97,18.8) 79.97,19.67 81.73,21.43 81.73,21.64 81.54,21.84 81.54,22.09 88.21,28.77 96.54,28.77 96.71,28.93 96.71,29.17 96.54,29.34 93.06,29.34 92.89,29.5 92.89,29.74 93.06,29.9 97.67,29.9 107,39.23 107,39.74
  BOTTOM w0.076: UC1.BB54 110.11,50.92 110.11,50.16 108.06,48.1 108.06,45.07 108.15,44.97
  BOTTOM w0.168: v1(79.97,18.8) 80.18,19 JDIMM1.121 ; 108.15,44.97 108.15,41.22 v1(108.3,41.07)
DDR_A_MA10: length 61.4
  IN1 w0.076: 113.38,40.12 113.98,40.71 113.98,48.22 113.99,48.23 113.99,50.09 113.66,50.42 113.66,50.93 112.01,52.58 112.01,54.31 v1(111.88,54.44)
  IN1 w0.142: v1(88.07,15.26) 88.29,15.03 88.6,15.03 88.83,15.26 88.83,15.54 87.76,16.61 87.76,18.52 89.56,20.32 89.9,20.32 90.07,20.15 90.31,20.15 92.88,22.72 99.61,22.72 113.25,36.36 113.25,37.35 113.25,38.51 113.25,38.51 113.25,39.98 113.38,40.12
  BOTTOM w0.076: UC1.AT50 v1(111.88,54.44)
  BOTTOM w0.168: v1(88.07,15.26) 87.69,14.88 87.69,13.2 88.43,12.46 JDIMM1.146
DDR_A_MA11: length 60.1
  IN1 w0.076: v1(109.24,43.31) 108.87,42.93 108.87,42.57 107.07,40.77 106.83,40.77 105.92,39.86 105.92,39.74
  IN1 w0.142: 105.92,39.74 105.92,39.56 97.1,30.75 91.11,30.75 90.91,30.54 90.91,29.82 90.71,29.61 87.76,29.61 80.13,21.99 80.13,21.17 79.08,20.12 79.08,17.15 79.47,16.77 79.47,16.43 79.57,16.32 79.57,14.76 v1(80.1,14.23)
  BOTTOM w0.076: UC1.BA54 110.01,51.46 110.28,51.19 110.28,50.07 108.22,48.02 108.22,45.52 108.58,45.16 108.58,43.97
  BOTTOM w0.168: 108.58,43.97 108.71,43.84 v1(109.24,43.31) ; v1(80.1,14.23) 79.34,13.46 79.34,13.19 79.93,12.6 JDIMM1.120
DDR_A_MA12: length 59.9
  IN1 w0.076: 105.49,39.74 107.13,41.38 107.35,41.38 108.64,42.67 108.64,43.6 108.99,43.96 v1(109.24,43.96)
  IN1 w0.142: 105.49,39.74 96.93,31.17 90.66,31.17 90.49,31 90.49,30.2 90.32,30.03 90.09,30.03 89.92,30.2 89.92,31 89.75,31.17 89.51,31.17 89.35,31 89.35,30.2 89.18,30.03 88.94,30.03 88.78,30.2 88.78,30.75 88.62,30.91 88.39,30.91 88.23,30.75 88.23,30.19 88.08,30.03 87.52,30.03 79.71,22.22 79.71,21.34 78.58,20.21 v1(78.58,18.29)
  BOTTOM w0.076: v1(109.24,43.96) 108.83,44.37 108.83,45.22 108.41,45.64 108.41,47.92 110.44,49.95 110.44,51.68 110.22,51.9 110.22,52.44 109.91,52.75 UC1.AW54
  BOTTOM w0.168: v1(78.58,18.29) 79.2,18.91 79.33,18.91 79.68,19.26 JDIMM1.119
DDR_A_MA13: length 62.2
  IN1 w0.076: 115.56,46.76 115.56,47.11 115.37,47.29 115.37,50.92 113.71,52.59 v1(113.71,53.81)
  IN1 w0.142: v1(90.82,16.49) 90.35,16.95 90.35,17.37 91.35,18.37 91.35,18.79 93.49,20.92 100.24,20.92 103.65,24.33 103.85,24.33 104.01,24.16 104.22,24.16 104.42,24.37 104.42,24.57 104.26,24.74 104.26,24.94 104.47,25.14 104.67,25.14 104.83,24.98 105.04,24.98 105.24,25.19 105.24,25.39 105.08,25.55 105.08,25.76 105.29,25.96 105.49,25.96 105.65,25.8 105.86,25.8 106.06,26.01 106.06,26.21 105.9,26.37 105.9,26.58 106.11,26.78 106.31,26.78 106.47,26.62 106.68,26.62 106.88,26.83 106.88,27.03 106.72,27.19 106.72,27.4 106.92,27.6 107.13,27.6 107.29,27.44 107.5,27.44 107.7,27.65 107.7,27.85 107.54,28.01 107.54,28.22 107.74,28.42 107.95,28.42 108.11,28.26 108.32,28.26 115.01,34.95 115.01,39.94 115.56,40.49 115.56,46.76
  BOTTOM w0.076: UC1.AU46 v1(113.71,53.81)
  BOTTOM w0.168: JDIMM1.158 91.43,15.35 91.4,15.37 91.4,15.9 v1(90.82,16.49)
DDR_A_MA14: length 60.5
  IN1 w0.076: v1(113.71,55.08) 113.28,54.65 113.28,53.18 113.44,53.03 113.44,52.45 115.16,50.72 115.16,47.9 114.73,47.48 114.73,42.13 114.86,42.01
  IN1 w0.142: 114.86,42.01 115.12,41.75 115.12,40.56 114.59,40.03 114.59,35.13 114.44,34.99 114.21,34.99 114.05,35.14 113.82,35.14 113.65,34.98 113.65,34.74 113.81,34.58 113.81,34.35 113.64,34.18 113.4,34.18 113.25,34.34 113.01,34.34 112.85,34.17 112.85,33.94 113,33.78 113,33.54 108.48,29.02 107.74,29.02 100.18,21.46 93.41,21.46 90.73,18.78 90.73,18.36 90.19,17.82 90.02,17.82 89.51,18.33 v1(89.51,18.33)
  BOTTOM w0.076: UC1.AT46 v1(113.71,55.08)
  BOTTOM w0.168: JDIMM1.151 89.68,19.27 90.83,18.11 90.83,17.82 90.57,17.57 90.28,17.57 v1(89.51,18.33)
DDR_A_MA15: length 60.7
  IN1 w0.076: v1(113.71,54.44) 114.08,54.07 114.08,52.57 115.57,51.08 115.57,47.47 115.8,47.25 115.8,42.93 115.88,42.85 115.88,42.84
  IN1 w0.142: 115.88,42.84 115.88,40.3 115.43,39.86 115.43,34.77 103.94,23.28 103.7,23.28 103.57,23.42 103.33,23.42 103.17,23.25 103.17,23.01 103.3,22.88 103.3,22.64 103.13,22.48 102.9,22.48 102.77,22.61 102.53,22.61 102.36,22.44 102.36,22.21 102.5,22.08 102.5,21.84 101.15,20.49 93.65,20.49 91.78,18.62 91.78,18.11 91.38,17.71 91.38,17.32 91.75,16.95 91.75,16.63 91.38,16.26 91.38,15.16 91.17,14.96 v1(90.83,14.96)
  BOTTOM w0.076: v1(113.71,54.44) UC1.AU48
  BOTTOM w0.168: JDIMM1.156 90.93,14.86 v1(90.83,14.96)
DDR_A_MA16: length 61.2
  IN1 w0.076: 114.48,41.96 114.48,47.55 114.96,48.03 114.96,50.55 114,51.51 113.62,51.51 112.36,52.77 112.36,54.02 112.79,54.45 v1(112.79,54.52)
  IN1 w0.142: v1(89.54,13.87) 89.46,13.95 89.46,15.79 88.83,16.43 88.83,17.06 89.07,17.31 89.07,18.62 89.4,18.95 90.31,18.95 93.23,21.88 100,21.88 107.56,29.44 108.3,29.44 112.28,33.42 112.28,34.2 114.1,36.02 114.1,39.97 114.48,40.36 114.48,41.96
  BOTTOM w0.076: v1(112.79,54.52) 112.42,54.14 UC1.AU50
  BOTTOM w0.168: v1(89.54,13.87) 90.1,13.31 90.1,12.85 89.93,12.67 JDIMM1.152
DDR_A_ODT0: length 64.8
  IN1 w0.076: 116.77,52.88 116.77,53.01 116.64,53.13 116.26,53.13 115.91,53.49 115.91,54.18 116.01,54.28 116.01,54.66 115.7,54.96 115.11,54.96 v1(114.63,54.48)
  IN1 w0.142: 116.77,52.88 117.33,52.32 117.33,48.92 117.56,48.69 117.56,39.94 117.35,39.73 117.35,33.95 104.08,20.68 104.08,20.48 104.52,20.04 104.52,19.8 104.35,19.63 104.11,19.63 103.67,20.07 103.46,20.07 102.85,19.46 102.85,16.43 101.92,15.5 97.7,15.5 97.47,15.27 93.46,15.27 v1(92.88,15.85)
  BOTTOM w0.076: v1(114.63,54.48) 114.63,54.45 114.97,54.79 UC1.AT45
  BOTTOM w0.168: v1(92.88,15.85) 92.39,16.33 92.39,17.22 90.68,18.94 JDIMM1.155
DDR_A_ODT1: length 67.5
  IN1 w0.076: 116.29,43.35 116.29,47.39 115.96,47.72 115.96,51.53 114.86,52.62 114.86,53.13 115.12,53.39 115.12,54.17 115.51,54.57 v1(115.55,54.57)
  IN1 w0.142: 116.29,43.35 116.77,42.87 116.77,40.18 116.5,39.91 116.5,34.32 101.52,19.34 99.45,19.34 99.28,19.17 99.28,16.72 99.12,16.56 98.88,16.56 98.71,16.72 98.71,19.17 98.55,19.34 97.97,19.34 97.8,19.17 97.8,16.72 97.64,16.56 97.4,16.56 97.23,16.72 97.23,19.17 97.07,19.34 94.02,19.34 93.4,18.72 93.4,17.76 v1(93.97,17.19)
  BOTTOM w0.076: v1(115.55,54.57) 115.77,54.79 UC1.AT43
  BOTTOM w0.168: v1(93.97,17.19) 93.33,17.83 93.33,18.44 92.98,18.8 92.55,18.8 92.18,19.17 92.18,20 JDIMM1.161
DDR_A_PARITY: length 59.2
  IN1 w0.076: v1(110.97,54.44) 111.78,53.62 111.78,52.35 113.34,50.79 113.34,50.52 113.77,50.09 113.77,49.83
  IN1 w0.142: 113.77,49.83 113.77,41.1 112.68,40.01 112.68,36.39 99.43,23.14 91.81,23.14 90.67,22 90.67,21.32 90.21,20.86 89.5,20.86 87.16,18.52 v1(87.16,16.77)
  BOTTOM w0.076: UC1.AT52 v1(110.97,54.44)
  BOTTOM w0.168: JDIMM1.143 85.68,19.2 87.18,17.7 87.18,16.77 v1(87.16,16.77)
DDR_B_ACT#: length 92.6
  IN4 w0.076: v1(110.05,56.35) 110.42,55.98 110.42,53.65 109.67,52.9 109.67,52.48 109.32,52.13
  IN4 w0.142: 109.32,52.13 108.15,50.96 108.15,50.09 106.05,48 106.05,42.78 105.39,42.12 105.39,33.01 110.27,28.13 111.94,28.13 118.07,22 118.79,22 123.49,17.3 126.82,17.3 129.69,14.44 136.99,14.44 137.34,14.78 145.47,14.78 146.03,15.34 150.52,15.34 151.11,15.92 154.84,15.92 155.56,16.65 156.88,16.65 159.12,14.41 v1(159.12,14.05)
  BOTTOM w0.076: UC1.AN53 v1(110.05,56.35)
  BOTTOM w0.168: JDIMM2.114 160.42,12.74 v1(159.12,14.05)
DDR_B_ALERT#: length 76.5
  IN1 w0.076: v1(116.43,56.36) 116.94,55.85 116.94,53.14 117.9,52.18
  IN1 w0.142: v1(160.93,13.26) 160.92,13.25 159.06,13.25 158.04,14.27 156.9,14.27 155.5,15.67 155.5,17.95 154.84,18.62 154.84,28.18 151.09,31.94 140.9,31.94 134.22,38.62 134.22,41.52 133.91,41.83 133.66,41.83 133.09,42.4 133.09,42.97 130.48,45.57 130.48,47.42 128.83,49.07 128.83,49.83 127.33,51.33 118.75,51.33 117.9,52.18
  BOTTOM w0.168: v1(160.93,13.26) JDIMM2.116
  BOTTOM w0.254: UC1.AN43 116.06,56.74 v1(116.43,56.36)
DDR_B_BA0: length 91.7
  IN4 w0.142: v1(115.13,43.64) 115.12,43.63 115.12,38.22 121.21,32.13 129.6,32.13 133.19,28.54 134.8,28.54 135.89,27.46 154.2,27.46 154.75,26.91 165.75,26.91 168.11,24.54 168.62,24.54 170.16,23 170.16,19.63 169.79,19.26 169.79,16.57 169.6,16.38 169.11,16.38 168.83,16.1 168.83,15.7 168.97,15.56 169.2,15.56 169.35,15.42 169.35,15.13 169.2,14.99 168.97,14.99 168.83,14.85 168.83,14.62 169.29,14.16 169.58,14.16 169.86,14.45 v1(169.86,14.61)
  BOTTOM w0.076: 115.74,44.51 115.74,47.31 115.58,47.47 115.58,49.5 115.75,49.68 115.75,50.92 UC1.BB44
  BOTTOM w0.168: v1(115.13,43.64) 115.15,43.62 115.88,43.62 116.13,43.87 116.13,44.12 115.74,44.51 ; v1(169.86,14.61) 170.42,15.16 171.1,15.16 171.43,14.83 JDIMM2.150
DDR_B_BA1: length 91.4
  IN4 w0.076: v1(115.13,44.93) 115.13,44.81 114.76,44.44 114.76,40.31 114.7,40.24 114.7,40.13
  IN4 w0.142: 114.7,40.13 114.7,38.05 121.3,31.44 129.69,31.44 133.02,28.12 134.63,28.12 135.71,27.03 154.03,27.03 154.58,26.48 165.57,26.48 165.96,26.09 165.96,25.89 165.63,25.56 165.63,25.36 165.83,25.16 166.03,25.16 166.37,25.49 166.57,25.49 166.77,25.29 166.77,25.09 166.43,24.75 166.43,24.55 166.64,24.35 166.84,24.35 167.17,24.68 167.37,24.68 167.57,24.48 167.57,24.28 167.24,23.95 167.24,23.75 167.44,23.55 167.64,23.55 167.98,23.88 168.18,23.88 168.46,23.6 168.46,22.91 168.59,22.77 168.59,20.03 168.76,19.86 169,19.86 169.16,20.03 169.16,22 169.3,22.14 169.59,22.14 169.73,22 169.73,19.8 169.35,19.41 169.35,17.82 v1(169.36,17.81)
  BOTTOM w0.076: UC1.BA44 115.59,51.41 115.59,49.75 115.52,49.68 115.52,49.68 115.37,49.53 115.37,47.29 115.54,47.13 115.54,45.34 v1(115.13,44.93)
  BOTTOM w0.168: JDIMM2.145 170.17,20 170.17,19.34 169.36,18.52 v1(169.36,17.81)
DDR_B_BG0: length 93.4
  IN4 w0.076: 111.31,53.31 111.35,53.35 111.35,55.33 v1(110.97,55.71)
  IN4 w0.142: 111.31,53.31 111.31,52.88 109.88,51.45 109.88,50.1 109.01,49.24 107.49,47.71 107.49,42.69 106.23,41.44 106.23,33.36 110.58,29.02 112.24,29.02 117.82,23.44 121.34,23.44 121.51,23.27 121.51,22.49 121.68,22.32 121.91,22.32 122.08,22.49 122.08,23.27 122.24,23.44 125.68,23.44 127.29,21.83 127.29,19.94 128.76,18.47 134.71,18.47 135.96,17.22 136.99,17.22 138.24,18.47 147.67,18.47 149.15,16.99 151.01,16.99 151.59,17.57 156.09,17.57 156.09,17.57 157.28,17.57 157.81,17.04 158.7,17.04 v1(159.06,16.68)
  BOTTOM w0.076: UC1.AP52 111.34,56.09 v1(110.97,55.71)
  BOTTOM w0.168: JDIMM2.115 160.68,18.3 v1(159.06,16.68)
DDR_B_BG1: length 93.3
  IN4 w0.076: v1(111.88,56.35) 111.51,55.98 111.51,52.74 110.19,51.42 110.19,49.82
  IN4 w0.142: 110.19,49.82 109.57,49.2 108.81,48.43 108.16,47.78 107.91,47.54 107.91,42.52 106.66,41.26 106.66,33.54 110.75,29.44 112.41,29.44 118,23.86 125.86,23.86 128.74,20.97 128.74,20.74 128.04,20.03 128.04,19.79 128.2,19.63 128.44,19.63 129.15,20.34 129.38,20.34 129.55,20.17 129.55,19.93 128.91,19.29 128.91,19.06 129.07,18.89 129.31,18.89 129.95,19.53 130.19,19.53 130.83,18.89 135.67,18.89 135.84,18.72 135.84,17.94 135.98,17.8 136.22,17.8 136.41,17.99 136.41,18.72 136.57,18.89 148.85,18.89 149.1,18.64 150.25,18.64 150.89,18 158.68,18 v1(158.92,17.76)
  BOTTOM w0.076: UC1.AN52 111.82,56.35 v1(111.88,56.35)
  BOTTOM w0.168: JDIMM2.113 160.17,19.02 v1(158.92,17.76)
DDR_B_CKE0: length 92.2
  IN4 w0.142: v1(156.77,16) 154.42,14.59 152.72,12.89 132.31,12.89 129.35,13.77 126.48,16.65 123.31,16.65 122.1,17.05 115.24,23.9 111.67,27.48 110.01,27.48 104.74,32.74 104.74,42.46 105.4,43.12 105.4,47.92 107.74,50.26 107.74,50.99 109.05,52.29 109.55,53.75 109.55,55.88 v1(109.1,56.34)
  BOTTOM w0.076: UC1.AN56 108.69,56.74 109.09,56.34 v1(109.1,56.34)
  BOTTOM w0.168: v1(156.77,16) 156.77,16.81 159.17,19.21 JDIMM2.109
DDR_B_CKE1: length 92.4
  IN4 w0.142: v1(156.6,13.85) 156.87,13.58 156.87,12.76 156.41,12.3 130.1,12.3 126.18,16.21 121.87,16.21 114.93,23.16 113.73,23.16 104.32,32.57 104.32,42.64 104.98,43.3 104.98,47.93 107.25,50.21 107.25,50.88 108.67,52.3 108.67,55.19 v1(109.14,55.65)
  BOTTOM w0.076: v1(109.14,55.65) 109.59,56.03 UC1.AP55
  BOTTOM w0.168: v1(156.6,13.85) 156.77,14.01 158.08,14.01 159.42,12.66 JDIMM2.110
DDR_B_CKE2: length 1.1
  TOP w0.168: T5.1 109.64,56.69 v1(109.98,57.03)
  BOTTOM w0.076: v1(109.98,57.03) 109.69,56.74 UC1.AN55
DDR_B_CKE3: length 1.3
  TOP w0.168: v1(110.05,55.71) 109.59,55.25 T6.1
  BOTTOM w0.076: UC1.AP53 v1(110.05,55.71)
DDR_B_CLK0: length 95.4
  IN4 w0.076: 114.57,52.78 114.57,52.8 114.56,52.8 114.56,52.9 115.16,53.5 115.16,55.88 115.3,56.02 115.3,56.11 v1(115.54,56.35)
  IN4 w0.089: 114.57,52.78 114.57,52.51 114.68,52.4 115.15,52.4 115.41,52.14 115.41,51.77 115.15,51.51 114.21,51.51 114.07,51.36 114.07,51.15 114.21,51 114.84,51 115.07,50.77 115.07,49.96 114.84,49.73 114.84,49.42 115.07,49.19 115.07,48.51 114.76,48.2 114.25,48.2 114.07,48.02 114.07,47.48 114.2,47.34 114.2,46.69 114.07,46.55 114.07,41.12 113.21,40.26 113.21,37.45 120.68,29.98 129.09,29.98 132.45,26.62 133.1,26.62 133.38,26.33 133.38,25.49 133.69,25.18 136.7,25.18 137.06,25.55 152.81,25.55 153.34,25.02 161.96,25.02 163.47,23.51 164.68,23.51 166.74,21.45 166.74,19.69 167.11,19.32 167.11,18.56 167.29,18.39 167.46,18.39 167.75,18.11 167.75,17.67 167.97,17.45 167.97,17.09 167.73,16.84 167.53,16.84 v1(167.13,16.44)
  BOTTOM w0.076: v1(115.54,56.35) 115.34,56.35 UC1.AP45
  BOTTOM w0.094: v1(167.13,16.44) 167.03,16.54 166.51,16.54 166.04,17.01 166.04,17.47 166.49,17.93 166.49,18.28 166.17,18.6 JDIMM2.137
DDR_B_CLK1: length 94.1
  IN4 w0.076: v1(113.72,55.7) 113.72,55.91 113.79,55.98 113.86,55.98 113.93,56.04 114.08,56.04 114.18,55.94 114.18,55.57 114.08,55.47 114.08,53.6 113.62,53.14 113.62,52.88 113.61,52.88 113.61,52.86
  IN4 w0.089: v1(166.61,14.71) 166.64,14.71 166.88,14.95 166.88,15.67 166.75,15.79 166.15,15.79 165.92,16.02 165.92,16.38 166.42,16.88 166.42,17.12 166.19,17.35 166.19,17.67 166.35,17.82 166.35,18.11 166.19,18.26 166.19,19.02 165.86,19.35 165.86,21.06 164.27,22.65 163.11,22.65 161.62,24.15 152.56,24.15 152.03,24.68 137.47,24.68 136.99,24.2 133.46,24.2 128.55,29.12 120.31,29.12 112.26,37.16 112.26,40.53 113.21,41.47 113.21,48.96 113.4,49.16 113.8,49.16 113.97,49.33 113.97,49.58 113.8,49.75 113.4,49.75 113.01,50.15 113.01,51.73 113.61,52.34 113.61,52.86
  BOTTOM w0.076: v1(113.72,55.7) 114.1,56.09 UC1.AP46
  BOTTOM w0.094: JDIMM2.138 166.43,12.59 166.58,12.75 166.58,13.06 167.13,13.61 167.13,13.84 166.85,14.12 166.85,14.47 v1(166.61,14.71)
DDR_B_CLK#0: length 95.4
  IN4 w0.076: 114.39,52.78 114.39,52.8 114.39,52.8 114.39,52.97 115,53.57 115,55.95 115.14,56.09 115.14,56.29 115.08,56.35 v1(114.62,56.35)
  IN4 w0.089: v1(167.1,17.02) 167.65,17.02 167.79,17.17 167.79,17.37 167.57,17.6 167.57,18.03 167.39,18.21 167.21,18.21 166.93,18.49 166.93,19.24 166.56,19.61 166.56,21.37 164.61,23.33 163.39,23.33 161.89,24.84 153.27,24.84 152.73,25.37 137.14,25.37 136.77,25 133.62,25 133.2,25.42 133.2,26.26 133.03,26.44 132.37,26.44 129.01,29.8 120.61,29.8 113.03,37.37 113.03,40.34 113.89,41.19 113.89,46.63 114.02,46.77 114.02,47.27 113.89,47.4 113.89,48.1 114.17,48.38 114.68,48.38 114.89,48.59 114.89,49.12 114.66,49.35 114.66,49.81 114.89,50.03 114.89,50.7 114.76,50.82 114.14,50.82 113.89,51.08 113.89,51.43 114.14,51.69 115.08,51.69 115.23,51.84 115.23,52.06 115.08,52.22 114.61,52.22 114.39,52.44 114.39,52.78
  BOTTOM w0.076: v1(114.62,56.35) 114.87,56.35 115.08,56.56 UC1.AN45
  BOTTOM w0.094: JDIMM2.139 166.68,19.24 166.36,18.93 166.36,18.68 166.68,18.36 166.68,17.85 166.22,17.4 166.22,17.09 166.59,16.72 166.82,16.72 167.1,17 v1(167.1,17.02)
DDR_B_CLK#1: length 94.1
  IN4 w0.076: v1(113.71,56.35) 113.85,56.21 114.15,56.21 114.35,56.01 114.35,55.5 114.25,55.4 114.25,53.53 113.78,53.07 113.78,52.88 113.79,52.88 113.79,52.78
  IN4 w0.089: v1(167.27,14.71) 167.06,14.92 167.06,15.74 166.83,15.97 166.22,15.97 166.1,16.1 166.1,16.3 166.6,16.81 166.6,17.19 166.37,17.42 166.37,17.59 166.53,17.75 166.53,18.18 166.38,18.33 166.38,19.1 166.04,19.43 166.04,21.13 164.34,22.83 163.19,22.83 161.69,24.33 152.64,24.33 152.11,24.87 137.4,24.87 136.91,24.38 133.54,24.38 128.62,29.3 120.38,29.3 112.45,37.24 112.45,40.45 113.39,41.4 113.39,48.89 113.48,48.98 113.87,48.98 114.15,49.26 114.15,49.65 113.87,49.93 113.48,49.93 113.19,50.22 113.19,51.66 113.79,52.26 113.79,52.78
  BOTTOM w0.076: UC1.AN46 v1(113.71,56.35)
  BOTTOM w0.094: v1(167.27,14.71) 167.04,14.47 167.04,14.19 167.31,13.92 167.31,13.53 166.76,12.98 166.76,12.76 166.92,12.59 JDIMM2.140
DDR_B_CS#0: length 93.5
  IN4 w0.142: v1(171.71,18.46) 172.07,18.83 172.07,23.79 169.02,26.84 168.52,26.84 166.54,28.82 155.55,28.82 155,29.37 136.68,29.37 132,34.05 131.77,34.05 131.6,33.88 131.6,33.65 134.39,30.86 134.39,30.62 134.22,30.46 133.99,30.46 130.39,34.05 122,34.05 117.07,38.98 117.07,41.78 116.77,42.08 116.77,43.1 116.25,43.61 116.25,47.45 v1(116.66,47.85)
  BOTTOM w0.076: UC1.BB42 117.22,50.99 117.22,50.05 117.02,49.86 117.02,49.7
  BOTTOM w0.168: v1(116.66,47.85) 116.77,47.85 117,48.08 117,49.68 117.02,49.7 ; JDIMM2.149 171.18,19.15 170.04,18.01 170.04,17.72 170.36,17.4 170.65,17.4 v1(171.71,18.46)
DDR_B_CS#1: length 96
  IN4 w0.142: v1(172.88,18.46) 172.49,18.84 172.49,19.18 172.64,19.32 172.99,19.32 173.16,19.49 173.16,19.72 172.99,19.89 172.64,19.89 172.49,20.03 172.49,20.32 172.64,20.46 172.99,20.46 173.16,20.62 173.16,20.86 172.99,21.03 172.64,21.03 172.49,21.17 172.49,23.97 169.11,27.35 168.61,27.35 166.72,29.24 155.72,29.24 155.17,29.79 136.86,29.79 132.18,34.47 122.18,34.47 117.5,39.15 117.5,41.95 117.15,42.29 117.15,43.35 v1(116.77,43.73)
  BOTTOM w0.076: 117.48,51.48 117.48,52.02 UC1.AY42
  BOTTOM w0.168: JDIMM2.157 173.18,19.2 173.79,18.59 173.79,18.18 173.56,17.95 173.3,17.95 172.88,18.38 v1(172.88,18.46) ; 117.48,51.48 117.48,51.23 117.54,51.17 117.54,50.7 117.48,50.63 117.48,50.01 117.3,49.83 117.3,49.3 117.66,48.94 117.66,48.74 117.45,48.54 117.45,48.22 117.66,48.02 117.66,47.8 117.15,47.29 117.15,44.9 118.65,43.4 118.65,42.54 118.32,42.21 114.74,42.21 114.54,42.41 114.54,42.77 114.74,42.97 116.64,42.97 116.77,43.1 v1(116.77,43.73)
DDR_B_D0: length 55
  IN1 w0.084: 118.89,42.5 118.89,43.46 119.24,43.81 v1(119.29,43.81)
  IN1 w0.089: 118.89,42.5 118.89,29.96 118.98,29.87 119.52,29.87 119.61,29.78 119.61,29.6 119.52,29.51 118.98,29.51 118.89,29.42 118.89,29.25 118.98,29.16 119.52,29.16 119.61,29.07 119.61,28.89 119.52,28.8 118.98,28.8 118.89,28.71 118.89,28.54 118.98,28.45 119.52,28.45 119.61,28.36 119.61,25.95 119.97,25.6 124.87,25.6 131.86,18.61 132.82,18.61 133.31,18.12 133.31,13.78 133.55,13.54 v1(134.41,13.54)
  BOTTOM w0.076: 117.98,47.57 117.98,49.11 118.1,49.22 118.1,49.88 118.07,49.91 118.07,50.63 118.02,50.68 118.02,51.16 118.08,51.3 118.08,51.6 118.19,51.85 118.45,52.12 UC1.AY39
  BOTTOM w0.102: v1(134.41,13.54) 133.93,13.06 JDIMM2.8 ; 117.98,47.57 117.77,47.35 117.77,45.32 v1(119.29,43.81)
DDR_B_D1: length 52.7
  IN1 w0.084: 117.97,39.74 117.97,48.46 v1(119.21,49.7)
  IN1 w0.089: v1(131.08,17.66) 131.08,18.03 124.43,24.68 117.28,24.68 117.07,24.89 117.07,26.26 117.28,26.47 117.88,26.47 117.97,26.55 117.97,26.73 117.88,26.82 116.92,26.82 116.82,26.93 116.82,27.07 116.92,27.18 117.88,27.18 117.97,27.27 117.97,39.74
  BOTTOM w0.076: v1(119.21,49.7) 119.55,50.03 119.55,50.59 119.35,50.79 119.35,51.16 119.39,51.28 119.39,51.39 119.33,51.61 119.33,51.76 119.39,51.91 119.39,52.1 119.37,52.14 119.37,52.71 119.11,52.97 UC1.AW39
  BOTTOM w0.102: JDIMM2.3 132.68,19.23 131.1,17.66 v1(131.08,17.66)
DDR_B_D2: length 55
  IN1 w0.084: 120.02,42.14 120.02,48.22 v1(119.21,49.02)
  IN1 w0.089: v1(134.51,15.14) 135.19,15.82 135.19,18.26 133.66,19.79 132.51,19.79 125.53,26.77 122.55,26.77 122.36,26.97 122.36,27.96 122.27,28.05 120.88,28.05 120.79,28.14 120.79,28.32 120.88,28.41 122.27,28.41 122.36,28.5 122.36,28.68 122.27,28.76 120.88,28.76 120.79,28.85 120.79,30.57 120.53,30.83 120.53,31.11 120.79,31.37 120.79,31.53 120.09,32.23 120.09,42.08 120.02,42.14
  BOTTOM w0.076: UC1.AY37 119.58,52.22 119.58,51.97 119.5,51.75 119.5,51.62 119.57,51.39 119.57,51.25 119.51,51.13 119.51,50.86 119.71,50.66 119.71,49.52 v1(119.21,49.02)
  BOTTOM w0.102: JDIMM2.16 135.93,14.23 135.01,15.14 v1(134.51,15.14)
DDR_B_D3: length 55.6
  IN1 w0.084: v1(120.62,45.04) 120.24,44.65 120.24,42.29 120.39,42.14 120.39,39.77
  IN1 w0.089: v1(135.95,15.1) 135.49,15.55 135.49,18.41 133.81,20.09 132.65,20.09 125.67,27.08 122.88,27.08 122.66,27.3 122.66,28.98 122.57,29.07 121.18,29.07 121.09,29.16 121.09,29.34 121.18,29.42 122.57,29.42 122.66,29.51 122.66,29.69 122.57,29.78 121.18,29.78 121.09,29.87 121.09,30.05 121.18,30.14 121.46,30.14 121.57,30.24 121.57,30.39 121.46,30.49 121.18,30.49 121.09,30.58 121.09,31.67 120.39,32.37 120.39,39.77
  BOTTOM w0.076: v1(120.62,45.04) 120.21,45.45 120.21,45.82 120.03,46 120.03,48.96 120.21,49.15 120.21,50.66 120.21,50.66 120.21,51.68 119.99,51.9 119.99,52.44 119.68,52.75 UC1.AW37
  BOTTOM w0.102: v1(135.95,15.1) 136.21,14.83 136.21,14.76 136.93,14.05 JDIMM2.20
DDR_B_D4: length 53.3
  IN1 w0.084: 118.28,39.74 118.28,44.39 118.3,44.41 118.3,44.95 119.07,45.72 v1(119.3,45.72)
  IN1 w0.089: v1(132.61,17.55) 132.16,18.01 131.56,18.01 124.58,24.99 117.48,24.99 117.38,25.09 117.38,25.24 117.48,25.35 118.91,25.35 119,25.44 119,25.61 118.91,25.7 117.48,25.7 117.38,25.81 117.38,25.95 117.48,26.06 118.91,26.06 119,26.15 119,26.33 118.91,26.41 118.37,26.41 118.28,26.5 118.28,39.74
  BOTTOM w0.076: 118.45,46.9 118.45,47.05 118.41,47.09 118.41,49.05 118.43,49.07 118.43,50.02 118.41,50.04 118.41,50.08 118.4,50.09 118.4,50.69 118.45,50.78 UC1.BB39
  BOTTOM w0.102: 118.45,46.9 118.45,46.57 v1(119.3,45.72) ; JDIMM2.7 133.68,18.62 v1(132.61,17.55)
DDR_B_D5: length 53.8
  IN1 w0.089: v1(119.29,45.12) 118.58,44.41 118.58,28.23 118.67,28.14 119.22,28.14 119.31,28.05 119.31,27.88 119.22,27.79 118.67,27.79 118.58,27.7 118.58,27.52 118.67,27.43 119.22,27.43 119.31,27.34 119.31,27.16 119.22,27.08 118.67,27.08 118.58,26.99 118.58,26.81 118.67,26.72 119.22,26.72 119.31,26.63 119.31,25.5 119.51,25.29 124.73,25.29 131.72,18.31 132.55,18.31 133.01,17.86 133.01,13.75 132.85,13.59 v1(132.5,13.59)
  BOTTOM w0.076: UC1.BA39 118.31,51.53 118.31,51.38 118.31,51.38 118.31,51.38 118.19,51.13 118.19,50.75 118.24,50.7 118.24,49.98 118.26,49.95 118.26,49.14 118.24,49.11 118.24,47.45 118.12,47.33 118.12,46.94
  BOTTOM w0.102: JDIMM2.4 132.93,13.17 v1(132.5,13.59) ; 118.12,46.94 118.12,46.21 119.22,45.12 v1(119.29,45.12)
DDR_B_D6: length 54.7
  IN1 w0.076: v1(137.15,18.32) 137.15,17.51
  IN1 w0.084: 121.08,42.23 121.08,43.34 v1(120.61,43.81)
  IN1 w0.089: 137.15,17.51 137.15,17.28 137.06,17.19 136.83,17.19 136.71,17.06 136.71,16.48 136.4,16.18 136.25,16.18 136.1,16.32 136.1,17.73 136.4,18.03 136.4,18.36 134.06,20.7 132.96,20.7 125.59,28.08 125.44,28.08 125.05,27.69 124.9,27.69 124.8,27.79 124.8,27.94 125.19,28.33 125.19,28.48 125.08,28.58 124.94,28.58 124.21,27.85 124.06,27.85 123.96,27.96 123.96,28.1 124.68,28.83 124.68,28.98 124.58,29.08 124.43,29.08 124.15,28.8 124.01,28.8 123.9,28.91 123.9,29.06 124.18,29.34 124.18,29.48 124.08,29.59 123.93,29.59 123.52,29.18 123.37,29.18 123.27,29.28 123.27,29.43 123.68,29.84 123.68,29.99 123.13,30.54 122.98,30.54 122.89,30.45 122.75,30.45 122.64,30.55 122.64,30.7 122.73,30.79 122.73,30.93 122.24,31.42 122.1,31.42 121.95,31.28 121.81,31.28 121.7,31.38 121.7,31.53 121.84,31.67 121.84,31.82 121,32.66 121,42.15 121.08,42.23
  BOTTOM w0.076: v1(120.61,43.81) 120.6,43.81 120.04,44.37 120.04,45.72 119.86,45.9 119.86,49.03 120.04,49.22 120.04,50.73 120.05,50.73 120.05,51.19 119.78,51.46 UC1.BA37
  BOTTOM w0.102: JDIMM2.21 137.17,18.34 v1(137.15,18.32)
DDR_B_D7: length 54.1
  IN1 w0.084: v1(120.62,42.6) 120.69,42.52 120.69,39.74
  IN1 w0.089: v1(137.15,16.69) 137.15,16.5 136.75,16.1 136.75,15.8 136.5,15.55 136.15,15.55 135.8,15.9 135.8,18.53 133.93,20.4 132.79,20.4 125.81,27.38 123.07,27.38 122.97,27.49 122.97,27.64 123.07,27.74 123.55,27.74 123.65,27.85 123.65,27.99 123.55,28.1 123.05,28.1 122.97,28.19 122.97,28.36 123.05,28.45 123.57,28.45 123.68,28.56 123.68,28.7 123.57,28.81 123.05,28.81 122.97,28.9 122.97,29.92 122.8,30.09 122,30.09 121.87,30.21 121.87,30.43 121.98,30.53 122.21,30.53 122.34,30.65 122.34,30.83 122.21,30.96 121.54,30.96 121.4,31.1 121.4,31.8 120.69,32.51 120.69,39.74
  BOTTOM w0.076: UC1.BB37 119.78,50.83 119.88,50.73 119.88,49.28 119.7,49.1 119.7,46.01 119.7,45.54 119.73,45.5 119.73,44.48
  BOTTOM w0.102: 119.73,44.48 119.73,43.41 120.55,42.6 v1(120.62,42.6) ; v1(137.15,16.69) 136.84,16.69 136.17,17.36 JDIMM2.17
DDR_B_D8: length 55.4
  IN1 w0.076: 121.9,39.74 121.9,39.87 121.55,40.22 121.55,46.05 v1(120.66,46.94)
  IN1 w0.084: 121.9,39.74 121.9,39.74
  IN1 w0.089: v1(138.77,13.54) 138.3,13.54 137.99,13.85 137.99,15.02 138.09,15.12 138.41,15.12 138.51,15.23 138.51,15.37 138.41,15.48 138.09,15.48 137.99,15.58 137.99,18.57 137.54,19.02 137.02,19.02 134.43,21.6 133.34,21.6 126.18,28.76 126.18,28.9 126.47,29.19 126.47,29.34 126.36,29.44 126.22,29.44 125.93,29.16 125.78,29.16 125.68,29.26 125.68,29.41 125.96,29.69 125.96,29.84 125.86,29.94 125.71,29.94 125.43,29.66 125.28,29.66 125.18,29.76 125.18,29.91 125.56,30.29 125.56,30.42 125.44,30.55 125.31,30.55 124.93,30.16 124.78,30.16 124.67,30.27 124.67,30.41 125.06,30.8 125.06,30.92 124.93,31.05 124.81,31.05 124.42,30.66 124.28,30.66 124.17,30.77 124.17,30.92 124.56,31.3 124.56,31.43 121.9,34.08 121.9,39.74
  BOTTOM w0.076: v1(120.66,46.94) 120.92,47.2 121.18,47.46 121.18,49.06 120.9,49.35 120.9,50.38 121.07,50.55 121.07,51.12 121.04,51.21 121.04,51.48 121.07,51.57 121.07,51.77 121.04,51.86 121.01,51.96 121.01,52.22 UC1.AY35
  BOTTOM w0.102: JDIMM2.28 138.95,11.83 138.95,13.36 v1(138.77,13.54)
DDR_B_D9: length 56
  IN1 w0.089: v1(137.58,13.36) 137.15,13.79 137.15,14.44 137.36,14.65 137.58,14.65 137.68,14.76 137.68,14.9 137.58,15.01 137.29,15.01 137.19,15.11 137.19,15.26 137.29,15.36 137.58,15.36 137.68,15.47 137.68,18.39 137.36,18.72 136.89,18.72 134.31,21.3 133.21,21.3 123.65,30.86 123.65,30.99 124.03,31.37 124.03,31.52 123.93,31.62 123.78,31.62 123.4,31.24 123.27,31.24 123.14,31.36 123.14,31.49 123.54,31.89 123.54,32.01 123.41,32.14 123.29,32.14 122.89,31.74 122.77,31.74 122.64,31.87 122.64,31.99 123.04,32.39 123.04,32.51 122.91,32.64 122.79,32.64 122.39,32.24 122.26,32.24 122.14,32.37 122.14,32.5 122.53,32.89 122.53,33.02 122.41,33.14 122.28,33.14 121.89,32.75 121.76,32.75 121.6,32.91 121.6,39.8 121.31,40.08 121.31,45.01 v1(120.64,45.69)
  BOTTOM w0.076: UC1.AW35 120.91,52.78 120.59,52.46 120.59,51.91 120.38,51.7 120.38,50.59 120.38,49.08 120.27,48.97 120.27,46.05 v1(120.64,45.69)
  BOTTOM w0.102: JDIMM2.24 137.93,13.02 v1(137.58,13.36)
DDR_B_D10: length 55.4
  IN1 w0.089: v1(142.42,14.21) 142.42,14.28 140.98,15.72 140.98,19.27 136.12,24.14 134.21,24.14 132.99,25.36 132.99,25.95 127.23,31.71 127.23,31.85 127.49,32.11 127.49,32.26 127.38,32.36 127.23,32.36 126.98,32.1 126.83,32.1 126.73,32.21 126.73,32.36 127.05,32.67 127.05,32.82 126.94,32.93 126.79,32.93 126.48,32.61 126.33,32.61 126.22,32.71 126.22,32.86 126.61,33.24 126.61,33.39 126.5,33.49 126.36,33.49 125.97,33.11 125.83,33.11 125.72,33.21 125.72,33.36 126.1,33.74 126.1,33.89 126,34 125.85,34 125.47,33.61 125.32,33.61 125.22,33.72 125.22,33.86 125.6,34.25 125.6,34.39 124.05,35.95 124.05,40.09 123.47,40.67 123.47,42.28 123.09,42.67 v1(123.09,42.67)
  BOTTOM w0.076: UC1.AY33 122.13,52.12 122.41,51.85 122.45,51.75 122.45,51.4 122.57,51.16 122.57,50.8 122.41,50.65 122.41,50.3 122.61,50.11 122.61,48.1 123.44,47.27 123.44,44.24 123.7,43.98 123.7,43.81
  BOTTOM w0.102: 123.7,43.81 123.7,43.28 v1(123.09,42.67) ; v1(142.42,14.21) 142.42,13.83 142.42,13.82 JDIMM2.42
DDR_B_D11: length 54.2
  IN1 w0.076: 123.73,39.74 123.73,40.08
  IN1 w0.084: v1(123.09,41.38) 123.24,41.22 123.24,40.57 123.73,40.08
  IN1 w0.089: v1(141.82,13.31) 141.16,13.97 141.16,14.64 140.5,15.3 140.5,19.32 135.99,23.83 133.63,23.83 132.68,24.78 132.68,25.82 124.78,33.72 124.78,33.87 125.06,34.15 125.06,34.3 124.96,34.4 124.81,34.4 124.53,34.12 124.38,34.12 124.28,34.22 124.28,34.37 124.59,34.68 124.59,34.83 124.48,34.93 124.34,34.93 124.03,34.62 123.88,34.62 123.73,34.78 123.73,39.74
  BOTTOM w0.076: UC1.AW33 121.48,52.97 121.28,52.77 121.2,52.67 121.2,51.9 121.24,51.8 121.24,51.53 121.2,51.45 121.2,51.25 121.24,51.16 121.24,50.49 121.06,50.31 121.06,49.45 121.39,49.12
  BOTTOM w0.102: 121.39,49.12 121.39,43.08 v1(123.09,41.38) ; v1(141.82,13.31) 141.42,12.92 JDIMM2.38
DDR_B_D12: length 53.7
  IN1 w0.076: 122.21,39.74 122.21,39.95 121.77,40.38 121.77,46.41 120.66,47.52 v1(120.66,47.52)
  IN1 w0.084: 122.21,39.74 122.21,39.74
  IN1 w0.089: v1(138.61,17.26) 138.28,17.59 138.28,18.25 138.31,18.28 138.31,18.68 137.66,19.33 137.14,19.33 134.56,21.91 133.46,21.91 130.18,25.2 130.18,25.34 130.5,25.67 130.5,25.81 130.39,25.92 130.25,25.92 129.92,25.59 129.78,25.59 129.67,25.7 129.67,25.85 129.98,26.16 129.98,26.3 129.88,26.41 129.73,26.41 129.42,26.1 129.27,26.1 129.17,26.2 129.17,26.35 129.47,26.65 129.47,26.8 129.37,26.9 129.22,26.9 128.92,26.6 128.77,26.6 128.64,26.73 128.64,26.88 128.9,27.14 128.9,27.29 128.79,27.39 128.65,27.39 128.39,27.13 128.24,27.13 128.13,27.24 128.13,27.38 128.52,27.77 128.52,27.89 128.39,28.02 128.27,28.02 127.91,27.66 127.76,27.66 127.66,27.77 127.66,27.91 128.02,28.27 128.02,28.4 127.89,28.52 127.76,28.52 127.38,28.14 127.23,28.14 127.13,28.24 127.13,28.39 127.51,28.77 127.51,28.9 127.39,29.03 127.26,29.03 126.88,28.64 126.73,28.64 126.63,28.75 126.63,28.89 127.01,29.28 127.01,29.4 122.21,34.21 122.21,39.74
  BOTTOM w0.076: UC1.BB35 120.71,50.92 120.71,49.29 121.02,48.97 121.02,47.89 120.66,47.53 v1(120.66,47.52)
  BOTTOM w0.102: JDIMM2.29 139.17,17.44 138.99,17.26 v1(138.61,17.26)
DDR_B_D13: length 54.5
  IN1 w0.076: v1(120.64,48.76) 120.76,48.63 120.76,48.61 121.98,47.39 121.98,40.56 122.53,40 122.53,39.74
  IN1 w0.089: 122.53,39.74 122.53,34.31 131,25.85 131,25.7 130.62,25.33 130.62,25.18 130.73,25.08 130.87,25.08 131.25,25.45 131.4,25.45 131.5,25.34 131.5,25.2 131.13,24.82 131.13,24.68 133.46,22.35 134.7,22.35 135.01,22.66 135.16,22.66 135.26,22.56 135.26,22.41 134.95,22.1 134.95,21.95 135.05,21.85 135.2,21.85 135.61,22.26 135.76,22.26 135.86,22.15 135.86,22 135.45,21.59 135.45,21.45 135.56,21.34 135.7,21.34 136.19,21.83 136.34,21.83 136.44,21.72 136.44,21.58 135.96,21.09 135.96,20.94 137.27,19.63 137.79,19.63 139.3,18.12 139.3,17.37 138.62,16.69 v1(138.62,15.95)
  BOTTOM w0.076: UC1.BA35 120.81,51.45 120.54,51.18 120.54,50.52 120.54,50.52 120.54,48.85 v1(120.64,48.76)
  BOTTOM w0.102: v1(138.62,15.95) 138.17,16.4 JDIMM2.25
DDR_B_D14: length 54.9
  IN1 w0.089: v1(123.02,46.5) 123.85,45.68 123.85,41.05 124.68,40.22 124.68,36.18 132.05,28.8 132.05,28.66 131.71,28.31 131.71,28.16 131.81,28.06 131.96,28.06 132.3,28.41 132.45,28.41 132.56,28.3 132.56,28.15 132.21,27.81 132.21,27.66 132.31,27.56 132.46,27.56 132.8,27.9 132.96,27.9 133.06,27.79 133.06,27.64 132.68,27.27 132.68,27.11 132.79,27.01 132.94,27.01 133.14,27.2 133.28,27.2 133.39,27.1 133.39,26.95 133.2,26.77 133.2,26.59 133.6,26.2 133.6,25.65 134.5,24.75 136.37,24.75 136.49,24.62 136.81,24.62 137.06,24.37 137.06,24.06 137.31,23.8 137.63,23.8 137.88,23.55 137.88,23.24 138.13,22.98 138.45,22.98 138.7,22.73 138.7,22.42 138.95,22.16 139.27,22.16 139.52,21.91 139.52,21.6 140.42,20.7 140.74,20.7 140.99,20.45 140.99,20.13 141.24,19.88 141.56,19.88 141.91,19.53 141.91,19.04 141.66,18.79 141.66,18.65 141.76,18.54 142.03,18.54 142.13,18.44 142.13,16.97 142.14,16.96 142.14,16.14 v1(141.75,15.75)
  BOTTOM w0.076: UC1.BA33 122.13,51.52 122.28,51.37 122.4,51.13 122.4,50.87 122.25,50.71 122.25,50.22 122.39,50.08 122.39,47.13 v1(123.02,46.5)
  BOTTOM w0.102: v1(141.75,15.75) 141.17,16.32 JDIMM2.37
DDR_B_D15: length 53.5
  IN1 w0.089: v1(141.7,17.28) 141.3,17.67 141.3,19.38 136.24,24.44 134.34,24.44 133.29,25.5 133.29,26.08 131.27,28.1 131.27,28.34 131.4,28.47 131.4,28.62 131.29,28.74 131.13,28.74 130.95,28.56 130.81,28.56 130.7,28.66 130.7,28.81 130.93,29.04 130.93,29.19 130.83,29.29 130.68,29.29 130.45,29.06 130.3,29.06 130.2,29.17 130.2,29.31 130.49,29.61 130.49,29.76 130.39,29.86 130.24,29.86 129.95,29.57 129.8,29.57 129.7,29.67 129.7,29.82 130.03,30.15 130.03,30.3 129.92,30.4 129.78,30.4 129.45,30.07 129.3,30.07 129.19,30.17 129.19,30.32 129.55,30.68 129.55,30.82 129.45,30.93 129.3,30.93 128.94,30.57 128.79,30.57 128.69,30.68 128.69,30.82 129.07,31.21 129.07,31.35 128.97,31.46 128.82,31.46 128.44,31.07 128.29,31.07 128.19,31.18 128.19,31.33 128.57,31.71 128.57,31.86 128.47,31.96 128.32,31.96 127.94,31.58 127.79,31.58 127.68,31.68 127.68,31.83 128.07,32.21 128.07,32.36 124.36,36.06 124.36,40.15 123.67,40.84 123.67,45.21 v1(123.02,45.85)
  BOTTOM w0.076: UC1.BB33 122.13,50.89 122.1,50.86 122.1,50.8 122.05,50.75 122.05,50.19 122.23,50.01 122.23,46.99 122.58,46.64 122.58,46.3 v1(123.02,45.85)
  BOTTOM w0.102: v1(141.7,17.28) 142.17,17.76 JDIMM2.41
DDR_B_D16: length 91.6
  IN4 w0.076: 118.93,51.35 119.99,50.29 119.99,45.32
  IN4 w0.084: 118.93,51.35 118.68,51.6 118.48,51.6 117.38,52.7 v1(117.38,53.73)
  IN4 w0.089: 119.99,45.32 119.99,43.71 120.22,43.48 120.22,42.43 120.53,42.12 120.53,40.57 120.53,40.42 123.37,37.58 133.36,37.58 138.11,32.82 144.94,32.82 145.2,33.09 156.17,33.09 156.98,32.27 167.97,32.27 169.78,30.47 170.29,30.47 176.95,23.8 176.95,18.52 176.72,18.29 176.72,16.39 177.28,15.83 177.28,14.15 v1(176.92,13.79)
  BOTTOM w0.076: v1(117.38,53.73) 117.79,54.14 UC1.AU40
  BOTTOM w0.102: v1(176.92,13.79) 176.43,13.3 JDIMM2.170
DDR_B_D17: length 92.3
  IN4 w0.076: 117.96,51.77 118.29,51.43 118.61,51.43 119.69,50.35 119.69,45.19
  IN4 w0.084: 117.96,51.77 117.01,52.71 117.01,53.9 117.37,54.26 v1(117.37,54.44)
  IN4 w0.089: 119.69,45.19 119.69,43.58 119.92,43.35 119.92,42.3 120.22,42 120.22,40.7 120.22,40.28 120.23,40.28 123.24,37.27 133.24,37.27 137.99,32.52 145.07,32.52 145.33,32.78 156.04,32.78 156.85,31.97 167.85,31.97 169.65,30.16 170.16,30.16 176.65,23.68 176.65,18.64 176.42,18.41 176.42,15.75 v1(176.82,15.34)
  BOTTOM w0.076: UC1.AT40 117.61,54.62 v1(117.37,54.44)
  BOTTOM w0.102: v1(176.82,15.34) 177.43,14.74 JDIMM2.174
DDR_B_D18: length 93.3
  IN4 w0.076: 122.03,46.93 122.03,46.95 122,46.98 122,48.83 121.85,48.97 121.68,48.97 120.93,49.72 120.93,50.75 119.58,52.1 119.58,53.94 119.2,54.32 v1(119.2,54.44)
  IN4 w0.089: v1(179.87,14.63) 179.36,14.13 179.13,14.13 178.91,14.35 178.91,18.39 178.45,18.84 178.45,24.43 170.94,31.94 170.39,31.94 168.59,33.75 157.59,33.75 156.78,34.56 144.59,34.56 144.33,34.3 138.74,34.3 135.28,37.77 135.27,37.77 134.71,38.32 134.71,38.32 133.97,39.06 123.98,39.06 122.03,41 122.03,46.93
  BOTTOM w0.076: v1(119.2,54.44) UC1.AT37
  BOTTOM w0.102: JDIMM2.182 179.43,14.19 v1(179.87,14.63)
DDR_B_D19: length 92.4
  IN4 w0.089: v1(179.92,13.11) 179.59,13.11 178.78,13.92 178.28,13.92 178.19,14.01 178.19,15 178.28,15.09 178.51,15.09 178.6,15.18 178.6,18.26 178.15,18.71 178.15,24.3 170.81,31.64 170.27,31.64 168.46,33.45 157.46,33.45 156.65,34.26 144.72,34.26 144.46,34 138.61,34 134.59,38.02 134.58,38.02 133.85,38.75 123.85,38.75 121.73,40.88 121.73,48.66 120.75,49.64 120.75,50.51 119.2,52.07 v1(119.2,53.79)
  BOTTOM w0.076: v1(119.2,53.79) UC1.AU37
  BOTTOM w0.102: JDIMM2.186 180.43,12.61 v1(179.92,13.11)
DDR_B_D20: length 93
  IN4 w0.076: 118.84,45.34 118.84,47.91 118.72,48.03 118.72,50.71
  IN4 w0.084: v1(117.37,55.08) 116.98,54.69 116.98,54.12 116.83,53.97 116.83,52.6
  IN4 w0.089: 118.84,45.34 118.84,43.69 118.89,43.65 118.89,43.64 119.12,43.41 119.12,43.41 119.61,42.92 119.61,42.18 119.92,41.87 119.92,40.83 119.92,40.41 119.92,40.16 123.11,36.97 133.11,36.97 137.86,32.21 145.2,32.21 145.46,32.48 155.91,32.48 156.72,31.66 167.72,31.66 169.53,29.86 170.03,29.86 176.34,23.55 176.34,18.77 176.11,18.54 176.11,16.12 176.02,16.03 175.81,16.03 v1(175.68,16.16) ; 118.72,50.71 116.83,52.6
  BOTTOM w0.076: v1(117.37,55.08) UC1.AR40
  BOTTOM w0.102: JDIMM2.173 177.18,19.8 177.17,19.8 177.17,17.66 v1(175.68,16.16)
DDR_B_D21: length 93.7
  IN4 w0.084: v1(117.37,55.71) 116.81,55.16 116.81,54.19 116.66,54.04 116.66,52.53 118.47,50.72 118.47,47.81 118.48,47.8
  IN4 w0.089: 118.48,47.8 118.54,47.74 118.54,45.32 118.53,45.32 118.53,43.47 119.31,42.69 119.31,42.03 119.61,41.73 119.61,40.95 119.61,40.54 119.61,40.03 122.98,36.66 132.98,36.66 137.73,31.91 145.32,31.91 145.58,32.17 155.79,32.17 156.6,31.36 167.59,31.36 169.4,29.55 169.91,29.55 176.04,23.42 176.04,21.96 175.95,21.87 175.78,21.87 175.7,21.78 175.7,21.61 175.78,21.52 175.95,21.52 176.04,21.43 176.04,21.25 175.95,21.16 175.78,21.16 175.7,21.07 175.7,20.89 175.78,20.81 175.95,20.81 176.04,20.72 176.04,20.54 175.95,20.45 175.57,20.45 175.48,20.35 175.48,20.18 175.57,20.09 175.95,20.09 176.04,20.01 176.04,19.83 175.95,19.74 175.46,19.74 175.38,19.65 175.38,19.47 175.46,19.38 175.95,19.38 176.04,19.29 176.04,19.08 175.96,19 175.41,19 175.27,18.86 175.27,17.69 175.39,17.58 175.59,17.58 175.68,17.67 v1(175.68,17.81)
  BOTTOM w0.076: v1(117.37,55.71) 117.61,55.91 UC1.AP40
  BOTTOM w0.102: JDIMM2.169 176.18,19.8 176.17,19.8 176.17,18.31 v1(175.68,17.81)
DDR_B_D22: length 94.7
  IN4 w0.076: v1(119.2,55.71) 119.74,55.17 119.74,54.29 119.91,54.12 119.91,52.65 121.65,50.92 121.65,50.36 122.34,49.67 122.34,47.32 122.64,47.02
  IN4 w0.089: v1(179.92,17.99) 179.76,17.83 179.61,17.83 179.52,17.92 179.52,19.14 179.4,19.26 179.16,19.26 179.06,19.35 179.06,19.57 179.15,19.65 179.77,19.65 179.86,19.74 179.86,20.04 179.77,20.12 179.15,20.12 179.06,20.21 179.06,20.51 179.15,20.59 179.77,20.59 179.86,20.68 179.86,20.98 179.77,21.06 179.15,21.06 179.06,21.15 179.06,22.06 179.15,22.15 179.47,22.15 179.56,22.24 179.56,22.53 179.47,22.62 179.15,22.62 179.06,22.71 179.06,23 179.15,23.09 179.47,23.09 179.56,23.18 179.56,23.47 179.47,23.56 179.15,23.56 179.06,23.65 179.06,24.7 171.21,32.55 170.65,32.55 168.84,34.36 157.84,34.36 157.03,35.17 144.34,35.17 144.08,34.91 139,34.91 133.75,40.16 131.83,40.16 131.47,39.81 130.74,39.81 130.6,39.68 124.22,39.68 122.64,41.26 122.64,47.02
  BOTTOM w0.076: v1(119.2,55.71) 119.56,56.01 UC1.AP37
  BOTTOM w0.102: v1(179.92,17.99) 180.68,18.74 JDIMM2.187
DDR_B_D23: length 94.2
  IN4 w0.076: v1(119.2,55.08) 119.58,54.7 119.58,54.18 119.75,54.01 119.75,52.39 121.28,50.85 121.28,50.42 121.48,50.22 121.48,50.22 121.58,50.12 121.58,50.12 121.8,49.9 121.8,49.9 122.16,49.54 122.16,47.14 122.34,46.96
  IN4 w0.089: v1(179.9,16.46) 179.9,15.54 179.75,15.4 179.36,15.4 179.21,15.54 179.21,18.51 178.76,18.97 178.76,24.55 171.06,32.25 170.52,32.25 168.71,34.06 157.72,34.06 156.91,34.87 144.47,34.87 144.2,34.61 138.88,34.61 136.22,37.26 136.22,37.26 135.4,38.07 135.4,38.07 134.11,39.36 124.11,39.36 122.34,41.13 122.34,46.96
  BOTTOM w0.076: v1(119.2,55.08) UC1.AR37
  BOTTOM w0.102: JDIMM2.183 179.68,19.16 179.34,18.82 179.34,16.94 179.82,16.46 v1(179.9,16.46)
DDR_B_D24: length 95.8
  IN4 w0.076: 124.1,47.6 124.1,47.65 123.93,47.83 123.88,47.83 123.06,48.64 123.06,49.65 122.33,50.39 122.33,51.18 121.28,52.23 121.28,52.9 120.65,53.53 120.65,53.96 121.02,54.34 v1(121.02,54.44)
  IN4 w0.089: 124.1,47.6 124.1,42.22 125.36,40.95 127.46,40.95 127.91,41.4 135.03,41.4 136.51,39.92 136.98,39.92 139.51,37.39 140.72,37.39 141.73,36.38 157.53,36.38 158.34,35.57 169.34,35.57 171.15,33.76 171.71,33.76 181.28,24.19 181.28,17.78 181.55,17.52 181.55,17.34 181.46,17.25 181.17,17.25 181.08,17.16 181.08,17 181.48,16.6 181.48,14.6 181.57,14.51 181.8,14.51 181.93,14.63 181.93,16.01 v1(182.13,16.21)
  BOTTOM w0.076: UC1.AT33 121.2,54.58 v1(121.02,54.44)
  BOTTOM w0.102: v1(182.13,16.21) 181.68,16.67 JDIMM2.191
DDR_B_D25: length 95.3
  IN4 w0.076: 124.08,48.21 123.24,49.05 123.24,50.8 121.56,52.48 121.56,53.27 v1(121.02,53.81)
  IN4 w0.089: 124.08,48.21 124.41,47.88 124.41,42.36 125.5,41.26 127.31,41.26 127.75,41.7 135.22,41.7 136.62,40.31 137.04,40.31 139.65,37.7 140.85,37.7 141.86,36.69 157.66,36.69 158.47,35.87 169.47,35.87 171.27,34.06 171.84,34.06 175.61,30.3 175.73,30.3 176.02,30.59 176.15,30.59 176.3,30.43 176.3,30.31 176.01,30.02 176.01,29.89 176.16,29.74 176.29,29.74 176.58,30.03 176.7,30.03 176.86,29.87 176.86,29.75 176.57,29.46 176.57,29.34 176.72,29.18 176.85,29.18 177.13,29.47 177.26,29.47 177.41,29.32 177.41,29.19 177.13,28.9 177.13,28.78 177.28,28.63 177.4,28.63 177.69,28.91 177.82,28.91 177.97,28.76 177.97,28.63 177.68,28.35 177.68,28.22 177.84,28.07 177.96,28.07 178.25,28.36 178.37,28.36 178.53,28.2 178.53,28.08 178.24,27.79 178.24,27.66 178.39,27.51 178.52,27.51 178.81,27.8 178.93,27.8 179.09,27.65 179.09,27.52 178.8,27.23 178.8,27.11 178.95,26.95 179.08,26.95 179.35,27.22 179.51,27.22 179.62,27.11 179.62,27.02 179.62,26.94 179.35,26.68 179.35,26.55 179.51,26.4 179.63,26.4 179.86,26.63 180.03,26.63 180.14,26.51 180.14,26.35 179.91,26.12 179.91,25.99 181.6,24.3 181.6,18.3 v1(182.13,17.77)
  BOTTOM w0.076: v1(121.02,53.81) 121.2,53.94 UC1.AU33
  BOTTOM w0.102: v1(182.13,17.77) 182.29,17.77 182.68,18.15 JDIMM2.195
DDR_B_D26: length 94.3
  IN4 w0.076: 126.35,48.27 126.8,47.83 126.8,46.66
  IN4 w0.084: v1(122.85,53.81) 123.17,53.49 123.17,51.99 124.64,50.52 124.64,49.99 126.35,48.27
  IN4 w0.089: v1(183.71,17.99) 183.27,18.43 183.27,19 182.85,19.42 182.85,19.63 182.94,19.72 183.09,19.72 183.18,19.81 183.18,20.02 183.09,20.11 182.94,20.11 182.85,20.2 182.85,20.42 182.94,20.51 183.09,20.51 183.18,20.6 183.18,20.81 183.09,20.9 182.94,20.9 182.85,20.99 182.85,21.21 182.94,21.29 183.09,21.29 183.18,21.38 183.18,21.6 183.09,21.69 182.94,21.69 182.85,21.78 182.85,21.99 182.94,22.08 183.09,22.08 183.18,22.17 183.18,22.39 183.09,22.48 182.94,22.48 182.85,22.56 182.85,22.78 182.94,22.87 183.09,22.87 183.18,22.96 183.18,23.17 183.09,23.26 182.94,23.26 182.85,23.35 182.85,24.79 181.4,26.24 181.4,27.01 175.98,32.43 175.73,32.43 175.53,32.23 175.34,32.23 175.1,32.47 175.1,32.59 175.32,32.81 175.32,32.94 175.17,33.09 175.04,33.09 174.82,32.87 174.7,32.87 174.54,33.02 174.54,33.15 174.76,33.37 174.76,33.49 174.61,33.65 174.48,33.65 174.26,33.43 174.14,33.43 173.98,33.58 173.98,33.71 174.2,33.93 174.2,34.05 174.05,34.2 173.93,34.2 173.71,33.98 173.58,33.98 173.43,34.14 173.43,34.26 173.65,34.48 173.65,34.61 173.49,34.76 173.37,34.76 173.15,34.54 173.02,34.54 172.33,35.24 171.76,35.24 169.95,37.05 163.28,37.05 163.2,37.14 163.2,37.92 163.11,38.01 162.89,38.01 162.8,37.92 162.8,37.14 162.71,37.05 162.5,37.05 162.41,37.14 162.41,37.92 162.32,38.01 162.1,38.01 162.01,37.92 162.01,37.26 161.93,37.17 161.71,37.17 161.61,37.27 161.61,37.8 161.43,37.99 149.97,37.99 149.69,38.27 141.94,38.27 141.34,38.87 140.19,38.87 135.87,43.19 129.7,43.19 127.99,44.89 127.54,44.89 126.8,45.64 126.8,46.66
  BOTTOM w0.076: UC1.AU30 v1(122.85,53.81)
  BOTTOM w0.102: v1(183.71,17.99) 184.06,17.99 184.68,18.6 JDIMM2.203
DDR_B_D27: length 95.4
  IN4 w0.076: v1(122.85,54.44) 122.85,54.34 123.37,53.82 123.37,53.17 ; 127.1,46.99 127.1,47.86 126.71,48.25
  IN4 w0.084: 123.37,53.17 123.37,52.15 124.94,50.57 124.94,50.01 126.71,48.25
  IN4 w0.089: v1(183.73,16.46) 183.98,16.46 184.13,16.61 184.13,19.04 183.51,19.67 183.51,23.42 183.42,23.51 183.28,23.51 183.19,23.6 183.19,23.82 183.28,23.91 183.42,23.91 183.51,24 183.51,24.21 183.42,24.3 183.28,24.3 183.19,24.39 183.19,24.6 183.28,24.69 183.42,24.69 183.51,24.78 183.51,24.98 183.38,25.1 183.02,25.1 182.94,25.19 182.94,25.32 183.16,25.55 183.16,25.68 183.02,25.82 182.9,25.82 182.67,25.59 182.54,25.59 181.7,26.42 181.7,27.14 173.3,35.54 171.89,35.54 170.08,37.35 165.32,37.35 165.16,37.51 165.16,38.22 165.07,38.31 164.86,38.31 164.77,38.22 164.77,37.45 164.68,37.36 164.47,37.36 164.38,37.45 164.38,38.22 164.29,38.31 164.07,38.31 163.98,38.22 163.98,37.45 163.89,37.36 163.68,37.36 163.59,37.45 163.59,38.22 163.5,38.31 150.21,38.31 149.94,38.58 142.12,38.58 141.52,39.18 140.32,39.18 136,43.49 129.96,43.49 128.25,45.21 128.25,45.84 127.69,46.4 127.36,46.4 127.1,46.66 127.1,46.99
  BOTTOM w0.076: UC1.AT30 v1(122.85,54.44)
  BOTTOM w0.102: JDIMM2.207 185.68,18.49 185.54,18.35 185.54,17.96 184.04,16.46 v1(183.73,16.46)
DDR_B_D28: length 96.5
  IN4 w0.076: 123.8,47.52 123.8,47.63 123.62,47.81 123.51,47.81 122.7,48.62 122.7,49.79 122.16,50.32 122.16,50.33 122.15,50.34 122.15,51.1 121.1,52.15 121.1,52.79 120.49,53.4 120.49,54.04 120.65,54.21 120.65,54.71 v1(121.02,55.08)
  IN4 w0.089: 123.8,47.52 123.8,42.04 125.19,40.65 127.62,40.65 128.07,41.09 134.83,41.09 136.42,39.51 136.96,39.51 139.38,37.09 140.59,37.09 141.61,36.08 157.41,36.08 158.22,35.26 169.21,35.26 171.02,33.46 171.59,33.46 180.77,24.27 180.77,16.87 181.17,16.47 181.17,14.13 181.37,13.93 181.37,13.58 181.48,13.46 181.81,13.46 181.93,13.58 181.93,14.2 182.34,14.61 v1(182.34,14.86)
  BOTTOM w0.076: UC1.AR33 121.2,55.22 v1(121.02,55.08)
  BOTTOM w0.102: JDIMM2.190 181.43,13.95 v1(182.34,14.86)
