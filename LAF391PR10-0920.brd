# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.2V_MEM_CPUCLK: length 8.1
  TOP w0.102: v1(118.34,56.37) 118.34,56.4 118.05,56.69 v2(117.83,56.69)
  TOP w0.254: v1(118.34,56.37) 117.84,55.87 117.84,53.65 CC297.1 118.54,52.49 118.36,52.31 117.59,52.31 117.2,52.7 RC231.1
  BOTTOM w0.152: v1(118.34,56.37) 118.34,56.87 UC1.AM40
+1.8V_3.3V_ALW_VTR3: length 29.7
  TOP w0.102: CE21.1 261.98,41.02 v2(262.04,40.95)
  TOP w0.254: RE549.1 256.21,41.4 v1(256.21,42.16) ; CE21.1 262.13,41.98 262.13,43.82 v1(262.03,43.91) 262.42,44.3 UE1.N5
  TOP w0.508: RE340.2 252.07,43.54 v1(252.21,43.68)
  IN4 w0.381: v1(262.03,43.91) 262.03,44.19 261.65,44.57 257.94,44.57 257.08,43.71 257.08,43.02 v1(256.21,42.16) 255.4,42.97 252.92,42.97 v1(252.21,43.68) 249.5,43.68 248.74,42.92 244.12,42.92 241.91,45.13 v1(241.56,45.13)
+1.8V_PGPPF: length 0.5
  BOTTOM w0.381: UC1.AF16 131.82,60.63 131.52,60.32 v1(131.52,60.29)
  vias: v2(133.94,60.28)
+1.8V_PRIM: length 103.3
  IN3 w1.016: 177.04,51.48 177.04,49.54 177.77,48.81 181.57,48.81 186.42,43.96 192.55,43.96 194.19,42.32 203.01,42.32 204.74,40.6 209.06,40.6 210.06,39.59 212.6,39.59 ; 167.06,103.11 167.06,102.57 168.01,101.62 171.22,101.62 171.73,101.11 173.56,101.11 174.81,99.87 174.81,96.77 175.2,96.38 175.2,93.15 174.15,92.1 174.15,89.94 173.79,89.58 173.79,87.8 174.52,87.08 174.52,80.81 175.09,80.23 175.09,78.25 177.73,75.61 177.73,67.24 179.15,65.82 179.15,56.71 177.27,54.83 177.27,53.86
  BOTTOM w0.203: 141.77,62.52 141.45,62.85 UC1.AA1
  BOTTOM w0.457: RC212.1 v1(154.25,58.7)
  vias: v1(144.39,62.47) v1(144.99,62.47) v1(167.15,104.64) v1(167.15,104.01) v1(177.09,52.98) v1(177.09,52.4) v1(238.89,45) v1(239.48,45) v3(237.91,37.7)
+1.8V_RUN: length 144.1
  TOP w0.508: v1(176.43,65.29) 179.93,65.29 181.67,63.55 181.67,62.66 183.19,61.13 183.19,54.05 186.31,50.92 v3(186.31,49.01) 186.31,47.18 189.49,44.01 189.49,42.92 190.45,41.96 200.05,41.96 v1(202.05,39.96) ; 236.55,34.22 233.98,34.22 233.02,35.18 233.02,35.9 233.23,36.11 233.23,37.46 232.47,38.22 v1(232.47,38.53)
  IN2 w1.016: 244.29,11.45 244.77,10.97 250.93,10.97 252.01,9.89 259.37,9.89 260.24,9.03 262.68,9.03 263.28,9.62 265.08,9.62
  IN3 w0.381: v1(232.47,38.53) 232.47,38.91 232.21,39.16 231.97,39.16 231.41,39.72 229.78,39.72 228.96,38.91 227.88,38.91 226.79,37.82 221.21,37.82 220.68,37.28 217.77,37.28 217.34,36.85 210.24,36.85 209.37,37.73 204.91,37.73 204.4,38.23 203.78,38.23 v1(202.05,39.96)
  BOTTOM w0.508: RC362.2 RC363.2 164.85,70.2 166.04,69.01 169.35,69.01 173.07,65.29 v1(176.43,65.29)
  BOTTOM w1.016: 238.94,26.97 238.94,30.65 237.8,31.8 237.8,33.07 ; 243.84,13.51 242.83,13.51 239.53,16.81 239.53,24.99
  vias: v1(237.21,33.83) v1(237.77,34.01) v1(244.67,13.04) v1(245.25,13.04) v1(265.87,9.19) v1(266.5,9.19)
+1.8V_RUN_AUDIO: length 5.2
  TOP w0.203: UA1.20 265.58,15.97 266.07,15.48 CA69.1 CA57.1 266.84,14.92 266.44,14.51 CA58.1 266.37,14.14 RA3.2
+1.8V_RUN_CARD: length 28.1
  TOP w0.508: JSD1.13 v1(85.72,110.45)
  IN4 w0.762: v1(82.73,108.48) 82.73,107.64 79.68,104.59 77.25,104.59 75.54,102.89 75.54,101.06 74.38,99.9 74.38,98.82 75.53,97.67 75.53,94.88
  BOTTOM w0.203: UR1.13 75.75,93.95 v1(75.7,93.9)
  BOTTOM w0.508: v1(82.73,108.48) 84.36,108.48 85.02,109.14 CR20.2 84.66,109.88 CR19.2 85.63,110.46 85.64,110.47 85.72,110.47 v1(85.72,110.45) 86.25,110.45 v3(87.05,109.65)
+1.8V_RUN_UZ8: length 1.9
  TOP w0.102: v2(239.46,36.94) 239.3,37.1 238.28,37.1 237.93,36.75 CZ120.1
+1.8VALWP: length 7.8
  BOTTOM w0.254: 169.22,104.57 171.38,104.57 171.71,104.24 172.14,104.24 172.87,104.97 PC503.1 175.65,104.97 PR501.1
  vias: v1(169.65,106.37) v1(170.24,106.37) v3(170.32,105.75)
+1VALWP: length 5.8
  BOTTOM w0.254: 165.22,101.28 165.93,101.28 166.53,101.88 166.53,104.4 PC307.1 PR306.1
  vias: v1(162.65,98.03) v1(163.24,98.03) v1(163.82,98.03) v1(164.11,101.22) v1(164.11,100.62) v1(164.11,99.98) v1(164.13,99.36) v1(164.14,98.76) v1(164.42,98.03) v1(164.72,101.28) v1(164.93,98.37) v3(165.08,97.72)
+1VALWP_B+:
  vias: v1(156.49,106.52) v1(156.8,107.03) v1(157.09,106.52) v1(157.38,107.03) v2(157.85,106.43)
+1VS_VCCIOP: length 13.6
  TOP w0.508: PC426.1 v3(170.44,51.48)
  IN2 w0.254: v1(170.39,54.76) 171.68,53.47 171.68,52.72 172.42,51.98 172.42,49.86 v1(173.28,48.99)
  BOTTOM w0.254: v1(173.28,48.99) 173.16,49.12 173.16,49.5 173.36,49.7 PU401.1 ; PC406.1 171.33,54.81 172.98,54.81 173.38,54.41 PR421.1
  vias: v1(169.78,54.76)
+2.5V_MEM: length 86.8
  IN2 w1.016: 117.66,18.84 120.07,21.26 120.07,22.65 121.82,24.41 131.78,24.41 132.99,23.19 136.17,23.19 139.2,20.16 194.31,20.16 195.61,21.46
  BOTTOM w0.305: v1(116.65,18.06) 116.18,18.54 JDIMM1.257 ; v1(116.73,18.75) 116.68,18.8 JDIMM1.259
  vias: v1(195.98,22.26) v1(196.27,22.78) v1(196.56,22.26) v1(198.43,18.22) v1(198.59,17.65) v1(199.18,17.65) v1(214.13,17.12) v1(214.71,17.12) v1(215.31,17.12) v3(191.27,24.05)
+2.5V_VIN: length 1.3
  TOP w0.102: v2(218.81,15.52) 219.09,15.24 219.97,15.24
+3.3V_1.8V_ESPI:
  vias: v2(155.47,49.58)
+3.3V_1.8V_PGPPA: length 2.7
  TOP w0.127: v1(154.41,52.49) v2(153.56,52.49)
  TOP w0.508: RC551.2 133.2,57.87 v1(132.92,57.59)
  BOTTOM w0.254: UC1.AK15 132.47,57.95 132.83,57.59 v1(132.92,57.59)
  vias: v1(154.42,53.08) v1(154.96,52.75)
+3.3V_1.8V_PGPPG: length 9.6
  TOP w0.508: RC234.2 146.21,60.68 145.24,59.71 143.77,59.71 142.7,58.64 140.92,58.64 140.52,59.05 140.52,59.79 140.62,59.89 140.62,61.24 v1(141.03,61.64)
  vias: v1(132.18,61.9) v1(132.82,61.86) v2(134.07,63.51)
+3.3V_ALW: length 437
  TOP w0.254: PR1.1 v1(33.36,16.2) ; v1(32.19,50.5) 32.19,50.94 31.86,51.28 30.54,51.28 30.31,51.04 30.31,49.25 PR933.1 ; JKBTP1.6 201.65,19.06 200.97,19.74 CZ91.1 ; PC206.1 54.98,62.89 54.56,62.47 v1(54.56,61.92) ; RE561.2 258.37,39.34 v1(258.37,40.31)
  TOP w0.305: v1(201.48,20.04) 201.48,20.24 201.1,20.62 CZ91.1 ; v1(274.07,8.56) 273.8,8.83 JLED1.6
  TOP w0.356: CZ93.1 278.81,71.41 UZ10.5
  TOP w0.381: v1(251.13,40.94) 251.57,40.51 UE6.5 ; v1(277.46,43.47) 277.6,43.61 CE61.1 277.59,44.13 UE4.5 ; UZ6.5 CZ82.1 205.41,36.7 205.8,37.08 v1(207.98,37.08) ; v1(278.62,41.89) 278.62,41.6 278.15,41.13 CE52.1 277.67,41.13 UE5.5 ; RC214.2 148.24,56.27 147.89,55.93 147.48,55.93 v1(147.2,55.65) ; v1(48.06,49.68) 48.01,49.63 47.25,49.63 46.49,50.39 46.49,51.53 45.77,52.25 45.77,52.39 45.75,52.4 45.75,52.79 45.77,52.81 45.77,52.93 46.3,53.46 PR1232.2 ; RE343.1 253.19,49.22 v1(252.15,49.22)
  TOP w0.406: UE3.5 276.86,37.14 CE53.1 v1(277.47,37.86)
  TOP w0.432: QZ2.2 283.24,37.96 283.74,38.45 283.74,39.73 282.08,41.39 v1(282.02,41.39)
  TOP w0.457: RE5.2 RE365.2 272.77,50.97 272.89,50.97 v1(273.09,51.18) ; v1(261.6,34.62) 261.31,34.32 261.31,33.99 RE12.2
  TOP w0.508: v1(254.97,53.18) 255.01,53.22 RE11.2 ; PR1259.2 50.45,50.57 49.53,49.65 48.09,49.65 v1(48.06,49.68) ; v1(230.86,34.97) 230.86,35.21 230.36,35.72 227.84,35.72 227.43,36.13 226.22,36.13 225.57,35.48 RZ518.1 ; RE35.2 269.8,40.83 270.31,40.32 v1(270.83,40.32) ; RE524.2 260.63,60.78 v1(260.63,61.67) ; v1(275.16,71.47) 275.9,72.21 278.35,72.21 278.73,71.83 CZ93.1 ; v1(248.85,52.98) 249,53.13 RE302.2 RE303.2 RE68.2 ; PR1234.2 48.51,54.7 48.8,54.99 48.8,56.23 48.54,56.49 PR1235.2 PR1233.2 52.06,57.36 54.56,59.86 v1(54.56,61.92) ; v1(174.76,48.01) 174.32,48.01 173.95,47.64 PR404.1 173.95,46.1 175.04,45 v1(177.52,45) 177.52,45.18 178.03,45.69 182.86,45.69 184.97,47.8 184.97,49.96 178.62,56.31 v1(176.84,56.31) ; PR517.2 175.55,106.5 v1(175.5,106.45) ; PR113.1 40.32,40.4 41.87,38.85 44.21,38.85 45.04,38.02 46.82,38.02 47.63,37.21 v1(49.76,37.21) 50.68,38.12 50.68,39.34 50.86,39.52 50.86,44.75 48.95,46.66 46.54,46.66 46.03,47.16 v1(46.03,47.93) ; RZ369.1 156.85,55.67 CZ57.1 CZ58.1 154.64,55.89 v1(154.25,56.28) ; PR307.1 163.9,103.82 v1(163.22,103.82) ; RE300.1 276.8,46.47 v1(277.27,46.94) ; RC68.2 v1(164.62,47.93) ; RE25.1 271.75,38.06 v1(272.34,38.06) ; RE38.2 272.59,43.94 v1(272.59,43.27) ; 236.19,11.21 235.36,10.38 RE72.1 RE74.1 RE75.1 RE73.1 ; v1(273.36,50.06) 273.92,50.06 RE84.2 ; PR410.1 173.84,95.07 174.15,95.37 v1(174.15,96.06) ; PR1224.2 PR1225.2 36.63,79.29 36.3,79.63 v1(36.28,79.63) ; v1(42.93,57.45) 42.68,57.2 PR1231.2 43.07,55.94 PR1230.2 ; PL502.1 177.84,106.99 v1(177.27,106.42) ; RE526.2 279.81,57.37 v1(279.33,57.37) ; 256.6,8.3 256.6,7.79 257.17,7.22 262.78,7.22 v1(263.25,6.75) ; PR417.1 PR418.1 174.93,103.69 174.93,104.06 v1(175.01,104.14) ; RT68.2 v1(32.52,53.97) ; v1(269.42,59.69) 269.3,59.81 RE21.2 ; RC431.2 v1(251.13,40.94) ; v1(275.85,47.16) 275.67,47.34 RE83.2 RE79.2 ; v1(273.26,55.44) 273.02,55.44 272.51,54.94 RE91.2 RE301.2 ; v1(50.83,83.39) 50.3,83.92 49.15,83.92 48.55,84.52 PR4.2 ; RE8.2 272.47,40.43 v1(272.53,40.37) ; v1(275.89,53.73) 275.05,53.73 RE63.2 ; v1(109.4,100.55) 113.16,100.55 114.1,99.61 114.99,99.61 115.5,99.11 116.01,99.11 117.63,100.73 v3(121.22,100.73) 123.68,100.73 124.7,99.72 v1(124.7,98.35) ; QC7.3 250.49,44.28 RC432.1 250.83,42.74 v1(251.11,42.46)
  IN1 w0.457: v1(32.19,50.5) 32.19,53.65 v1(32.52,53.97)
  IN1 w0.508: v1(268.28,63.04) 268.91,63.67 268.91,66.21 271.15,68.45 272.14,68.45 v1(275.16,71.47) ; v1(260.63,61.67) 260.93,61.96 262.32,61.96 262.51,61.77 265.1,61.77 v1(266.37,63.04) ; v1(252.75,54.1) 254.06,54.1 v1(254.97,53.18) ; v1(42.93,57.45) 39.63,57.45 36.68,54.5 35.44,54.5 34.9,53.97 v1(32.52,53.97)
  IN2 w0.254: v1(49.76,37.21) 49.76,35.96 54.67,31.06 54.67,24.56 46.74,16.63 43.11,16.63 41.38,14.91 34.65,14.91 v1(33.36,16.2)
  IN2 w0.508: v1(154.25,56.28) 154.25,56.24 152.23,54.22 148.63,54.22 v1(147.2,55.65) ; v1(263.25,6.75) 263.72,7.22 273.55,7.22 274.07,7.74 v1(274.07,8.56) ; v1(275.85,47.16) 277.04,47.16 v1(277.27,46.94) 277.13,46.79 277.13,43.8 v1(277.46,43.47) ; v1(272.34,38.06) 272.34,36.37 270.92,34.95 v1(270.92,34.34) ; v1(148.45,30.23) 148.45,31.19 148.96,31.7 170.62,31.7 174.12,35.2 174.12,41.6 v1(177.52,45)
  IN3 w0.508: v1(277.47,37.86) 278.19,38.58 278.19,39.87 278.62,40.31 v1(278.62,41.89) ; v1(278.62,41.89) 277.46,43.05 v1(277.46,43.47) ; v1(278.62,41.89) 281.51,41.89 v1(282.02,41.39) ; v1(272.53,40.37) 272.41,40.37 271.64,39.61 271.64,38.68 272.27,38.06 v1(272.34,38.06)
  IN4 w0.508: v1(174.76,48.01) 174.16,47.42 169.58,47.42 168.31,48.69 165.13,48.69 164.62,48.18 ; 164.62,48.18 164.62,48.38 164.32,48.69 163.5,48.69 154.45,48.69 153.73,49.41 153.73,51.73 151.55,53.91 148.94,53.91 v1(147.2,55.65) ; 164.62,48.18 v1(164.62,47.93) ; v1(50.83,83.39) 49.46,84.76 41.99,84.76 39.65,82.42 39.65,82.09 37.72,80.16 36.81,80.16 v1(36.28,79.63) ; v1(248.85,52.98) 249.71,52.98 250.25,53.51 252.17,53.51 v1(252.75,54.1) ; v1(48.06,49.68) 47.38,49.68 46.03,48.33 v1(46.03,47.93)
  BOTTOM w0.254: v1(54.56,61.92) 54.53,61.9 PU200.13
  BOTTOM w0.305: v1(212.2,15.69) 211.7,15.19 JAPS1.7 ; JAPS1.3 213.7,15.41 214.21,15.92 214.89,15.92 215.9,16.94 v1(215.9,17.12)
  BOTTOM w0.381: v1(109.4,100.55) 109.02,100.17 109.02,96.03 108.46,95.47 107.62,95.47 106.81,94.66 RE69.1
  BOTTOM w0.508: PR107.1 145.85,101.9 v1(146.49,101.27) ; v1(272.53,40.37) 272.59,40.42 v1(272.59,43.27) ; v1(277.46,43.47) 277.44,43.45 RE532.2 ; v1(136.73,91.67) 137.55,90.85 137.55,88.9 UZ35.5 ; v1(50.83,83.39) 50.83,84.47 51.19,84.83 PR29.2 51.76,85.7 PR28.2 ; PR413.1 177,54.52 PR414.1 177.86,55.64 177.19,56.31 v1(176.84,56.31) ; PR205.2 v1(58.34,64.51)
  vias: v1(72.22,88.13) v1(72.8,88.06) v1(124.94,97.74) v1(125.33,98.32) v1(125.52,97.74) v1(125.91,98.32) v1(126.11,97.74) v1(126.5,98.32) v1(126.69,97.74) v1(127.08,98.32) v1(127.27,97.74) v1(127.67,98.32) v1(127.86,97.74) v1(128.25,98.32) v1(128.44,97.74) v1(129.03,97.74) v1(164.34,55.9) v1(164.93,55.9) v1(176.46,64.21) v1(176.89,64.65) v1(176.86,63.78) v1(177.27,105.81) v1(177.32,64.22) v1(177.35,63.45) v1(177.64,60.59) v1(177.78,63.85) v1(178.11,60.24) v1(214.43,35.3) v1(215.02,35.3) v1(215.6,35.3) v1(216.21,35.3) v1(219.97,17.29) v1(220.4,17.73) v1(229.98,39.14) v1(230.31,38.59) v1(230.56,39.14) v1(230.92,38.59) v1(231.14,39.14) v1(233.1,39.15) v1(233.44,38.67) v1(233.68,39.21) v1(234.24,39.39) v1(235.48,11.95) v1(236.06,11.95) v1(236.66,11.95) v1(237.24,11.95) v1(252.21,46.66) v1(256.04,12.79) v1(256.52,13.19) v1(257.79,40.28) v1(267.01,63.04) v1(267.64,63.04) v1(270.31,34.41) v3(155.55,30.34) v3(177.96,64.56)
+3.3V_ALW2: length 158.2
  TOP w0.508: v1(139.15,100.38) 139.63,99.89 v3(139.63,98.52) v1(139.63,93.85) ; RE57.2 246.21,51.66 245.17,50.62 v1(245.17,50.49)
  IN3 w0.254: v1(245.17,50.49) 244.94,50.49 244.19,49.74 244.19,49.13 242.34,47.28 240.53,47.28 239.2,45.94 237.88,45.94 235.36,43.43 230.26,43.43 229.67,42.85 227.64,42.85 226.83,42.03 221.11,42.03 220.02,40.94 217.66,40.94 216.55,42.05 207.33,42.05 202.91,46.46 197.4,46.46 189.12,54.75 189.12,55.69 185.54,59.27 185.54,62.57 184.6,63.51 184.6,69.34 179.07,74.86 179.07,75.91 177.57,77.41 177.57,87.45 v1(176.46,88.57)
  IN4 w0.508: v1(176.46,88.57) 175.32,87.42 172.05,87.42 166.59,92.88 156.65,92.88 154.66,90.9 147.45,90.9 145.87,89.32 145.35,89.32 144.63,90.04 142.09,90.04 139.63,92.5 v1(139.63,93.85)
  BOTTOM w0.508: PR104.2 139.15,101.02 v1(139.15,100.38)
+3.3V_ALW_DSW: length 272.5
  TOP w0.508: v1(237.34,49.1) 235.69,49.1 233.87,47.27 232.75,47.27 232.11,46.63 230.69,46.63 230.16,46.11 229.17,46.11 228.1,45.03 225.91,45.03 225.27,44.39 212,44.39 v1(210.8,45.59) ; RC323.2 141.69,35.63 v1(141.41,35.35) v2(139.87,35.35) 138.8,35.35 134.98,39.17 134.98,40.1 135.26,40.38 135.26,42.26 v1(134.74,42.78) 135.1,43.15 RC72.2 ; RC243.2 167.06,47.18 ; 167.06,47.18 RC67.2 166.4,47.42 166.04,47.77 v1(166.04,47.93) ; 167.06,47.18 167.11,47.13 167.11,45.36 168.15,44.32 187.1,44.32 v1(187.68,44.9) ; v1(245.67,44.37) RC440.1 247.17,44.37 RC439.1
  IN2 w0.508: v1(166.04,47.93) 166.04,47.44 165.16,46.55 165.16,45.39 163.91,44.14 161.37,44.14 157.44,40.2 149.89,40.2 147.63,42.46 142.55,42.46 140.14,40.05 140.14,37.77 141.41,36.5 v1(141.41,35.35)
  IN3 w0.508: v1(118.41,95.7) 120.55,95.7 121.77,94.48 150.68,94.48 154.13,91.03 154.13,88.24 150.81,84.92 150.81,82.38 150.24,81.81 150.24,79.13 158.47,70.9 158.47,67.41 157.53,66.47 156.21,66.47 155.25,65.5 155.25,63.93 154.84,63.52 154.84,60.65 154.17,59.98 v1(152.18,59.98) ; v1(202.19,45.51) 199.89,43.21 194.56,43.21 192.87,44.9 v1(187.68,44.9) ; v1(96.15,93.21) 96.15,93.51 99.75,97.11 99.75,101.39 99.98,101.62 99.98,102.54 100.85,103.41 102.32,103.41 104.36,105.46 108.19,105.46 v1(111.23,102.42)
  IN4 w0.508: v1(245.67,44.37) 245.67,45.08 v1(243.9,46.86) ; 143.54,55.86 145.37,55.86 146.74,57.24 146.74,58.09 147.43,58.77 147.98,58.77 149.18,59.98 150.23,59.98 150.59,59.62 151.82,59.62 v1(152.18,59.98)
  BOTTOM w0.254: UC1.AJ17 131.17,59.04 v1(130.85,59.36)
  BOTTOM w0.508: v1(111.23,102.42) 111.82,101.83 111.82,98.27 111.21,97.66 111.21,96.08 111.89,95.4 118.1,95.4 v1(118.41,95.7) ; v1(210.8,45.59) 202.26,45.59 v1(202.19,45.51) ; v1(243.9,46.86) 239.17,46.86 237.34,48.69 v1(237.34,49.1) ; RC241.2 v1(96.15,93.21)
  vias: v1(130.79,61.93) v1(143.17,56.48) v1(143.81,56.49)
+3.3V_ALW_DSW_R: length 4.2
  TOP w0.102: v2(246.75,46.3) 246.75,45.7 RC439.2
  TOP w0.508: RC439.2 247.37,45.26 248.64,46.53 QC7.1
+3.3V_ALW_PCH: length 457.4
  TOP w0.254: RC235.1 135.19,64.52 RC23.2 ; v1(181.16,34.79) 159.59,34.79 158.98,34.18 137.58,34.18 RC187.2
  TOP w0.381: v1(240.14,39.76) 240.14,39.7 240.57,39.26 241.95,39.26 244.53,41.85 244.53,43.45 245.09,44 245.09,44.6 245.77,45.28 RC440.2 ; RC344.2 165.23,47.46 v1(165.23,47.93) ; v1(160.15,54.99) 160.16,55 UC7.5 ; v1(131.09,57.58) 130.76,57.91 CC223.1 131.51,58.17 CC224.1
  TOP w0.406: RZ69.1 v1(162.41,64.37)
  TOP w0.508: v1(150.19,83.41) 150.19,82.6 149.69,82.09 147.55,82.09 147.32,81.86 RC346.2 RC288.2 144.67,81.86 v1(143.94,81.13) ; v1(134.45,48.83) 134.88,49.26 134.88,50.97 134.57,51.27 RC387.2 ; v1(135.44,89.84) 134.17,89.84 132.87,91.13 132.87,93.47 132.36,93.98 RC330.2 RC331.2 130.8,95.06 131.27,95.53 131.27,98.07 129.47,99.87 126.09,99.87 124.31,101.65 v3(117.87,101.65) 115.5,101.65 v1(114.66,102.49)
  IN1 w0.254: v1(181.16,34.79) 183.2,34.79 187.67,30.32 194.29,30.32 196.63,27.99 197.21,27.99 198.1,27.1 199.67,27.1 200.97,25.8 201.76,25.8 202.72,24.84 202.72,24.13 202.73,24.12 202.73,24.1 203.38,23.45 203.4,23.45 203.43,23.41 205.82,23.41 206.53,22.7 206.53,22.17 207.67,21.03 207.67,19.63 v1(209.38,17.93)
  IN1 w0.508: v1(87.05,100.55) 87.51,100.55 88.8,101.84 90.34,101.84 91.39,102.89 102.9,102.89 103.31,103.3 104.59,103.3 105.6,102.28 108.59,102.28 109.35,103.04 114.11,103.04 v1(114.66,102.49)
  IN2 w0.508: v1(147.77,64.21) 147.96,64.21 148.47,64.72 148.47,66.46 149.94,67.94 v1(149.94,67.97) 149.94,69.04 146.12,72.87 146.12,75.72 150.19,79.79 v1(150.19,83.41) 150.19,85.53 148.24,87.49 144.13,87.49 143.55,88.07 139.43,88.07 137.66,89.84 v1(135.44,89.84) ; v1(181.16,34.79) 178.39,34.79 175.49,37.69 175.49,40.35 179.46,44.31 179.46,46.36 179.37,46.44 179.37,48.17 180.89,49.69 180.89,53.57 179.06,55.41 176.75,55.41 176.05,56.1 v1(176.05,57.04) ; v1(157.4,47.48) 160.11,44.77 163.52,44.77 164.39,45.64 164.39,46.78 165.23,47.62 v1(165.23,47.93)
  IN3 w0.254: v1(181.16,34.79) 184.66,34.79 186.06,33.4 204.62,33.4 205.97,32.05 209.57,32.05 210.01,31.61 210.66,31.61 211.48,30.78 214.88,30.78 215.1,30.55 216.97,30.55 218.62,32.2 220.65,32.2 221.51,33.07 225.14,33.07 226,33.92 228.59,33.92 229.02,34.35 232.57,34.35 233.49,35.28 234.84,35.28 235.74,36.18 236.44,36.18 237.52,37.26 238.41,37.26 239.64,38.49 239.64,39 240.14,39.5 v1(240.14,39.76)
  IN3 w0.508: v1(157.59,52.9) 157.83,52.9 159.91,54.99 v1(160.15,54.99) ; v1(154.72,66.36) 153.98,67.1 150.8,67.1 v1(149.94,67.97)
  IN4 w0.381: v1(240.14,39.76) 236.28,43.62 236.28,46.02 237.67,47.42 238.94,47.42 239.83,48.31 239.83,48.69 241.04,49.89 241.04,51.16 241.99,52.12 243.44,52.12 243.77,52.45 244.71,52.45 247.93,55.67 249.23,55.67 253.04,59.48 253.04,62.78 255.36,65.11 260.45,65.11 260.73,65.39 263.69,65.39 264.6,66.29 264.6,66.98 266.09,68.47 278.34,68.47 279.38,69.52 279.38,84.55 288.99,94.17 v1(289.49,94.17)
  BOTTOM w0.254: v1(129.51,64.46) 129.71,64.26 129.87,64.09 UC1.V19 ; UC1.AK17 131.17,57.67 v1(131.09,57.58) ; UC1.AJ21 128.21,59.36 v1(128.21,59.38)
  BOTTOM w0.305: JAPS1.1 214.7,15 216.46,16.76 216.46,17.43 216.15,17.75 213.02,17.75 212.7,17.43 209.87,17.43 v1(209.38,17.93)
  BOTTOM w0.381: v1(153.65,64.99) 153.33,64.99 RC348.2 RC347.2
  BOTTOM w0.508: v1(159.64,66.99) 159.58,67.05 RC555.2 ; v1(87.05,100.55) 87.05,96.39 86.21,95.55 86.21,94.56 85.01,93.36 85.01,92.64 86.69,90.95 89.26,90.95 90.17,91.87 RC133.2 ; RC17.2 149.42,66.4 RC15.2 ; v1(149.94,67.97) 149.97,67.93 149.97,67.86 150.36,67.47 RC371.2 RC15.2 ; v1(151.19,60.42) 151.45,60.16 RC283.2 ; v1(289.49,94.17) RC222.2 ; RC400.2 154.68,66.4 v1(154.72,66.36) 154.91,66.56 RC553.2 ; RC15.2 RC25.2
  vias: v1(156.32,53.62) v1(156.77,47.48) v1(175.43,57.06)
+3.3V_ALW_PCH_UZ3: length 1.9
  TOP w0.102: PJP38.1 v2(176.5,58.38)
+3.3V_ALW_UE1: length 21.9
  TOP w0.203: UE1.M9 265.98,45.69 v1(265.98,45.69) ; UE1.K2 259.8,46.93 259.42,46.55 258.99,46.55 258.02,45.58 257.66,45.58 257.59,45.65 257.01,45.65 v1(256.93,45.56)
  TOP w0.254: UE1.B7 264.01,53.33 263.62,53.73 263.62,55.56 ; UE1.H1 257.86,48.53 257.25,47.93 256.54,47.93 CE15.1 ; v1(264.41,49.73) 264.8,49.33 UE1.G8
  TOP w0.356: v1(256.98,47.42) 256.82,47.42 CE15.1
  TOP w0.381: 263.62,55.56 263.45,55.73 CE14.1 CE13.1 v1(262.74,55.83) ; v1(256.93,45.56) CE23.1
  BOTTOM w0.508: RE314.2 251.26,50.82 251.39,50.69 254.08,50.69 256.98,47.8 v1(256.98,47.42)
  vias: v1(266.5,60.5) v2(265.92,60)
+3.3V_ALW_UZ12: length 0.6
  BOTTOM w0.102: v1(154.39,57.48) 154.39,57.69 v2(154.14,57.93)
  vias: v1(154.39,56.89) v1(164.44,52.41) v1(165,52.65)
+3.3V_ALWP: length 19.8
  TOP w0.508: v3(130.07,103.68) PC106.1
  IN1 w0.254: v1(142.17,104.19) 140.39,102.41 129.85,102.41 129.21,103.04 v1(129.21,104.82)
  BOTTOM w0.254: PR108.2 141.41,103.42 v1(142.17,104.19) 142.48,104.5 PU100.14
  vias: v1(129.21,109.01) v1(129.21,108.38) v1(129.21,107.11) v1(129.21,106.47) v1(129.21,105.46)
+3.3V_CAM: length 3.5
  TOP w0.102: CZ1.1 v3(65.63,101.89)
  BOTTOM w0.254: JEDP1.11 67.6,100.35 67.31,100.63 v1(66.35,100.63)
+3.3V_CPS: length 8.1
  TOP w0.203: 25.23,79.5 25.66,79.07 26.2,79.07 26.4,78.86 UT9.28 ; UT9.6 v1(28.4,71.22)
  TOP w0.254: v1(31.55,80.39) CT120.1 31.02,79.83 v2(30.74,79.55) 30.47,79.28 30.47,77.94 30.22,77.68 UT9.20
  TOP w0.381: v1(23.3,70.28) 23.88,69.69 RT246.1
  vias: v1(23.36,79.88) v1(23.97,79.85) v1(24.55,79.85)
+3.3V_CPS_R1: length 4.6
  TOP w0.102: RT246.2 24.29,71.04 v2(24.76,71.51)
  TOP w0.203: UT9.1 26.4,72.12 25.46,71.17 CT122.1
  TOP w0.381: RT246.2 24.57,70.61 24.74,70.78 25.28,70.78 CT122.1
+3.3V_EC_PLL: length 14.4
  TOP w0.254: CE18.1 256.67,49.6 257.03,49.96 257.99,49.96 258.12,49.83 v1(258.12,49.7) 258.25,49.83 258.88,49.83 259.18,50.13 UE1.F1
  BOTTOM w0.432: CE17.1 250.37,52.29 250.55,52.12 RE314.1 250.68,51.61 v2(251.9,51.61) 252.23,51.94 253.72,51.94 254.23,51.43 255.38,51.43 255.71,51.1 255.71,50.08 256.93,48.87 257.71,48.87 258.12,49.27 v1(258.12,49.7)
+3.3V_HDD: length 16.5
  TOP w0.381: v1(228.85,23.94) 228.85,23.81 228.95,23.71 228.95,23.63 RN12.1 ; v1(229.9,19.73) RN10.2 ; RN16.1 v1(230.05,17.06)
  TOP w0.508: v1(223.45,23.67) 223.36,23.67 RN14.1 ; RN18.1 226.24,14.91 226.05,14.72 v1(226.05,14.49) ; RN6.1 RN8.2 220.26,22.26 v1(219.79,21.79) ; RN10.2 RN20.1
  BOTTOM w0.508: v1(226.05,14.49) 226.05,15.11 227.16,16.21 229.2,16.21 v1(230.05,17.06) ; v1(223.45,23.67) 222.43,23.67 220.55,21.79 v1(219.79,21.79)
  vias: v1(220.86,18.18) v1(228.19,24.02) v1(231.99,12.36) v1(232.44,11.96) v1(249.03,8.78) v1(249.62,8.78) v2(247.51,10.55)
+3.3V_HDD_M2: length 4
  TOP w0.127: v3(276.48,2.49) 277.09,3.09 v1(277.09,3.55) ; v3(276.47,4.31) 276.65,4.14 v1(277.09,4.14) ; v3(277.39,6.03) 277.39,5.6 v1(277.09,5.3)
  BOTTOM w0.508: RN37.1 255.36,10.51 v1(255.62,10.77)
  vias: v1(247.45,11.88) v1(248.04,11.88) v1(249.27,13.08) v1(249.27,12.49) v1(249.27,11.91) v1(259.97,3.04) v1(260.56,3.04) v1(261.14,3.04) v1(261.73,3.04) v1(262.31,3.04) v1(277.09,4.72)
+3.3V_LAN: length 308.5
  TOP w0.127: v1(271.64,69.07) v3(272.8,69.07)
  TOP w0.356: v1(281.53,70.77) 281.49,70.74 CL19.1
  TOP w0.381: RL70.2 142.24,37.13 v1(142.31,37.19)
  TOP w0.406: v1(271.33,64.18) 271.33,63.78 271.56,63.55 CL15.1 UL2.5
  TOP w0.508: RL1.2 RL2.2 v1(250.37,68.69) ; RL6.2 261.36,66.64 v1(260.88,66.16) 260.41,66.64 RL4.2 ; v1(279.52,86.28) CL18.1 281.91,86.28 JLOM1.9 ; RL5.2 264.53,64.74 RL8.2 ; RL30.1 v1(271.64,69.07) ; v1(175.95,91.51) 175.09,92.38 v1(168.97,92.38) ; RL29.1 v1(267.64,64.05)
  IN2 w0.508: v1(161.69,71.33) 164.95,71.33 168.4,67.87 168.4,66.11 168.37,66.08 168.37,63.43 167.94,63 167.94,61.65 168.37,61.22 168.37,60.39 169.63,59.13 169.63,58.24 173.73,54.14 177.19,54.14 177.7,53.63 177.7,51.3 177.45,51.05 177.45,47.28 172.65,42.48 172.65,37.4 169.1,33.85 144.96,33.85 142.31,36.51 v1(142.31,37.19)
  IN3 w0.254: v1(155.88,65.22) 156.62,65.96 157.74,65.96 158.98,67.2 158.98,68.26 161.69,70.97 v1(161.69,71.33)
  IN3 w0.508: v1(250.37,68.69) 252.44,68.69 253.04,68.09 253.04,60.5 ; v1(281.53,70.77) 281.53,79.26 279.52,81.26 v1(279.52,86.28) ; v1(281.53,70.77) 282.68,70.77 283.05,71.14 JLOM1.12 ; v1(281.53,70.77) 279.68,68.93 275.09,68.93 274.38,69.64 272.22,69.64 v1(271.64,69.07) 271.64,67.17 272.6,66.21 272.6,65.1 271.68,64.18 v1(271.33,64.18) 271.2,64.05 v1(267.64,64.05) 267.62,64.05 266.73,64.94 v1(265.21,64.94) ; v1(175.95,91.51) 176.56,91.51 177.09,90.98 177.09,90.14 179.76,87.47 179.76,77.03 186.87,69.92 186.87,64.44 188.31,63 188.31,60.51 191.89,56.93 191.89,56.36 200.32,47.93 203.38,47.93 206.49,44.81 209.31,44.81 209.76,44.37 224.34,44.37 224.85,44.88 227.77,44.88 228.53,45.64 229.67,45.64 230.05,46.02 233.1,46.02 233.35,46.27 ; v1(260.88,66.16) 262.18,66.16 262.77,65.58 v1(265.23,65.58)
  IN3 w1.016: 254.08,61.08 254.08,63.19 255.22,64.33 259.36,64.33 260.02,64.99 260.02,65.45 260.74,66.16 v1(260.88,66.16)
  BOTTOM w0.254: RC20.2 154.98,65.41 154.98,64.11 RC19.2 155.88,64.47 v1(155.88,65.22)
  BOTTOM w0.508: v1(161.69,71.33) 160.69,71.33 157.66,74.35 157.66,77.39 157.43,77.62 157.43,86.95 158.93,88.44 162.87,88.44 164.9,90.47 167.29,90.47 168.97,92.15 v1(168.97,92.38)
  vias: v1(234.09,45.39) v1(234.67,45.39)
+3.3V_LAN_OUT: length 9.6
  TOP w0.203: UL1.5 258.91,72.72 v1(258.75,72.56) 259,72.32 UL1.4 ; CL7.1 252.95,73.92 UL1.29 ; UL1.19 256.44,77.24 v1(256.44,77.24) ; UL1.15 v1(258.04,77.24)
  TOP w0.381: CL7.1 252.4,74.6 252.66,74.85 252.66,75.74 v1(253.04,76.12)
  BOTTOM w0.102: v1(258.04,77.24) v2(259.01,77.24)
  BOTTOM w0.508: v1(258.04,77.24) 258.07,77.26 CL30.1 ; CL29.1 256.73,77.52 v1(256.44,77.24)
  vias: v1(263.71,67.36) v1(263.71,66.77) v1(263.71,66.19)
+3.3V_LAN_UZ2: length 1.8
  TOP w0.127: v2(232.72,45.54) 232.97,45.28 232.97,45.11 233.09,44.99 233.09,44.52 233.56,44.05
+3.3V_M_TPM: length 26.1
  TOP w0.508: v1(164.62,60.35) 165.08,60.8 CZ59.1 ; CZ60.1 156.57,64.56 RZ366.2 156.79,64.78 v1(156.79,65.38) ; RZ368.2 156.9,53.95 RZ369.2
  IN1 w0.508: v1(156.79,65.38) 156.79,64.58 158.06,63.31 159.76,63.31 162.72,60.35 v1(164.62,60.35)
  IN3 w0.508: v1(157.59,54.23) 158.2,54.23 160.46,56.49 161.6,56.49 161.83,56.71 163.33,56.71 164.62,58.01 v1(164.62,60.35)
  BOTTOM w0.127: v1(156.79,65.38) v2(156.79,64.84)
+3.3V_MMI_AUX: length 2.3
  BOTTOM w0.203: UR1.27 81.92,94.35 82.07,94.2 82.78,94.2 83.04,93.95 v1(83.57,93.95)
  vias: v1(84.15,94.1) v2(84.03,94.65)
+3.3V_MMI_IN: length 2.5
  BOTTOM w0.203: 76.47,92.93 76.58,92.93 76.8,93.15 UR1.11
  BOTTOM w0.356: CR4.1 75.24,92.63 CR3.1
  BOTTOM w0.381: CR3.1 76.17,92.63 76.47,92.93
  vias: v1(74.65,90.32) v1(75.32,89.56) v2(74.71,89.29)
+3.3V_PDA_VOUT: length 3.8
  TOP w0.076: 25.94,64.5 25.94,64.5 25.94,64.06 UT5.H2
  TOP w0.152: v2(24.66,65.96) 25.18,65.44 25.18,65.34 25.94,64.57 25.94,64.5
  TOP w0.508: CT83.1 24.4,66.22 v2(24.66,65.96)
+3.3V_PGPPB: length 48.2
  TOP w0.254: v1(132.14,59.42) 132.01,59.56 131.33,59.56 131.07,59.82 130.48,59.82 130.22,59.56 130.22,59.55 130.22,59.55 CC265.1
  TOP w0.381: v1(170.02,59.61) v2(170.02,58.68) 170.02,58.3 170.65,57.67 RC305.2
  IN3 w0.508: v1(170.02,59.61) 168.18,59.61 167.26,58.7 167.26,57.05 165.51,55.29 162.59,55.29 160.46,53.16 158.98,53.16 158.46,52.63 v1(158.46,52.41)
  IN4 w0.508: v1(132.14,59.42) 131.55,58.83 131.55,58.42 ; 136.07,58.09 136.96,58.09 140.01,55.04 145.47,55.04 146.87,56.43 148.69,56.43 150.58,54.55 154.1,54.55 156.35,52.29 158.34,52.29 v1(158.46,52.41)
  BOTTOM w0.254: v1(132.14,59.42) 132.14,59.5 UC1.AG15
+3.3V_PGPPC: length 89.4
  TOP w0.127: v2(131.19,62.28) 131.47,62.56 v1(131.47,62.76)
  TOP w0.508: RC306.2 170.82,58.7 v1(170.82,59.94)
  IN2 w0.508: v1(170.82,59.94) 170.82,58.83 171.18,58.47 173.71,58.47 174.35,57.83 174.35,55.58 175.16,54.77 177.51,54.77 178.34,53.94 178.34,51.04 178.08,50.79 178.08,46.63 173.42,41.97 173.42,36.38 169.98,32.94 141.53,32.94 138.26,36.21 138.26,38.37 137.11,39.52 v1(135.82,39.52) ; 129.6,49.64 129.6,47.99 133.28,44.31 133.28,42.06 v1(134.65,40.69)
  BOTTOM w0.508: v1(134.65,40.69) v1(135.82,39.52)
  vias: v1(132.18,62.76)
+3.3V_PGPPD: length 19.9
  IN3 w0.508: v1(133.2,62.99) 133.2,62.53 133.53,62.2 133.53,62.02 134.14,61.41 135.42,61.41 135.44,61.43 137.56,61.43 138.04,60.94 138.83,60.94 140.39,62.5 142.49,62.5 143.23,61.75 147.95,61.75 v1(149.08,60.62)
  BOTTOM w0.127: v2(148.69,60.27) 149.03,60.62 v1(149.08,60.62)
  BOTTOM w0.254: v1(133.2,62.99) 132.67,62.99 UC1.Y15
+3.3V_PGPPE: length 0.6
  BOTTOM w0.127: v1(147.88,60.88) v2(147.3,60.88)
  vias: v1(130.88,64.44) v1(131.51,64.44) v1(148.18,60.37)
+3.3V_RTC_LDO: length 103.6
  TOP w0.508: v1(138.49,100.38) v3(138.49,100.94) ; PD3.3 v1(48.8,80.92)
  IN1 w0.508: v1(48.8,80.92) 49.33,81.45 49.33,83.23 50.98,84.88 52.25,84.88 53.9,86.53 54.67,86.53 57.97,89.84 61.65,89.84 65.46,93.65 67.34,93.65 69.45,95.75 70.85,95.75 71.74,96.64 72.47,96.64 72.83,97 72.83,97.84 73.41,98.42 76.84,98.42 79.1,100.68 84.78,100.68 85.56,99.9 87.76,99.9 89.06,101.21 91.92,101.21 92.28,101.56 102.01,101.56 102.53,102.08 104.91,102.08 105.34,101.65 115.54,101.65 116.81,100.38 v1(138.49,100.38)
  BOTTOM w0.508: v1(138.49,100.38) 138.23,100.63 PR105.2
+3.3V_RUN: length 521.7
  TOP w0.203: UV7.30 171.9,84.97 171.94,84.93 172.37,84.93 CV82.1 ; 161.42,82.57 UV7.57 ; CV85.1 163.82,79.25 164.39,79.82 UV7.5 ; CV106.1 279.96,50.21 280.36,49.81 UV6.26 ; 171.84,81.01 171.48,81.37 UV7.21 ; CV100.1 287.79,49.07 286.8,49.07 286.45,49.41 UV6.14 ; UV7.51 162.1,85.37
  TOP w0.254: UC8.14 102.24,99.61 102.09,99.46 CC30.1 ; CN20.1 247.81,26.77 RN50.1 ; CN20.1 246.58,26.77 246.12,26.31 v1(246.12,25.97) ; CN20.1 246.74,26.44 246.74,25.98 246.6,25.84 UN4.24 ; 163.28,73.94 163.28,74.57 162.09,75.76 158.86,75.76 157.36,74.27 RC177.2 ; v1(224.01,26.84) 224.01,28.67 223.65,29.03 223.65,30.02 222.23,31.44 v1(222.23,31.7) 222.23,31.76 RN65.1 ; RC59.2 138.58,38.68 140.36,38.68 140.47,38.78 151.06,38.78 152.51,40.23 v1(152.51,41.53) 152.51,41.88 151.01,43.38 147.54,43.38 RC414.2 ; UN4.12 249.1,20.01 CN21.1 248.31,19.17 RN27.1
  TOP w0.305: RE67.2 246.13,50.77 245.71,50.35 245.71,50.15 245.52,49.96 244.91,49.96 244.54,50.33 244.54,51.89 244.21,52.22 241.79,52.22 239.2,49.63 v1(239.2,48.56)
  TOP w0.356: QC2.2 158.01,66.68 158.34,67.01 158.34,68.22 157.97,68.59 RC319.2 ; v1(100.97,100) 100.94,99.97 CC30.1 ; CV85.1 v1(163.28,78.89)
  TOP w0.381: RN51.1 251.77,20.21 v1(251.31,20.67) ; v1(61.52,64.18) 61.7,64 61.89,64 PR612.1 ; v1(234.37,28.75) 234.55,28.57 RN63.1 RN64.1 ; 154.72,67.45 155.49,66.68 QC2.5 ; CA7.1 69.14,100.38 v1(69.52,100.76) ; RN71.1 242.37,22.27 v1(242.78,21.87) ; v1(236.66,27.61) 236.66,27.43 236.02,26.79 RN70.1 ; RN55.1 231.69,18.45 231.45,18.21 v1(231.45,17.95) ; 161.42,82.57 161.41,82.58 160.75,82.58 160.71,82.55 CV84.1 160.11,82.04 v1(160.15,82) ; LV30.1 284.03,53.64 v1(284.59,54.2) ; RN171.1 233.18,31.29 RN44.1 231.53,30.98 230.93,30.39 v1(230.48,30.39) ; 244.8,16.84 243.77,17.88 243.77,18.11 243.7,18.17 243.7,18.65 243.77,18.71 RN26.1 ; v1(279.91,49.4) CV106.1 ; v1(279.38,47.93) 278.92,47.47 RV106.2 277.97,47.29 RV107.2
  TOP w0.406: CV100.1 287.96,48.76 287.49,48.29 v1(287.27,48.29)
  TOP w0.508: RD26.1 198.06,23.05 197.67,22.66 v1(197.67,22.6) ; LV14.1 v1(280.09,43.11) ; RV124.1 289.64,46.02 v1(289.87,46.25) ; RC402.2 RC403.2 130.61,90.71 129.98,91.35 v1(129.98,91.64) ; v1(157.61,53.59) 158.02,53.59 RZ89.1 ; 171.84,81.01 172.26,80.59 CV83.1 v1(172.86,81.2) ; v1(70.49,109.42) 70.72,109.65 72.14,109.65 73.74,111.25 RV326.1 ; RN56.1 RN58.1 v1(234.36,16.89) ; RN43.1 RN42.1 227.89,28.62 228.12,28.39 229.01,28.39 229.29,28.67 v1(229.29,29) ; v1(154.14,73.67) 154.14,73.88 154.53,74.27 RC176.2 ; v1(242.78,21.87) 242.88,21.76 RN25.1 ; RD24.1 177.2,12.27 177.59,11.89 177.59,10.87 v1(177.26,10.54) ; RV95.2 RV87.2 159.24,80.46 158.5,80.46 v1(158.47,80.44) ; RZ365.2 158.28,64.77 v1(158.31,64.8) ; v1(157.77,67.98) 157.77,68.52 RC319.2 ; v1(140.76,88.97) 143.81,85.92 RC272.2 143.81,82.1 RC345.2 ; QV5.2 16.77,53.64 RV20.2 17,54.66 17.31,54.34 v1(17.9,54.34) 18.28,54.34 18.6,54.66 19.11,54.66 19.66,54.1 RV18.1 ; RV72.2 v1(175.77,86.28) ; v1(62.92,96.44) 62.92,95.96 63.4,95.47 QZ1.3 ; RN69.1 238.32,17.4 v1(238.32,16.84) 238.48,16.67 RN4.1 ; v1(168.05,76.12) 168.25,75.92 RV91.2 ; RV8.2 61.62,96.22 v1(60.99,96.85) ; RN226.1 v1(219.61,32.69) RN228.1 ; v1(49.57,14.18) 50.05,14.66 RD19.2 ; v1(160.15,87.8) CV81.1 160.84,87.17 162.1,85.91 162.1,85.37 ; v1(95.75,10.34) 95.75,10.72 96.08,11.05 RD8.1 ; CV82.1 172.15,85.81 v1(172.14,85.81) ; v1(262.69,37.94) 262.18,38.45 RE547.2 ; RV93.2 161.45,77.72 v1(161.45,77.34) ; v1(17.99,50.18) 17.47,49.65 16.75,49.65 16.39,50.01 RV19.2 ; RV620.1 v1(289.87,47.8) ; RV89.2 164.09,75.92 v1(164.01,75.99) ; RV70.2 v1(176.38,83.61) ; v1(117.83,94.48) 117.83,92.07 v3(121.59,88.31) ; RC50.2 138.43,39.21
  IN1 w0.508: v1(69.52,100.76) 69.52,100.22 67.9,98.6 66.48,98.6 64.32,96.44 v1(62.92,96.44) 61.4,96.44 v1(60.99,96.85)
  IN2 w0.508: v1(49.57,14.18) 49.57,14.08 52.4,11.25 94.84,11.25 v1(95.75,10.34) 95.75,10.66 96.37,11.28 117.13,11.28 117.95,12.09 118.78,12.09 v1(119.45,11.43) 121.16,11.43 122.41,10.18 126.37,10.18 128.55,12.37 175.43,12.37 v1(177.26,10.54) 178.5,11.79 199.05,11.79 201.77,14.51 201.77,17.74 202.75,18.72 ; v1(152.51,41.53) 152.51,44.36 154.84,46.7 154.84,48.08 156.59,49.83 v1(156.59,50.15)
  IN3 w0.381: v1(61.52,64.18) 61.52,64.56 60.99,65.1 60.99,65.86 59.11,67.74 59.11,70.66 59.62,71.17 59.62,73.94 61.09,75.41 61.09,76.56 60.63,77.01 60.63,79.1 62.03,80.5 62.03,82.62 63.73,84.32 64.83,84.32
  IN3 w0.508: v1(164.01,75.99) 162.87,74.85 v1(162.87,72.86) ; v1(107.29,104.8) 104.6,104.8 102.37,102.56 102.37,101.75 100.97,100.35 v1(100.97,100) ; v1(197.24,26.64) 196.68,26.08 196.68,23.59 v1(197.67,22.6) ; v1(163.28,78.89) 162.26,78.89 161.44,78.07 161.44,77.35 v1(161.45,77.34)
  IN4 w0.305: v1(239.2,48.56) 238.82,48.94 238.05,48.94 235.77,46.66 235.77,43.1 237.06,41.8 237.06,39.3 237.71,38.65 239.55,38.65 239.81,38.4 241.51,38.4 v1(242.12,37.79)
  IN4 w0.381: v1(245.04,9.38) 245.1,9.38 245.48,9.76 250.13,9.76 250.35,9.55 251.21,9.55 251.62,9.95 251.62,11.15
  IN4 w0.508: v1(170.41,74.06) 168.35,76.12 v1(168.05,76.12) ; v1(160.15,87.8) 168.66,87.8 170.65,85.81 v1(172.14,85.81) 173.63,85.81 174.1,86.28 v1(175.77,86.28) ; v1(107.29,104.8) 108.59,103.5 108.59,98.9 109.12,98.37 110.27,98.37 111.05,97.58 114.74,97.58 v1(117.83,94.48) ; v1(175.77,86.28) 175.77,84.22 v1(176.38,83.61) 175.28,83.61 v1(172.86,81.2) ; v1(175.77,86.28) 178.46,88.97 178.46,90.76 v1(179.67,91.97) ; v1(253.67,12.63) 253.2,12.16 252.63,12.16 251.62,11.15 249.15,11.15 248.64,11.66 248.64,12.14 246.68,14.11
  BOTTOM w0.254: v1(69.52,100.76) 69.43,100.85 JEDP1.10 ; QV3.5 23.04,50.86 23.35,51.16 23.35,51.75 22.98,52.12 22.66,52.12 v1(20.5,54.28)
  BOTTOM w0.305: LGA1.10 244.76,9.73 245.04,9.44 v1(245.04,9.38) 245.26,9.6 LGA1.9
  BOTTOM w0.381: QV3.2 20.36,50.86 19.66,50.15 18.02,50.15 v1(17.99,50.18) ; UC12.5 146.46,88.31 RC291.2 146.3,88.89 v1(146.59,89.18) 146.87,89.45 RC225.2
  BOTTOM w0.508: v1(82.4,96.36) 82.4,96.91 82.53,97.04 82.53,98.07 RC137.2 ; v1(179.67,91.97) RE51.1 RE48.1 ; 229.29,29.66 226.51,29.66 224.01,27.16 v1(224.01,26.84) ; 229.29,29.66 229.98,29.66 230.48,30.17 v1(230.48,30.39) ; 229.29,29.66 v1(229.29,29) ; v1(203.26,19.48) 203.26,19 203.88,18.37 204.94,18.37 205.56,17.75 205.56,16.99 RD22.1 205.58,16.98 206.45,16.98 RD20.1 ; v1(160.15,87.8) v1(160.15,82) ; RZ362.1 158.68,67.28 157.98,67.98 v1(157.77,67.98) ; v1(287.27,48.29) 286.82,47.85 RV622.1 ; RA58.1 253.67,13.15 v1(253.67,12.63)
  vias: v1(19.42,76.82) v1(20.06,76.82) v1(65.21,90.85) v1(65.84,90.85) v1(69.85,109.42) v1(85.65,93.11) v1(86.26,93.11) v1(151.88,65.39) v1(152.46,58.01) v1(153.01,58.3) v1(153.03,57.7) v1(153.37,60.66) v1(153.95,60.68) v1(156.47,85.14) v1(156.47,84.31) v1(156.9,69.94) v1(160.43,73.41) v1(160.42,72.82) v1(161.07,73.41) v1(161.07,72.83) v1(161.65,73.41) v1(161.65,72.82) v1(162.26,73.41) v1(162.25,72.83) v1(197.24,27.28) v1(232.25,25) v1(240.42,18.41) v1(242.75,37.79) v1(245,15.01) v1(245,14.41) v1(245.58,15.01) v1(245.58,14.41) v1(246.17,15.01) v1(246.18,14.4) v1(249.53,27.73) v1(249.53,27.12)
+3.3V_RUN_AUDIO: length 52.1
  TOP w0.381: LA12.1 260.24,14.4 259.1,15.54 258.29,15.54 257.79,15.04 v1(257.79,14.95)
  TOP w0.508: v1(255.07,25.88) 255.07,26.67 RA59.1 255.38,27.34 255.76,27.72 255.76,29.59 255.35,29.99 254.69,29.99 254.36,29.66 252.73,29.66 252.35,30.04 251.13,30.04 250.25,30.93 250.25,31.16 v3(250.19,31.21) 249.38,32.03 247.36,32.03 247.3,31.96 246.45,31.96 245.54,32.86 244.48,32.86 243.9,33.45 241.86,33.45 241.61,33.7
  IN3 w0.508: v1(257.79,14.95) 257.79,20.57 255.07,23.29 v1(255.07,25.88)
  BOTTOM w0.381: RA61.1 265.38,25.32 263.05,22.98 262.36,22.98 260.4,21.02 259.86,21.02 259.2,21.69 259.2,22.13 258.73,22.6 258.3,22.6 257.23,23.67 257.23,24.56 256.72,25.07 255.88,25.07 v1(255.07,25.88)
+3.3V_RUN_AUDIO_DVDD: length 14.6
  TOP w0.102: v2(254.44,26.66) 253.99,26.66 253.52,26.19 253.52,24.91 254.13,24.3 LA14.2
  TOP w0.203: UA1.3 261.21,21.45 260.84,21.08 CA10.1
  TOP w0.381: CA10.1 260.71,21.05 258.78,21.05 258.53,21.31 256.82,21.31 256.42,21.71 CA70.1 256.21,21.89 255.73,22.37 255.72,22.37 255.7,22.39 254.51,22.39 CA61.1
  TOP w0.508: CA61.1 254.31,24.18 LA14.2 254.87,24.3 RA18.1
+3.3V_RUN_AUDIO_IO: length 5.4
  TOP w0.127: v2(261.99,13.43) 262.23,13.67 LA12.2
  TOP w0.203: CA55.1 263.8,15.4 264.09,15.69 264.24,15.69 264.78,16.23 UA1.18
  TOP w0.381: CA55.1 263.8,14.99 263.33,14.52 CA56.1
  TOP w0.508: LA12.2 263.26,14.4 CA56.1
+3.3V_RUN_AUDIO_UZ5: length 1
  TOP w0.102: CZ128.1 245.25,34.34 v2(245.47,34.11)
+3.3V_RUN_CARD: length 14
  IN2 w1.016: 76.51,92.5 77.04,92.5 79.25,90.29 86.49,90.29 88.07,91.87
  BOTTOM w0.203: v1(76.46,93.48) 76.53,93.55 UR1.12
  vias: v1(75.88,93.3) v1(87.69,92.78) v1(88.27,92.79) v2(87.91,93.73)
+3.3V_RUN_DIMM1: length 2.4
  BOTTOM w0.305: JDIMM1.255 115.68,21.32 v1(114.95,22.05)
  vias: v1(113.54,21.52) v1(113.63,22.1) v1(114.31,22.1) v2(116.87,22.11)
+3.3V_RUN_DIMM2: length 0.7
  TOP w0.102: v2(195.62,18.44) 195.7,18.52 195.7,19.12
  vias: v1(197.5,21.18)
+3.3V_RUN_UT9: length 50.3
  TOP w0.381: RT247.2 21.7,71.88 v1(21.52,72.06) 21.52,72.49 RT143.2 ; LT11.1 22.5,81.35 21.9,80.74 ; v1(32.52,82.52) 32.69,82.34 34.26,82.34 34.67,81.93 34.67,80.81 34.4,80.54 RT411.1 ; 22.36,79.57 22.76,79.57 23.54,78.79 RT308.2
  TOP w0.508: RT131.2 v1(27.61,82.09) ; RT135.2 19.31,69.62 v1(19.23,69.54) ; RT141.2 v1(19.41,75.15)
  IN2 w0.508: v1(27.61,82.09) 27.61,81.76 28.15,81.23 30.05,81.23 30.41,81.58 32.44,81.58 33.08,80.95 33.08,79.02 v1(33.81,78.28) 33.23,78.28 32.11,77.16 32.11,73.53 31.4,72.82 v1(30.79,72.82)
  IN3 w0.508: v1(27.61,82.09) 27.61,81.71 27.11,81.2 23.04,81.2 v1(21.9,80.06)
  IN4 w0.508: v1(33.81,78.28) 33.11,78.98 33.11,81.92 v1(32.52,82.52)
  BOTTOM w0.381: RT139.2 RT145.2 33.25,76.93 33.74,77.42 33.74,78.2 v1(33.81,78.28)
  BOTTOM w0.508: RT137.2 v1(30.79,72.82) ; RT412.1 v1(32.52,82.52)
  BOTTOM w1.016: 13.52,67.67 14.47,67.67 14.85,67.29 16.5,67.29 18.41,69.2
  vias: v1(19.23,70.28) v1(21.26,80.06) v3(20.88,80.63)
+3.3V_RUN_UZ3:
  vias: v2(174.32,64.65)
+3.3V_SPI: length 75.2
  TOP w0.102: v1(168.33,58.8) v3(168.33,59.41)
  IN3 w0.254: v1(132.15,58.51) 132.15,57.44 132.47,57.12 132.47,55.69 132.45,55.67 132.45,53.51 132.14,53.2
  IN3 w0.508: v1(168.33,58.8) 168.33,57.22 165.77,54.66 163.03,54.66 160.14,51.76 v1(159.05,51.76) 159.05,50.48 157.22,48.65 155.01,48.65 v1(154.06,47.7) 154.02,47.74 152.77,47.74 151.19,46.15 147.78,46.15 144.42,49.51 136.15,49.51 135.96,49.7 135.13,49.7 133.37,51.47 132.53,51.47 132.01,51.98 132.01,53.07 132.14,53.2
  IN4 w0.508: v1(163.63,50.24) 163.25,50.24 162.51,50.97 159.84,50.97 v1(159.05,51.76) ; v1(170.03,60.24) 169.78,60.24 v1(168.33,58.8)
  BOTTOM w0.254: UC1.AJ16 131.82,58.94 132.15,58.62 v1(132.15,58.51)
  BOTTOM w0.305: JSPI1.15 172.97,63.36 172.97,61.83 RC41.2 172.91,61.78 172.06,60.93 171.05,60.93 170.36,60.24 v1(170.03,60.24)
  BOTTOM w0.381: UC6.8 155.61,48.71 155.23,48.33 CC10.1 154.06,48.03 v1(154.06,47.7) ; v1(159.05,51.76) 159.21,51.93 160.46,51.93 160.96,52.43 CC9.1 161.45,52.45 UC5.8
  BOTTOM w0.457: RC31.2 v1(163.63,50.24)
  BOTTOM w0.508: RC30.2 168.33,59.33 v1(168.33,58.8)
+3.3V_TBTA_FLASH: length 97.4
  TOP w0.203: UT5.G1 26.69,64.31 26.69,64.82 26.27,65.25 26.27,65.76 26.47,65.96 26.84,65.96 CT84.1
  TOP w0.508: v1(17.45,78.15) 17.76,77.85 RT407.1 17.45,77.26 16.97,76.78 16.97,75.84 17.33,75.48 RT405.1 ; v1(27.23,53.26) 27.44,53.46 RT98.2 ; v1(18.98,68.25) 19.05,68.32 RT406.1 20.53,68.32 21.04,67.81 RT95.2 ; v1(23.22,52.55) 23.09,52.55 22.38,53.26 RT76.2 ; RT378.2 RT379.2 v1(33.13,70.15) ; v1(29.66,66.23) 30.11,66.68 RT107.2 RT106.2 ; v1(26.94,67.08) 26.94,66.89 27.26,66.57 CT84.1 ; RT66.2 RT67.2 33.16,62.7 v1(33.2,62.66)
  IN1 w0.508: 33,61.94 33,57.68 28.91,53.59 27.56,53.59 v1(27.23,53.26) 26.84,53.65 26.12,53.65 25.02,52.55 v1(23.22,52.55)
  IN2 w0.508: v1(50.35,77.9) 48.95,77.9 47.55,76.5 47.55,72.69 v1(43.87,69.01) ; v1(17.45,78.15) 17.45,75.23 18.47,74.21 18.47,68.75 v1(18.98,68.25) 20.94,68.25 22.1,67.08 v1(26.94,67.08)
  IN4 w0.508: v1(26.94,67.08) 26.24,67.08 25.58,67.74 25.58,69.26 26.47,70.15 26.47,74.13 25.87,74.72 v1(25.87,78.39)
  BOTTOM w0.254: v1(25.87,78.39) 25.98,78.28 JDB1.1
  BOTTOM w0.381: RT52.1 56.58,70.62 RT53.1 56.93,71.34 56.34,71.93 54.59,71.93 54.23,71.57 RT51.1 53.25,71.27 50.99,73.53 50.99,75.41 51.13,75.55 51.13,76.23 v2(50.74,76.63) 50.35,77.02 v1(50.35,77.9)
  BOTTOM w0.508: UT6.8 CT70.1 45.42,69.54 44.89,69.01 v1(43.87,69.01) ; RT50.1 v1(43.87,68.25)
+3.3V_TP: length 6.6
  TOP w0.127: 198.98,25.92 v3(197.86,25.92)
  TOP w0.305: v1(206.38,26.49) 206.38,26.41 206.4,26.39 206.4,25.79 RZ21.1 ; RZ20.1 205.29,26.03 205.24,26.08 v1(205.24,26.67) ; JKBTP1.12 v1(204.65,17.61)
  TOP w0.508: v1(205.6,20.2) 205.44,20.37 RZ116.1 ; RZ18.1 203.23,24.05 v1(203.69,24.51) 204.17,24.03 RZ19.1 ; v1(206.56,20.2) 206.56,20.7 RZ117.1
  vias: v1(198.94,25.24) v1(199.52,25.24)
+3.3V_TSP:
  vias: v1(67.3,106.28) v1(67.76,106.77) v3(66.23,106.19)
+3.3V_VCCHDA: length 0.5
  BOTTOM w0.254: UC1.AJ19 129.87,59.02 v1(129.51,59.38)
+3.3V_VDD_DCIN: length 49.8
  TOP w0.102: v1(67.24,81.86) 67.24,81.33 v2(67.52,81.05)
  TOP w0.381: v1(67.24,81.86) 67.24,82.85 PR17.1
  TOP w0.508: v1(55.77,76.2) 56.87,75.1 58.37,75.1 59.44,76.17 59.44,76.47 PD1801.3 60.61,77.65 PR1208.1 ; PR1206.1 57.98,81.06 57.72,81.32 v1(56.03,81.32)
  IN2 w0.508: v1(67.24,81.86) 66.5,82.6 62.67,82.6 61.65,81.58 60.18,81.58 59.8,81.96 58.17,81.96 57.79,81.58 56.58,81.58 56.32,81.32 v1(56.03,81.32)
  BOTTOM w0.381: PC9.1 53.33,90.45 PU1.5
  BOTTOM w0.508: PC9.1 54.28,90.6 56.54,88.35 56.54,81.82 v1(56.03,81.32) 57.18,80.17 PC10.1 56.07,78 PU2.3 55.74,76.23 v1(55.77,76.2) ; PU1.5 52.49,90.13 52.02,89.66 49.92,89.66 48.82,88.57 48.82,87.8 49.14,87.48 49.86,87.48 PR27.2
+3.3V_VDD_PIC: length 62
  TOP w0.254: QT1.5 v1(37.07,64.74) QT1.2
  TOP w0.381: v1(34.45,73.43) 34.65,73.22 PR1226.1
  TOP w0.508: v1(50.79,48.59) 51.52,49.31 v2(51.52,49.62) PR1254.2 ; PR1237.1 56.52,69.5 PR1240.1 56.48,68.89 v1(56.82,68.55) ; PR1253.1 v1(41.82,79.03)
  TOP w0.762: v1(60.26,75.99) 60.3,75.99 61.19,76.88 PD1801.2 61.68,76.43 PR1236.2
  IN2 w0.762: 15.9,65.48 16.9,64.49 16.9,59.53 18.88,57.54 21.05,57.54 21.5,57.1 21.5,57.09 23.42,55.16 26.39,55.16 26.75,54.81 27.51,54.81 28,55.29 31.17,55.29 33.58,57.7 33.58,60.37 34.42,61.21 35.07,61.21 35.64,61.78 36.03,61.78 36.58,62.33 36.58,62.98 37.07,63.46 v1(37.07,64.74) 36.86,64.74 35.67,65.93 35.67,69.05 35.03,69.68 35.03,71.6
  BOTTOM w0.508: v1(34.45,73.43) 35.83,73.43 36.57,72.69 38.28,72.69 v1(40.06,74.47)
  vias: v1(13.64,66.09) v1(14.28,66.09)
+3.3V_VDD_PIC_PDA: length 22.1
  TOP w0.152: v1(25.61,66.25) 25.53,66.18 25.53,65.33 26.19,64.67 26.19,64.31 UT5.H1
  TOP w0.203: UT5.B1 29.19,64.55 v1(29.56,64.92)
  TOP w0.508: v1(25.61,66.25) 25.29,66.57 CT74.1
  IN2 w0.508: v1(15.65,68.17) 17.28,68.17 18.09,67.36 20.76,67.36 21.86,66.25 v1(25.61,66.25) 25.67,66.32 28.02,66.32 28.85,67.15 30,67.15 30.41,66.74 30.41,66.06 29.9,65.55 29.81,65.55 29.56,65.31 v1(29.56,64.92)
  vias: v2(14.6,68.28)
+3.3V_VGA:
  vias: v2(280.86,45.61)
+3.3V_WLAN: length 21.5
  BOTTOM w1.016: 215.57,20.87 213.74,22.71 213.74,25.36 212.91,26.19 212.91,28.62 213.92,29.64 213.92,32.3 214.86,33.24 214.86,33.98 214.43,34.41 214.02,34.41 213.45,34.98 213.45,36.08 215.02,37.64 215.83,37.64 216.21,38.02
  vias: v1(216.72,38.91) v1(217.35,38.91) v1(217.96,38.91) v1(218.55,38.91) v1(218.85,19.76) v1(219.43,19.76) v3(214.16,39.86) v3(216.48,40.41) v3(218.3,39.65)
+3.3V_WLAN_UZ4:
  vias: v2(211.68,35.47)
+3.3V_WWAN:
  vias: v1(226.37,40.66) v1(226.42,40.08) v1(226.98,40.66) v1(227.03,40.08) v1(227.59,40.66) v1(258.88,35.23) v1(259.47,35.23) v1(277.03,35.1) v1(277.55,35.4) v3(225.8,41.63)
+3.3V_WWAN_UZ2: length 1.5
  TOP w0.102: CZ124.1 228.73,43.53 v2(228.45,43.81)
+5V_ALW: length 374.2
  TOP w0.203: UZ3.4 177.22,61.8 177.28,61.74 177.96,61.74 178.16,61.95 178.16,62.62 178.47,62.93 ; v1(231.86,38.53) 231.86,38.81 232.21,39.16 232.21,39.92 UZ2.4 ; UZ5.4 245.55,38.15 245.65,38.25 v1(245.65,38.68) ; UZ4.4 216.11,33.54 216.23,33.42 216.93,33.42 217.76,32.6 217.76,29.92 v1(216.59,28.75)
  TOP w0.254: UI3.8 274.65,29.01 274.54,28.9 274.35,28.9 274.27,28.83 ; 274.27,28.83 274.27,29.13 274.66,29.51 UI3.7 ; 274.27,28.83 274.27,28.47 274.93,27.82 v1(274.93,27.71) ; UZ8.4 235.41,38.3 235.89,38.78 237.41,38.78 v1(237.88,39.25) ; 275.14,31.29 275.49,31.64 RI13.2
  TOP w0.305: UZ26.3 127.57,34.05 ; PC668.1 66.15,48.8 66.54,49.2 66.54,50.08 66.08,50.54 PR680.1 ; JLED1.1 271.3,9.16 270.95,8.81 v1(270.82,8.81)
  TOP w0.381: v1(295.71,93.9) 296,94.19 LED3.2
  TOP w0.457: v1(75.29,61.53) 75.29,61.81 74.87,62.23 PR686.1
  TOP w0.508: 127.57,34.05 129.03,32.6 132.89,32.6 135.14,30.35 143.92,30.35 146.88,27.39 146.88,25.43 147.65,24.66 158.01,24.66 v3(162.74,29.39) 164.46,31.11 v1(175.52,31.11) ; v1(86.92,83.66) 87.55,83.03 PR615.2 PR634.2 ; v1(180.93,63.29) 178.83,63.29 178.47,62.93 ; v1(73.94,74.44) 74.03,74.53 74.03,76.21 72.99,77.25 PR691.1 72.7,77.14 PR689.1 ; PR681.1 66.13,47.52 PC668.1 66.15,46.86 v1(66.09,46.81) ; v1(45.95,81.81) 46.62,81.81 PR7.1 ; v1(168.65,92.95) 168.58,93.01 156.14,93.01 154.36,91.23 148.92,91.23 148.42,91.74 v3(147.68,91.74) 143.44,91.74 142.47,90.78 134.47,90.78 v1(133.53,91.72) ; v1(273.99,30.3) 273.99,30.45 274.83,31.29 275.14,31.29 ; v1(20.73,56.05) 19.99,56.05 19.49,56.56 19.49,57.39 18.98,57.9 18.53,57.9 18.03,58.4 DT1.2
  IN1 w0.508: v1(71.28,53.96) 70.22,53.96 69.71,54.47 69.71,55.57 71.31,57.17 71.31,59.15 71.3,59.17 ; v1(237.88,39.25) 235.11,39.25 233.89,38.02 233.23,38.02 233.1,37.89 232.21,37.89 231.86,38.25 v1(231.86,38.53) ; v1(85.39,59.64) 85.39,61.58 83.71,63.25 79.34,63.25 78.11,62.02 76.04,62.02 75.54,61.53 v1(75.29,61.53) 75.29,61.73 74.78,62.24 73.02,62.24 72.85,62.07
  IN2 w0.508: v1(175.52,31.11) 174.86,31.77 174.86,40.61 178.82,44.57 178.82,46.1 178.72,46.2 178.72,49.91 179.38,50.57 179.38,51.71 ; v1(66.09,46.81) 66.7,46.2 68.43,46.2 71.28,49.04 v1(71.28,53.96) ; v1(20.73,56.05) 20.73,55.06 21.65,54.15 25.33,54.15 25.61,53.87 27.64,53.87 27.93,53.58 30.97,53.58 32.96,55.57 v1(34.8,55.57) ; v1(261.55,99.87) 266.77,99.87 269.6,97.04 269.6,94.85 270.57,93.89 276.81,93.89 280.86,89.84 289.87,89.84 293.93,93.9 v1(295.71,93.9) ; v1(86.92,83.66) 84.72,83.66 81.3,80.23 80.62,80.23 74.83,74.44 v1(73.94,74.44) 73.59,74.09 69.52,74.09 66.6,71.17 63.94,71.17 60.68,67.91 v1(60.05,67.91)
  IN3 w0.381: v1(262.58,29.19) 262.58,29 262.96,28.62 264.31,28.62 264.37,28.67 266.35,28.67 267.1,29.43 273.12,29.43 v1(273.99,30.3)
  IN3 w0.508: v1(135.87,85.8) 135.87,88.67 v1(135.61,88.94) 135.47,88.94 133.53,90.88 v1(133.53,91.72)
  IN3 w2.032: 180.5,53.87 184.21,57.58 184.21,61.54 182.99,62.76 182.99,66.7
  IN4 w0.508: v1(225.33,39.49) 225.56,39.26 227.87,39.26 228.91,40.31 230.94,40.31 231.86,39.39 v1(231.86,38.53) ; v1(245.65,38.68) 245.89,38.93 245.89,39.5 245.44,39.95 244.66,39.95 243.64,38.93 240.05,38.93 239.74,39.25 v1(237.88,39.25) ; v1(255.62,8.68) 254.61,9.69 254.61,11.58 255.13,12.1 v1(255.13,12.4)
  BOTTOM w0.203: v1(216.59,28.75) 216.46,28.88 v1(216.46,31.06)
  BOTTOM w0.254: PU614.6 87.86,83.99 PC685.1 ; RA53.2 262.69,27.07 262.46,27.3 262.16,27.3 261.85,27.61 261.85,28.46 v1(262.58,29.19)
  BOTTOM w0.305: PU613.15 75.21,74.39 PC697.1 ; PU612.15 65.98,46.92 v1(66.09,46.81) ; PU610.15 85.13,60.24 85.22,60.33 PC661.1
  BOTTOM w0.381: v1(135.61,88.94) 135.61,88.44 135.36,88.19 UZ19.3 ; v1(135.87,85.8) 135.87,86.27 135.51,86.63 134.7,86.63 133.9,85.83 UZ21.3
  BOTTOM w0.508: PC685.1 87.52,83.66 v1(86.92,83.66) ; v1(73.94,74.44) 74.1,74.29 75.11,74.29 PC697.1 ; PR688.1 PC661.1 85.63,59.88 v1(85.39,59.64) ; v1(60.05,67.91) 60.4,67.91 PR602.2
  vias: v1(31.42,18.11) v1(31.42,17.52) v1(32.11,18.13) v1(32.11,17.55) v1(34.8,58.06) v1(34.8,57.48) v1(34.8,56.84) v1(34.8,56.21) v1(35.41,58.06) v1(35.41,57.48) v1(35.41,56.84) v1(35.41,56.21) v1(35.41,55.57) v1(36,58.06) v1(36,57.48) v1(36,56.84) v1(36,56.21) v1(36,55.57) v1(44.78,81.43) v1(44.89,82.11) v1(45.42,81.4) v1(59.82,68.5) v1(60.02,69.06) v1(175.95,101.93) v1(176.56,101.93) v1(177.22,101.93) v1(179.08,52.94) v1(179.5,52.53) v1(180.03,52.3) v1(180.12,51.72) v1(182.73,69.11) v1(183.19,68.63) v1(183.62,68.23) v1(184.04,67.81) v1(215.29,31.06) v1(215.68,32.69) v1(215.88,31.03) v1(216.26,32.69) v1(239.88,12.26) v1(240.11,12.82) v1(240.52,12.34) v1(241.58,16.46) v1(241.94,15.62) v1(242.12,16.18) v1(242.78,16.81) v1(243.39,16.81) v1(243.98,16.81) v1(278.57,31.44) v1(279.2,31.54) v1(279.56,31.06) v1(279.71,31.92) v1(280.06,31.37) v1(282.63,33.24) v1(282.63,32.64) v1(282.63,32.05) v1(283.16,33.57) v1(283.19,32.97) v1(283.16,32.33) v1(287.89,45.34) v1(287.91,44.73) v1(288.52,45.31) v1(288.6,44.7) v1(289.18,45.31) v1(289.23,44.67) v3(216.43,31.91)
+5V_ALW2: length 2.7
  TOP w0.127: v3(39.22,44.51) 39.44,44.51 40.1,45.17 PC126.1
  TOP w0.508: PC126.1 39.82,46.02 v1(39.25,46.02)
+5V_ALW_PDA: length 4.6
  TOP w0.254: UT5.H10 26.19,60.18 v1(26.31,60.3)
  IN1 w0.508: v1(29.27,58.24) 27.97,58.24 26.31,59.9 v1(26.31,60.3)
  vias: v1(29.04,58.85) v1(29.65,58.82) v1(29.87,58.24) v1(30.26,58.85) v1(30.46,58.26) v1(31.04,58.29) v3(30.34,53.5)
+5V_ALWP: length 11.7
  IN4 w0.254: v1(40.09,52.19) 39.5,52.19 38.56,51.25 38.56,45.92 v1(39.36,45.12)
  BOTTOM w0.254: PR117.2 38.09,44.28 38.09,44.83 38.5,45.23 39.25,45.23 v1(39.36,45.12) 39.51,45.12 39.55,45.09 PU102.14
  vias: v1(40.06,53.97) v1(40.09,53.39) v1(40.09,52.8) v1(40.09,51.61) v1(40.09,51.02) v1(40.09,50.42) v1(40.09,49.83) v1(40.67,53.97) v1(40.7,53.39) v1(40.7,52.8) v1(40.7,52.19) v1(40.7,51.61) v1(40.7,51.02) v1(40.7,50.42) v1(40.7,49.83) v3(41.38,49.68)
+5V_HDD: length 7.1
  TOP w0.381: 252.94,7.24 252.65,7.53 250.94,7.53 250.41,8.06 250.41,9.14 249.8,9.75 249.8,11.5 249.9,11.6 RN1.1
  vias: v1(253.04,6.14) v1(253.42,5.69) v1(253.8,6.14) v3(246.6,3.95)
+5V_HDD_UZ23: length 0.6
  TOP w0.127: 242.26,10.82 241.95,10.51 v2(241.95,10.37)
+5V_PD_VDD: length 3
  TOP w0.102: v2(19.35,61.43) 18.68,61.43 18.03,62.08
  TOP w0.508: RT111.1 17.88,65.14 UT7.1
+5V_RUN: length 337.3
  TOP w0.254: v1(200.05,20.04) 200.05,20.32 CZ92.1 200.54,20.44 200.54,19.63 201.15,19.02 JKBTP1.5 ; JUSH1.7 254.1,9.29
  TOP w0.508: 254.1,9.29 256.86,6.52 v1(257.74,6.52) 262.16,6.52 262.67,6.02 263.52,6.02 264.01,6.51 264.01,6.96 264.9,7.84 268.96,7.84 269.42,8.3 269.42,10.21 269.8,10.59 ; RZ370.1 242.56,44.13 v1(241.38,42.95)
  TOP w1.016: 181.04,72.05 185.48,67.61 185.48,64.18 187.06,62.59 187.06,56.9 v3(188.81,55.16) 192.76,51.2 192.76,50.03 195.06,47.74 196.84,47.74 199.98,44.6 199.98,43.51 199.32,42.85 192.97,42.85
  IN3 w0.508: v1(193.44,29.33) 192.27,28.16 187.38,28.16 184.13,24.91 134.26,24.91 131.31,27.86 102.24,27.86 100.39,26.01 71.1,26.01 68.25,23.16 48.82,23.16 46.64,20.98 44.33,20.98 43.6,20.25 36.92,20.25 36.28,19.6 28.63,19.6 27.23,21 23.32,21 21.87,22.45 19.05,22.45 18.39,23.11 18.39,25.93 17.83,26.49 17.83,33.57 18.85,34.59 18.85,41.32 15.8,44.37 15.8,50.9 v1(17.24,52.33)
  IN3 w1.016: 197.67,20.24 196.89,20.24 196.09,21.04 195.66,21.04 193.78,22.92 193.78,27.78
  IN4 w0.508: v1(241.38,42.95) 241.41,42.92 241.41,40.12 241.96,39.57 243.38,39.57 244.39,40.59 245.71,40.59 246.56,39.73 246.56,39.47 247.06,38.97 v1(247.5,38.97)
  IN4 w1.016: 179.68,74.47 179.68,80.27 181.75,82.34 181.75,86.13 183.19,87.56
  BOTTOM w0.381: v1(17.24,52.33) CV39.1 18.53,52.14 UV2.1
  BOTTOM w1.016: 193.78,30.78 193.78,30.98 188.78,35.99 188.78,40.05 190.81,42.08
  vias: v1(179.68,73.44) v1(180.18,72.96) v1(182.81,88.5) v1(183.31,88.83) v1(190.94,43.1) v1(191.44,42.72) v1(193.92,28.93) v1(213.82,27.58) v1(214.28,27) v1(214.41,27.58) v1(214.86,27) v1(215.45,27) v1(216.03,27) v1(243.9,5.99) v1(243.9,5.41) v1(244.48,5.99) v1(244.48,5.41) v1(245.05,5.7) v1(247.96,40.18) v1(248.11,39.45) v1(248.53,39.99) v1(248.79,39.45) v1(279.58,41.08) v1(279.59,40.48)
