# Allegro board LAF391PR10-0920.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+5V_RUN_AUDIO: length 23.3
  TOP w0.508: LA5.2 269.97,24.79 271.23,24.79 v1(271.38,24.94)
  IN3 w0.508: v1(271.38,24.94) 272.98,24.94 273.71,25.68 273.71,28.01 273.24,28.48 267.38,28.48 266.87,27.98 266.87,27.48 266.49,27.1 262.15,27.1 261.72,27.53 261.72,29.54 262.18,30.01 v1(262.18,30.7)
  vias: v3(252,31.34)
+5V_RUN_AUDIO_UZ5:
  vias: v3(248.39,35.16)
+5V_RUN_CHG: length 3.4
  TOP w0.102: v2(245.41,46.58) 244.91,46.09 QZ4.1
  TOP w0.508: QZ4.1 243.64,45.54 243.96,45.22 RZ370.2
+5V_RUN_PVDD_L: length 3.4
  BOTTOM w0.305: v1(262.39,24.08) 262.39,24.61 261.93,25.07 261.93,25.87 CA47.1
  BOTTOM w0.356: CA45.1 266.38,25.55 266.25,25.42
  BOTTOM w0.381: 266.25,25.42 v1(266.07,25.24)
  vias: v1(261.8,24.08) v1(265.64,24.71) v2(260.47,24.68)
+5V_RUN_UZ4:
  vias: v3(213.2,30.97)
+5V_TBT_VBUS:
  vias: v3(18.6,55.29)
+5V_TBTA_VBUS_D:
  vias: v2(13.2,56.68)
+5V_USB_CHG_PWR:
  vias: v1(277.42,27.35) v1(277.91,27.81) v1(278.06,27.22) v1(278.49,27.81) v1(279.07,27.96) v1(282,20.87) v1(282.73,20.65) v1(282.83,19.91) v1(283.27,20.37) v3(283.04,19.17)
+DV33_18: length 3
  BOTTOM w0.203: 78.12,96.81 78.37,96.56 UR1.18
  BOTTOM w0.508: 78.12,96.81 77.93,97 v2(77.93,97.65) 77.93,98.34 CR22.1
+GND_CHASSIS:
  vias: v1(266.13,84.76) v1(266.13,84.12) v2(266.84,93.51)
+VBUS_DC_SS: length 33.2
  TOP w0.762: PD903.2 31.14,39.15 32.15,40.15 v1(34.99,40.15)
  IN3 w0.762: v1(34.99,40.15) 35.42,40.59 35.42,48.6 34.55,49.48 34.55,52.02 34.7,52.17 34.7,53.53 35.77,54.59 36.11,54.59 36.86,55.34 36.86,58.31 42.55,64 42.92,64
  vias: v1(43.73,64.45) v1(44.12,64.88) v2(43.41,65.31)
+VCC1V8A_TBTA_LDO: length 1.3
  TOP w0.203: 24.18,65.12 24.38,65.12 UT5.K1
  vias: v2(23.37,65.72)
+VCC1V8D_TBTA_LDO: length 21
  TOP w0.203: 30.38,64.28 30.34,64.25 30.33,64.25 30.31,64.22 30.11,64.22 30.05,64.16 30.05,64.16 29.84,63.95 29.84,63.95 UT5.A2
  TOP w0.254: RT97.1 24.79,53.36 v1(24.85,53.31)
  TOP w0.381: 30.38,64.28 31.19,64.28 31.45,64.03 CT72.1
  TOP w0.508: CT72.1 31.63,64.64 v1(31.68,64.69)
  IN1 w0.508: v1(31.68,64.69) 31.68,62.02 32.34,61.36 32.34,58.16 30.74,56.56 27.23,56.56 24.85,54.17 v1(24.85,53.31)
  BOTTOM w0.102: v1(31.68,64.69) v2(31.68,65.25)
+VCC_1P8: length 20.6
  IN4 w0.508: v1(133.73,64.15) 133.73,63.98 134.12,63.6 134.73,63.6 135.54,64.41 139.27,64.41 140.59,63.09 v1(149.01,63.09)
  BOTTOM w0.102: CC222.1 151.03,62.44 v2(151.22,62.63)
  BOTTOM w0.254: UC1.U11 134.47,64.75 134.12,64.75 UC1.U12 133.73,64.37 v1(133.73,64.15)
  BOTTOM w0.457: CC222.1 150.21,62.43 RC313.2 149.34,62.76 v1(149.01,63.09)
+VCC_CORE: length 55.7
  TOP w0.254: RC140.2 92.49,65.15 v1(92.97,65.15)
  TOP w0.508: PC1075.1 122.52,63.47 v1(122.94,63.47)
  IN1 w0.102: 101.4,62.02 101.38,62.05 99.65,62.05
  IN3 w0.102: 109.66,70.76 109.63,70.74 109.63,69.69 ; 111.46,70.74 111.46,70.3 ; 112.4,71.45 112.38,71.43 112.38,71.02 112.3,70.94 ; 114.2,70.13 114.2,69.72 ; 113.21,71.4 113.21,70.94
  IN4 w0.254: v1(92.97,65.15) 93.1,65.27 93.48,65.27 94.06,64.69 98.51,64.69 98.73,64.92 108.59,64.92 108.7,65.02 109.86,65.02 111.48,66.65 115.42,66.65 v1(116.39,67.61)
  BOTTOM w0.127: UC1.AK40 117.82,58.72 ; UC1.AK40 117.47,58.33 ; UC1.AK40 117.82,58.02 ; UC1.AK40 118.29,58.33 ; 118.74,58.02 UC1.AK38 118.74,58.33 ; 120.71,69.16 UC1.J33 ; UC1.J33 121.02,68.88 ; UC1.J33 121.34,69.16 ; UC1.J33 121.02,69.52 ; UC1.AL33 122.29,57.86 ; UC1.AL33 121.59,57.86 ; UC1.AL33 121.94,58.21 ; UC1.AL33 121.94,57.51 ; UC1.AK35 120.57,58.66 ; UC1.AK35 120.1,58.33 v1(120.1,58.57) ; UC1.AK35 120.57,58.02 ; UC1.K33 121.48,68.37 ; UC1.K33 121.48,69.01 ; UC1.K33 121.01,68.7 ; UC1.K33 121.85,68.7 ; v1(121.01,68.47) 121.01,68.7 ; 121.01,68.7 UC1.K35 ; 121.48,58.72 UC1.AK33 ; UC1.AK33 121.95,58.33 v1(121.95,58.59) ; UC1.AK33 121.48,58.02 ; 115.63,68.5 UC1.K43 116,68.42 ; 118.29,58.33 v1(118.29,58.57) ; 118.29,58.33 118.74,58.33 ; 117.82,69.01 UC1.K40 ; UC1.K40 117.82,68.4 ; UC1.K40 117.53,68.7 ; 118.61,57.86 UC1.AL40 ; UC1.AL40 118.28,57.51 ; UC1.AL40 118.28,58.15 ; UC1.AL40 117.97,57.86 ; 118.74,69.01 UC1.K38 118.74,68.4 ; UC1.AL37 120.11,58.15 ; UC1.AL37 119.82,57.86 ; UC1.AL37 120.11,57.58 ; UC1.AL37 120.45,57.86 ; 120.57,68.42 UC1.K35 ; UC1.K35 120.57,69.01 ; UC1.K42 116.91,68.4 ; UC1.K42 117.28,68.7 ; UC1.K42 116.91,69.01 ; 118.74,58.33 118.74,58.66 ; 119.65,58.66 UC1.AK37 ; UC1.AK37 120.01,58.33 ; UC1.AK37 119.65,58.02 ; 119.56,69.16 UC1.J37 ; UC1.J37 118.93,69.16 ; UC1.J37 119.2,69.52 ; UC1.J37 119.2,68.88 ; 119.65,69.01 UC1.K37 119.65,68.4 ; UC1.J40 117.37,68.88 ; UC1.J40 117.66,69.16 ; UC1.J40 117.37,69.52 ; UC1.J40 117.02,69.16
  BOTTOM w0.203: UC1.A34 v1(120.41,74.28) ; UC1.A44 115.45,74.21 v1(115.55,74.31) ; UC1.A39 117.93,73.98 v1(118.2,74.25)
  BOTTOM w0.381: UC1.A30 122.89,73.81 v1(122.66,74.04)
  vias: v1(79.29,67.74) v1(79.3,72.41) v1(79.3,71.83) v1(79.3,71.24) v1(79.3,70.66) v1(79.3,70.07) v1(79.3,69.49) v1(79.3,68.91) v1(79.3,68.32) v1(79.89,72.41) v1(79.89,71.83) v1(79.89,71.24) v1(79.89,70.66) v1(79.89,70.07) v1(79.89,69.49) v1(79.89,68.91) v1(79.89,68.32) v1(79.87,67.74) v1(80.47,72.41) v1(80.47,71.83) v1(80.47,71.24) v1(80.47,70.66) v1(80.47,70.07) v1(80.47,69.49) v1(80.47,68.91) v1(80.47,68.32) v1(80.7,74.28) v1(80.7,73.7) v1(80.97,78.89) v1(80.97,78.25) v1(80.97,77.67) v1(81.06,70.06) v1(81.06,69.48) v1(81.08,68.89) v1(81.08,68.31) v1(81.29,74.28) v1(81.29,73.7) v1(81.26,70.62) v1(81.55,78.89) v1(81.55,78.25) v1(81.55,77.67) v1(81.7,70.15) v1(81.7,69.57) v1(81.7,68.98) v1(81.87,74.28) v1(81.87,73.7) v1(82.14,78.89) v1(82.14,78.25) v1(82.14,77.67) v1(82.46,74.28) v1(82.46,73.7) v1(82.87,69.57) v1(82.87,68.98) v1(82.87,68.4) v1(83.04,74.28) v1(83.04,73.7) v1(83.46,70.15) v1(83.46,69.57) v1(83.46,68.98) v1(83.46,68.4) v1(83.62,74.28) v1(83.62,73.7) v1(84.04,70.15) v1(84.04,69.57) v1(84.04,68.98) v1(84.04,68.4) v1(84.21,74.28) v1(84.21,73.7) v1(84.62,70.15) v1(84.62,69.57) v1(84.62,68.98) v1(84.62,68.4) v1(84.79,74.28) v1(84.79,73.7) v1(84.99,72.45) v1(84.99,71.87) v1(84.99,71.28) v1(84.94,70.7) v1(85.21,70.15) v1(85.21,69.57) v1(85.21,68.98) v1(85.21,68.4) v1(85.58,71.87) v1(85.58,71.28) v1(85.53,70.7) v1(85.79,70.15) v1(85.79,69.57) v1(85.79,68.98) v1(85.79,68.4) v1(85.78,67.8) v1(86.38,68.98) v1(86.38,68.4) v1(86.36,67.78) v1(86.36,67.19) v1(86.99,68.37) v1(87.01,67.78) v1(87.01,67.19) v1(113.9,64.56) v1(113.85,59.61) v1(114.38,64.92) v1(114.38,63.7) v1(114.38,63.12) v1(114.38,62.53) v1(114.38,61.95) v1(114.48,59.61) v1(114.84,67.61) v1(115.75,64.56) v1(115.75,63.31) v1(115.75,62.14) v1(115.77,60.98) v1(116.03,68.08) v1(116.01,59.76) v1(116.01,59.18) v1(116.89,68.06) v1(117.29,58.66) v1(117.35,69.91) v1(117.35,68.44) v1(117.81,68.04) v1(118.19,64.66) v1(118.19,63.39) v1(118.19,62.22) v1(118.19,61.05) v1(118.24,67.63) v1(118.34,59.76) v1(118.34,59.18) v1(118.71,68.01) v1(119.18,69.95) v1(119.18,68.45) v1(119.18,57.2) v1(119.64,68.01) v1(120.12,67.61) v1(120.12,57.2) v1(120.52,68.06) v1(120.52,64.08) v1(120.53,63.47) v1(120.53,62.23) v1(120.55,61.03) v1(120.73,59.74) v1(120.73,59.15) v1(121.06,69.93) v1(121.02,57.22) v1(121.36,68) v1(121.94,57.23) v1(122.88,69.93) v3(119.21,73.3)
+VCC_CORE_G0: length 9.9
  TOP w0.254: v1(122.52,68.18) 122.52,68.54 123.35,69.36 123.35,70.28 124.07,71 124.07,72.88 123.63,73.33 123.63,75.1 122.86,75.87 T122.1
  BOTTOM w0.254: UC1.K32 122.52,68.57 v1(122.52,68.18)
+VCC_CORE_G1: length 4.1
  TOP w0.102: v1(122.13,59.36) 122.43,59.05 122.43,56.64 T123.1
  BOTTOM w0.254: UC1.AK32 122.42,58.35 122.42,59.07 122.13,59.36 v1(122.13,59.36)
+VCC_GT: length 39.1
  TOP w0.254: RC161.2 92.04,66.58 94.71,66.58 v1(95.69,65.6)
  TOP w0.508: v1(110.75,58.77) 110.47,58.49 RC438.2 ; 106.3,74.6 106.3,75.65 v3(106.74,76.09) 110.09,79.44 RC437.1
  BOTTOM w0.127: UC1.T62 105.64,64.82 ; UC1.T62 105.97,65.22 ; UC1.T62 105.64,65.58 ; UC1.T62 105.34,65.22 ; UC1.J60 106.1,69.16 ; UC1.J60 106.39,69.52 ; UC1.J60 106.74,69.16 ; UC1.J60 106.39,68.82 ; 105.17,63.55 UC1.W63 ; UC1.W63 104.91,63.85 ; UC1.W63 105.47,63.85 ; UC1.J53 110.05,68.88 ; UC1.J53 109.78,69.16 ; UC1.J53 110.05,69.45 ; UC1.J53 110.42,69.16 ; UC1.J56 108.51,69.16 ; UC1.J56 107.94,69.16 ; UC1.J56 108.22,69.45 ; UC1.J56 108.22,68.88 ; 105.34,67.05 UC1.M62 ; UC1.M62 105.97,67.05 ; UC1.M62 105.64,66.72 ; UC1.M62 105.64,67.36 ; UC1.J58 107.62,69.16 ; UC1.J58 107.31,68.88 ; UC1.J58 106.99,69.16 ; UC1.J55 109.14,68.88 ; UC1.J55 109.47,69.16 ; UC1.J55 109.14,69.45 ; UC1.J55 108.83,69.16 ; 110.51,69.01 UC1.K53 ; UC1.K53 110.16,68.7 ; UC1.K53 110.51,68.37 ; UC1.AA63 105.17,63.29 ; UC1.AA63 104.91,62.93 ; UC1.AA63 105.47,62.93 ; UC1.AA63 105.17,62.53 ; UC1.Y62 105.97,63.39 ; UC1.Y62 105.64,63.04 ; UC1.Y62 105.64,63.67 ; UC1.Y62 105.34,63.39 ; 105.64,67.61 UC1.L62 ; UC1.L62 105.34,67.96 ; UC1.L62 105.64,68.25 ; UC1.L62 105.97,67.96 ; UC1.L63 105.17,67.2 ; UC1.L63 105.17,67.86 ; UC1.L63 105.59,67.5 ; UC1.L63 104.87,67.5 ; UC1.K56 108.68,68.37 ; UC1.K56 108.39,68.7 ; UC1.K56 108.68,69.01 ; UC1.K56 109.02,68.7 ; UC1.K55 109.28,68.7 ; UC1.K55 109.59,69.01 ; UC1.K55 109.59,68.37 ; UC1.K55 109.91,68.7 ; UC1.R63 105.17,65.32 ; UC1.R63 105.17,65.93 ; UC1.R63 105.47,65.68 ; UC1.R63 104.86,65.68 ; UC1.K58 108.07,68.7 ; UC1.K58 107.77,69.01 ; UC1.K58 107.5,68.7 ; UC1.K58 107.77,68.37 ; UC1.K60 106.85,68.37 ; UC1.K60 106.85,69.01 ; UC1.K60 107.24,68.7 ; UC1.K60 106.54,68.7 ; UC1.N63 105.47,66.59 ; UC1.N63 105.17,66.31 ; UC1.N63 105.17,66.89 ; UC1.N63 104.9,66.59
  BOTTOM w0.203: UC1.A66 v1(103.06,74.32) ; UC1.A62 105.54,74 105.49,74.05 105.49,74.07 105.42,74.13 105.42,74.16 105.38,74.2 105.38,74.38 v1(105.28,74.47) ; v1(108.03,74.22) 108.02,74.21 UC1.A58
  vias: v1(74.48,50.08) v1(74.48,49.45) v1(74.48,48.81) v1(74.48,48.18) v1(74.48,47.6) v1(75.06,47.6) v1(75.11,50.72) v1(75.11,50.08) v1(75.11,49.45) v1(75.11,48.81) v1(75.11,48.18) v1(75.7,50.72) v1(75.7,50.08) v1(75.7,49.45) v1(75.7,48.81) v1(75.7,48.18) v1(76.13,53.83) v1(76.38,53.07) v1(76.38,52.43) v1(76.38,49.45) v1(76.38,48.81) v1(76.38,48.18) v1(76.73,53.84) v1(77.02,49.45) v1(77.02,48.81) v1(77.16,54.42) v1(77.32,53.83) v1(77.47,54.97) v1(77.63,49.45) v1(77.65,48.81) v1(77.78,54.4) v1(77.92,53.82) v1(78.1,54.97) v1(78.24,49.45) v1(78.24,48.84) v1(78.36,54.43) v1(78.5,53.83) v1(78.85,49.53) v1(78.82,48.94) v1(79,54.44) v1(79.09,53.83) v1(79.47,53.37) v1(79.47,52.79) v1(79.47,52.16) v1(79.47,51.52) v1(79.48,50.78) v1(79.47,50.16) v1(79.44,49.55) v1(80.34,54.78) v1(80.93,54.73) v1(86.99,63.72) v1(86.99,63.14) v1(87.62,63.55) v1(87.62,62.91) v1(87.62,62.33) v1(87.62,61.74) v1(88.21,63.55) v1(88.21,62.91) v1(88.21,62.33) v1(88.21,61.74) v1(100.28,66.17) v1(100.28,64.29) v1(100.25,62.46) v1(100.28,61.59) v1(100.94,67.11) v1(100.94,66.17) v1(100.99,62.46) v1(100.94,61.64) v1(101.6,67.11) v1(101.6,66.17) v1(101.57,64.29) v1(101.62,62.46) v1(102.29,67.11) v1(102.29,64.29) v1(102.29,61.59) v1(102.89,67.13) v1(102.87,66.17) v1(102.93,62.45) v1(102.95,61.62) v1(103.56,67.11) v1(103.58,66.17) v1(103.53,64.29) v1(103.56,62.46) v1(104.16,67.11) v1(104.24,64.29) v1(104.22,61.64) v1(104.85,67.11) v1(104.88,66.17) v1(106.13,64.31) v1(106.2,65.83) v1(106.39,68.15) v1(106.46,61.92) v1(106.85,67.68) v1(107.31,68.15) v1(107.32,64.31) v1(107.64,61.95) v1(107.77,67.68) v1(108.22,68.15) v1(108.51,64.31) v1(108.83,61.94) v1(109.14,68.15) v1(109.48,65.88) v1(109.59,67.68) v1(109.68,64.54) v1(110.09,68.19) v1(110.27,64.54) v1(110.47,67.59)
+VCC_GT_+VCC_CORE: length 21.3
  BOTTOM w0.127: UC1.AK45 115.08,58.02 ; UC1.AK45 115.43,58.33 ; UC1.AK45 114.99,58.66 ; UC1.AK45 114.8,58.33 ; UC1.J46 113.4,69.16 ; UC1.J46 113.71,68.82 ; UC1.J46 113.71,69.45 ; UC1.J46 114.04,69.16 ; UC1.AL43 116.13,57.86 ; UC1.AL43 116.77,57.86 ; UC1.AL43 116.45,57.51 ; UC1.AL43 116.45,58.15 ; UC1.AK46 113.85,58.33 ; UC1.AK46 114.17,58.66 ; UC1.AK46 114.48,58.33 ; UC1.AK46 114.17,58.02 ; UC1.J50 111.88,69.16 ; UC1.J50 112.2,69.16 ; UC1.J50 111.88,69.45 ; 111.88,69.16 111.88,68.88 ; 111.88,69.16 111.56,69.16 ; 112.79,68.88 UC1.J48 ; UC1.J48 112.79,69.45 ; UC1.J48 112.51,69.16 ; UC1.J48 113.15,69.16 ; UC1.AL50 112.51,57.86 ; UC1.AL50 112.79,57.58 ; UC1.AL50 112.79,58.15 ; UC1.AL50 113.15,57.86 ; UC1.AK48 113.25,58.66 ; UC1.AK48 113.25,58.02 ; UC1.AK48 112.96,58.33 ; UC1.AK48 113.59,58.33 ; 112.34,68.44 UC1.K50 ; UC1.K50 112.01,68.7 ; UC1.K50 112.34,69.01 ; UC1.K50 112.64,68.7 ; 110.97,68.75 UC1.J52 111.31,69.16 ; 116.32,58.33 UC1.AK43 ; UC1.AK43 116,58.66 ; UC1.AK43 116,58.02 ; UC1.AK43 115.69,58.33 ; UC1.J45 114.62,68.82 ; UC1.J45 114.36,69.16 ; UC1.J45 114.93,69.16 ; UC1.J45 114.62,69.45 ; 113.25,68.44 UC1.K48 ; UC1.K48 113.25,69.01 ; UC1.K48 113.53,68.7 ; UC1.K48 112.96,68.7 ; 112.34,57.96 UC1.AK50 ; UC1.AK50 112.34,58.66 ; UC1.AK50 112.64,58.33 ; 116.91,57.96 UC1.AK42 ; UC1.AK42 116.77,58.72 ; UC1.AK42 116.58,58.33 ; 114.99,57.86 UC1.AL46 ; UC1.AL46 114.62,58.21 ; UC1.AL46 114.62,57.51 ; UC1.AL46 114.29,57.86 ; 115.5,68.82 UC1.J43 115.18,69.16
  BOTTOM w0.203: UC1.A53 110.5,74.22 v1(110.57,74.29) ; UC1.A48 113.15,73.5 v1(113.15,73.82)
  vias: v1(111.31,67.6) v1(111.88,68.15) v1(111.92,67.56) v1(112.2,59.48) v1(112.48,68.14) v1(112.5,67.56) v1(112.75,58.72) v1(112.83,59.48) v1(113.06,68.14) v1(113.09,67.56) v1(113.64,68.14) v1(113.67,58.72) v1(114.61,58.72) v1(115.37,58.72) v2(113.26,59.18)
+VCC_GT_AK52: length 1.4
  TOP w0.254: v1(111.36,58.82) 111.38,58.8 RC438.1
  BOTTOM w0.254: v1(111.36,58.82) 111.42,58.76 UC1.AK52
+VCC_GT_K52: length 18.2
  TOP w0.127: 109.78,71.17 109.78,71.55 110.16,71.17 110.16,71.04 110.6,70.61 110.6,69.16 110.16,69.16 109.63,69.69 109.63,71.01 109.78,71.17
  TOP w0.254: 109.78,71.55 108.51,72.82 v2(108.51,74.55) 108.02,75.05 108.02,76.65 111,79.63 RC437.2 ; 110.6,69.16 110.99,68.77 v1(110.99,68.22)
  BOTTOM w0.254: v1(110.99,68.22) 111.42,68.65 UC1.K52
+VCC_GTX: length 10.1
  TOP w0.102: v1(108.26,57.02) 108.26,56.5 v2(108.12,56.36)
  BOTTOM w0.127: UC1.AL56 109.14,58.21 ; UC1.AL56 109.47,57.86 ; UC1.AL56 108.83,57.86 ; UC1.AL56 109.14,57.58 ; 109.28,58.33 UC1.AK55 ; UC1.AK55 109.59,58.66 ; UC1.AK55 109.91,58.33 ; UC1.AK55 109.59,58.02 ; UC1.AK60 107.18,58.33 ; UC1.AK60 106.93,58.66 ; UC1.AK60 106.54,58.33 ; UC1.AK60 106.85,58.02 ; 107.62,57.86 UC1.AL60 ; UC1.AL60 106.99,57.86 ; UC1.AL60 107.31,57.45 ; UC1.AL60 107.31,58.15 ; UC1.AK56 109.02,58.33 ; UC1.AK56 108.68,58.02 ; UC1.AK56 108.68,58.66 ; 107.43,58.33 UC1.AK58 ; UC1.AK58 107.77,57.96 ; UC1.AK58 107.77,58.66 ; UC1.AK53 110.16,58.33 ; UC1.AK53 110.8,58.33 ; UC1.AK53 110.51,58.02 ; UC1.AL53 111.31,57.86 ; UC1.AL53 110.67,57.86 ; UC1.AL53 110.97,57.51 ; UC1.AL53 110.97,58.21
  vias: v1(106.52,58.78) v1(110.88,57.07)
+VCC_SA: length 20.6
  TOP w0.254: RC168.1 126.09,77.72 125.71,77.34 125.71,74.85 125.45,74.6 124.77,74.6 124.44,74.27 124.44,73.61 124.69,73.35 124.69,70
  TOP w0.381: PC1149.1 PC1148.1 126.61,58.68 v1(126.47,58.83)
  BOTTOM w0.127: UC1.J27 124.68,68.88 ; UC1.J27 124.39,69.16 ; UC1.J27 125.02,69.16 ; UC1.J27 124.68,69.52 ; UC1.K23 127.31,68.7 ; UC1.K23 126.67,68.7 ; UC1.K23 126.97,69.01 ; 126.55,58.33 UC1.AK23 126.97,58.72 ; UC1.J22 127.31,69.52 ; UC1.J22 127.06,69.16 ; UC1.J22 127.43,68.88 ; UC1.K25 126.42,68.7 ; UC1.K25 126.05,69.01 ; UC1.K25 126.05,68.37 ; UC1.J23 126.17,69.16 ; UC1.J23 126.51,68.88 ; UC1.J23 126.8,69.16 ; UC1.J23 126.51,69.52 ; 124.77,68.7 UC1.K27 125.14,69.01 ; UC1.AK25 126.42,58.33 ; UC1.AK25 126.05,58.72 ; UC1.AK25 125.66,58.33 ; 124.22,69.01 UC1.K28 124.52,68.7
  BOTTOM w0.203: v1(123.77,68.54) 123.47,68.54 UC1.K30
  BOTTOM w0.508: v1(99.43,88.12) 99.7,88.39 PC1144.1
  vias: v1(97.08,87.65) v1(97.08,87.07) v1(97.08,86.48) v1(97.69,87.52) v1(98.02,88.03) v1(98.33,87.52) v1(98.96,87.52) v1(99.72,87.52) v1(122.96,65.34) v1(122.95,64.09) v1(123.48,68.03) v1(124.17,68.08) v1(124.76,68.1) v1(125.27,65.2) v1(125.34,63.98) v1(125.33,62.81) v1(125.63,69.93) v1(126.59,68.24) v1(126.6,67.65) v3(97.79,85.44)
+VCC_SFR_OC: length 0.7
  BOTTOM w0.254: UC1.AL23 v1(127.43,58.57)
  vias: v3(126.93,40.47)
+VCCK_12: length 15.7
  TOP w0.102: v2(280.12,52.98) 279.9,52.76 CV105.1
  TOP w0.203: CV104.1 280.82,50.22 UV6.25 ; CV103.1 283.57,44.75 UV6.4
  TOP w0.381: CV103.1 283.09,44.88 283.09,44.9 v1(282.88,45.11)
  TOP w0.508: CV104.1 CV105.1 v1(280.56,52.03)
  BOTTOM w0.508: v1(282.88,45.11) 282.05,45.94 282.05,50.54 v1(280.56,52.03)
+VDD_DAC_33: length 1.9
  TOP w0.203: LV30.2 283.97,52.74 v1(283.97,51.72) UV6.20
+VDDA_AVDD1: length 6.8
  TOP w0.203: UA1.40 265.98,23.84 266.83,24.7 267.78,24.7 CA8.1
  TOP w0.508: CA8.1 268.91,24.81 268.96,24.86 LA5.1 268.96,25.54 v2(269.35,25.92) 270.41,25.92 CA9.1
+VSS_PLL: length 13.3
  TOP w0.254: CE18.2 255.88,49.4 256.09,49.2 256.98,49.2 v1(257.23,49.45) 257.73,49.45 257.93,49.25 258.31,49.25 258.36,49.3 259.18,49.3 259.18,49.29 UE1.G1
  BOTTOM w0.432: CE17.2 250.93,53.46 251.69,53.46 v2(252,53.16) 252.56,52.6 255.22,52.6 256.34,51.48 256.34,50.34 v1(257.23,49.45)
GND: length 3611
  TOP w0.203: v1(161.24,84.6) 161.26,84.57 UV7.52 ; UV6.24 282.37,51.38 282.14,51.61 v1(281.87,51.61) ; v1(232.21,42.92) 232.21,41.97 UZ2.11 ; UV7.11 v1(166.79,79.82) ; PQ1209.1 61.4,71.01 61.24,71.17 v1(60.96,71.17) ; v1(174.07,61.87) 174.14,61.8 UZ3.11 ; v1(245.55,36.75) UZ5.11 ; v1(155.88,63.19) 155.91,63.17 155.91,63.14 156.35,62.7 UZ12.23 ; UV7.19 v1(169.99,79.83) ; PC1201.1 v1(60.67,72.98) 60,72.31 PQ1209.4 ; UZ4.11 v1(213.89,33.54)
  TOP w0.254: v1(260.97,75.02) 261.12,75.16 261.12,78.23 261.31,78.42 v1(262.44,78.42) 263.56,78.42 263.78,78.2 YL1.4 ; UE1.H4 261.24,48.16 v1(261.24,48.1) ; v1(31.6,50.5) 31.39,50.72 PC944.2 ; CA23.2 264.72,25.95 265.19,26.42 265.19,27.34 265.14,27.39 265.14,29.22 265.33,29.41 v1(265.33,30.07) ; PR927.2 21.75,47.81 v1(21.71,47.81) ; v1(246.73,22.32) 246.6,22.19 UN4.7 ; v1(262.95,55.19) 263.22,54.91 UE1.A6 ; RC141.2 92.51,65.76 v1(92.97,65.76) ; UE1.E6 262.84,51.31 v1(262.84,51.35) ; v1(264.77,77.22) 264.77,76.37 264.65,76.25 264.65,74.01 264.22,73.58 CL13.2 ; CT120.2 v1(31.55,80.97) ; v1(23.54,65.1) 24.06,64.58 24.43,64.58 24.69,64.31 ; CL9.2 260.53,78.66 v1(260.91,79.04) ; v1(11.23,66.82) 11.23,67.03 DT13.2 ; UE1.A13 268.9,54.13 v1(269.51,54.75) ; DT18.2 12.01,74.74 v1(12.12,74.62) ; v1(159.12,61.35) 159.35,61.58 UZ12.16 ; UC8.7 106.05,99.11 v1(106.38,98.78) ; v1(134.36,64.19) 134.03,64.53 CC314.2 ; UT5.A1 v1(30.17,64.79) ; UZ12.32 155.85,58.08 v1(156.07,58.3) ; UZ12.9 159.35,58.08 v1(159.12,58.3) ; v1(280.34,29.49) 280.31,29.51 279.65,29.51 ; JUSH1.3 252.1,8.68 v1(251.85,8.43) 251.85,8.57 251.6,8.81 JUSH1.2 ; CT118.2 v1(25.07,81.91) ; 279.65,29.51 UI3.14 ; 279.65,29.51 RI14.1 ; PC1092.2 118.44,65.34 PC1039.2 118.44,66.49 PC1084.2 118.45,67.07 PC1098.2 118.45,67.18 118.77,67.51 119.05,67.51 v1(119.16,67.61) ; v1(12.12,76.4) 12.03,76.31 DT17.2 ; UN7.3 v1(224.97,23.41) ; UE1.C4 v1(262.03,52.13)
  TOP w0.305: v1(272.7,8.25) 272.7,8.58 272.8,8.68 JLED1.4 ; CN20.2 247.58,27.86 RN53.2 ; JKBTP1.15 206.15,17.29 205.84,16.98 v1(203.93,16.98) ; CL16.2 v1(260.53,86.03) ; v1(276.45,37.87) 276.25,37.87 275.95,37.56 CE53.2 ; JKBTP1.20 208.65,17.2 v1(207.95,16.51) 207.8,16.51 207.15,17.16 JKBTP1.17 ; CL21.2 v1(260.66,95.04) ; CC270.2 130.7,58.81 CC223.2 ; v1(231.67,25) CN30.2 ; JKBTP1.2 199.65,17.93 v1(199.92,17.66) 200.15,17.9 JKBTP1.3 ; CZ103.2 128.12,37.52 UZ26.5 ; JKBTP1.9 v1(203.15,17.76) ; CL20.2 v1(260.53,91.99) ; v1(174.22,79.85) 174.22,80.17 173.81,80.59 CV83.2 ; CL17.2 v1(260.53,88.95)
  TOP w0.356: v1(155.88,63.19) 155.82,63.19 155.47,63.55 CZ53.2 154.92,64.35 CZ60.2 ; PC1334.2 115.29,58.18 PC1330.2 115.29,57.24 v1(115.54,57) ; CZ75.2 158.2,55.79 CZ50.2 ; CZ63.2 CZ73.2 256.95,12.49 v1(257.18,12.72) ; PC1038.2 119.5,58.27 v1(119.2,58.58) 118.83,58.21 PC1030.2 ; v1(280.7,67.61) 280.7,68.65 CL19.2 ; CZ51.2 153.7,58.4 153.7,58.97 v1(153.73,59) ; v1(255.07,47.93) 255.19,47.81 CE15.2 ; CZ67.2 254.13,13.94 CZ69.2 255.16,13.98 CZ68.2 256.85,13.98 v1(256.98,13.85) ; CR17.1 85.49,96 v1(85.42,95.93) ; CZ93.2 278.15,71.26 278.21,71.19 278.21,70.69 v1(277.96,70.43) ; v1(121.02,58.57) 121.26,58.34 PC1053.2 ; CC30.2 v1(100.36,100) ; RT63.2 35.13,68.42 PQ1204.1 ; v1(36.85,70.48) 36.43,70.91 PQ1204.4 ; CZ71.2 270.6,12.33 CZ66.2 271.31,11.15 v1(271.48,11.15) ; CN3.2 240.81,19.39 240.63,19.57 RN61.2 ; CV85.2 163.82,77.78 v1(163.78,77.75) ; v1(73.82,93.47) 73.82,92.93 73.77,92.88 CV17.2 RV3.1 ; v1(264.22,14.52) 264.38,14.69 CA55.2 264.51,15.16 CA69.2 ; v1(210,36.22) 210,35 CZ122.2 209.78,34.78 CZ118.2 ; CV84.2 159.03,82.55 v1(158.96,82.47) ; PC1332.2 PC1333.2 113.36,57.61 PC1331.2 113.37,57.34 v1(113.71,57) ; CA10.2 260.23,21.66 v1(260.18,21.61) ; CZ111.2 v1(234.94,41.16) ; CZ129.2 v1(241.48,9.99)
  TOP w0.381: v1(94.08,66.11) RC114.2 94.08,64.16 RC91.2 RC90.2 v1(94.07,62.44) ; UD1.3 48.19,30.3 47.93,30.56 v1(47.93,30.91) ; v1(31.55,80.97) 31.55,81.16 31.88,81.49 32.8,81.49 RT410.2 ; CZ82.2 207.93,36.24 208.58,36.89 v1(208.58,37.07) ; v1(17.91,53.62) 17.91,53.39 18.09,53.21 RV21.2 ; CE25.2 277.89,49.41 278.31,49.83 v1(278.31,50.21) ; v1(277.1,1.41) 278.83,3.13 281.2,3.13 DA2.1 ; RN73.2 237.29,27.05 v1(237.29,27.61) ; CA12.2 274.63,18.21 v1(273.99,17.57) 274.32,17.24 CA13.1 ; RC44.2 RC96.2 148.22,64.61 v1(147.81,65.03) ; RZ40.1 230.9,37.77 230.41,37.27 v1(230.41,36.75) ; CZ62.2 260.43,11.96 v1(259.93,11.45) ; v1(66.68,101.39) 66.68,101.16 67.21,100.63 67.89,100.63 CA7.2 ; PU1201.4 56.36,76.46 56.82,75.99 v1(57.08,75.99) ; CT189.2 10.57,73.71 8.91,73.71 CT99.2 CT100.2 ; v1(171.45,60.45) 171.78,60.78 CZ113.2 172.14,60.49 172.56,60.07 CZ112.2 ; 132.34,57.95 132.34,57.37 RC311.2 ; CZ54.2 162.46,61.81 CZ55.2 163.5,62.85 v1(164.81,62.85) 165.22,62.85 165.99,62.07 CZ59.2 ; v1(266.35,58.85) 266.07,59.13 RE93.2 ; CC323.2 132.19,63.73 132.19,64.38 v1(132.16,64.41) 132.16,64.75 CC211.2 ; CZ72.2 252.96,11.37 v1(252.95,11.35) ; v1(219.73,20.59) 220.37,20.59 RN7.1 220.67,20.29 CN17.2 ; RC1.2 134.78,65.89 134.64,65.75 CC281.2 ; v1(114.87,13.39) 115.44,13.96 CD24.2 ; v1(251.97,75.1) 251.95,75.1 251.82,74.98 CL7.2 ; UZ6.3 202.75,34.94 203.13,34.56 v1(203.13,33.88) ; v1(252.31,14.09) 252.72,14.09 RZ10.1 ; PR1210.2 41.97,73.28 v1(41.61,73.63) PQ1214.4 ; RC324.2 124.38,77.09 124.64,76.82 v1(124.64,76.15) ; v1(254.95,44.4) 255.39,44.84 CE3.2 255.8,45.04 CE23.2 ; v1(276.28,41.73) 276.28,41.96 275.91,42.32 275.38,42.32 275.09,42.62 275.09,42.65 274.9,42.83 UE4.3 ; CC29.2 100.96,107.86 v1(100.97,107.87) ; v1(133.75,66.3) 133.2,66.86 CC264.2 ; v1(195.14,17.91) 195.14,18 195.05,18.09 194.97,18.09 194.67,18.39 CD60.2 ; v1(47.98,52.07) 47.78,51.86 47.45,51.86 47.25,51.66 PQ1208.1 ; v1(232.85,25) 233.23,25.38 RN185.2 ; CE21.2 v1(260.86,41.83) ; CZ120.2 v1(238.51,35.91) ; v1(44.28,56.97) 44.2,56.97 43.86,57.31 PQ1210.1 ; v1(31.73,18.72) 31.7,18.74 CI7.2 ; PQ1201.4 v1(37.14,69.26) ; PU1200.3 v1(38.07,75.28) 38.75,74.6 PR1262.2 ; v1(57.79,67.81) 58.25,68.28 PC1214.2 ; CA19.2 259.96,25.95 259.24,26.68 259.24,29.02 CA46.2 ; CC27.2 129.42,36.46 128.45,37.42 UZ26.5 ; v1(259.74,68.53) 259.62,68.41 CL11.2 ; v1(24.87,70.15) 25.33,69.69 CT122.2 ; CD28.2 113.47,23.86 v1(113.6,23.98) 114.13,23.98 CD27.2 ; v1(34.5,69.01) 34.75,69.26 PQ1204.1 ; CA24.2 262.04,25.97 261.57,26.44 261.57,29.84 v1(261.33,30.08) ; CN21.2 RN40.2 249.84,18.89 v1(249.84,18.44) ; v1(49.08,25.19) 48.95,25.32 CD32.2 ; v1(29.8,70.46) 29.6,70.66 CT121.2 CT119.2 ; RZ25.2 268.56,27.28 v1(268.1,27.74) ; CZ84.2 199.55,22.22 v1(199.55,21.59) 200.21,21.59 200.36,21.43 CZ92.2 CZ91.2 ; v1(254.77,42.08) 254.49,41.81 UE6.3 ; CE13.2 v1(262.74,57.96) ; CL15.2 v1(272.61,64.08) ; v1(132.58,39.76) 132.58,38.74 133.41,37.92 CC332.2 134.26,37.17 CC333.2 ; v1(245.01,41.19) 244.92,41.19 242.26,38.53 241.51,38.53 240.96,37.98 240.96,36.61 240.11,35.76 CA67.2 CA68.2 ; RN74.2 240.62,23.05 v1(240.66,23.01) ; UL2.3 v1(274.73,65.94) ; PC1204.2 40.51,72.21 v1(40.01,71.71) ; CC205.2 132.51,61.09 v1(132.92,61.09) 133.26,61.43 CC326.2 ; CC203.2 129.57,66.91 CC202.2 129.51,66.21 v1(129.56,66.16) ; CC331.2 131.3,37.05 129.95,38.41 129.95,40.68 130.94,41.68 131.47,41.68 v1(132.58,42.78) ; PC1148.2 PC1149.2 126.04,57.67 v1(125.6,57.22) ; v1(131.75,42.78) 129.81,42.78 128.08,41.06 128.08,38.64 CZ103.2 ; CI3.2 18.84,25.45 v1(19.44,24.85) ; v1(142.74,41.46) 142.12,42.08 CC214.2 142.57,42.72 143.01,42.29 CC316.2 ; CZ125.2 247.43,36.75 v1(245.55,36.75) ; v1(275.47,40.46) 275.47,40.22 275.09,39.83 UE5.3 ; v1(63.94,81.83) 64.16,81.61 PQ1.1 ; v1(254.52,12.47) 254.52,11.96 CZ64.2 ; v1(27.11,55.55) 27.44,55.22 RT99.2 ; v1(66.6,92.86) 67.77,92.86 RV2.2 ; PQ1210.4 v1(42.41,58.61) ; CE20.2 CE19.2 267.73,59.32 268.03,59.61 v1(268.03,59.74) ; PQ1201.1 39.09,70.96 v1(38.65,70.52) ; v1(18.9,63.47) 18.5,63.47 CT89.2 ; CL10.2 250.54,67.97 v1(250.28,67.71) ; CC208.2 130.09,65.15 130.86,65.92 v1(130.86,66.09) ; PC1089.2 115.45,65.31 PC1088.2 115.43,65.91 PC1086.2 115.43,66.52 PC1090.2 115.43,67.6 v1(115.42,67.61) ; RN59.2 231.69,20.02 231.4,20.32 231.14,20.32 230.08,21.38 v1(230.08,21.93) ; CL3.2 v1(263.87,70.7) ; RN17.1 v1(230.05,17.95) ; CC324.2 128.52,58.91 128.88,59.28 v1(128.88,59.38) ; CE11.2 v1(258.14,55.79) ; v1(128.31,43.56) 128.34,43.58 RC6.2 RC7.2 ; PC1153.2 v1(127.41,67.64)
  TOP w0.406: v1(70.67,59.71) 70.48,59.53 PC618.1 ; QE2.4 249.82,48.73 249.58,48.97 v1(249.58,49.2) 249.58,49.73 249.28,50.03 QE2.1 ; v1(126.57,42.34) 126.55,42.31 126.55,41.89 126.11,41.45 CC178.2 125.15,41.45 CZ102.2 ; 154.66,27.86 156.01,27.86 156.6,27.27 UZ34.3 ; UE3.3 274.39,34.96 274.63,34.72 v1(274.63,34.29) ; UZ10.3 v1(280.11,67.75) ; v1(222.89,35.1) 222.89,34.39 QN4.1 ; DT40.3 13.06,71.42 v1(13.47,71.01) ; v1(39.17,66.59) 38.62,67.14 PR1222.2
  TOP w0.432: QN1.4 250.78,15.99 v1(250.68,15.88) 250.36,15.57 249.99,15.57 249.49,15.07 249.49,14.79 QN1.1 ; v1(225.94,32.63) 225.91,32.66 QN4.4
  TOP w0.457: v1(22.64,78.06) 22.55,78.15 21.8,78.15 21.62,77.97 RT416.2 ; v1(157.54,54.89) 157.79,54.89 158.12,55.22 CZ75.2 ; v1(36.49,47.09) 36.49,46.95 35.97,46.43 PC950.1 ; CC199.2 130.2,82.14 v1(130.2,82.62) ; CC266.2 145.54,37.81 v1(145.54,37.19) ; PC1134.2 92.07,56.12 92.38,56.43 v1(92.38,56.77) ; v1(128.15,77.59) 128.02,77.72 RC166.2 ; v1(130.85,60.28) 130.67,60.46 CC265.2 ; v1(261.52,36.24) 260.66,37.11 RE342.2 ; v1(219.53,29.61) 219.54,29.6 221.29,29.6 222.02,28.87 QN6.3 ; CD11.2 89.4,19.53 88.89,19.02 88.89,17.25 88.43,16.79 v1(88.28,16.79) ; PC1140.2 125.8,63.39 v1(125.33,63.39) ; PC1142.2 125.76,65.85 v1(125.31,65.85) ; CE38.2 v1(271.45,62.78) ; RZ62.2 v1(152.63,62.15)
  TOP w0.483: v1(261.6,57.98) 261.07,57.45 CE29.2
  TOP w0.508: CV14.2 79.2,97.84 v1(79.16,97.8) 79.17,97.79 QV2.3 ; v1(252.53,51.35) RE313.2 CE4.2 ; CE40.2 275.34,45.67 v1(275.92,45.67) 276.24,45.35 CE47.2 ; PQ1208.4 48.55,53.21 48.82,53.49 v1(48.82,53.51) ; v1(199.19,20.04) 198.96,20.27 CD59.2 ; QN7.3 v1(219.53,29.61) ; v1(106.07,101.04) 106.25,101.22 CC308.2 ; RN174.2 228.77,30.77 v1(229.11,30.43) ; CE12.2 279.17,54.85 279.32,54.7 279.32,54.68 v1(279.32,54.68) 279.53,54.46 CE10.2 ; CD7.2 88.99,13.11 v1(89.52,13.11) 89.85,12.77 CD14.2 ; RV78.2 v1(176.38,84.5) ; CE28.2 v1(257.23,57.45) ; v1(21.01,58.28) 21.28,58.01 CT86.2 ; CZ128.2 244.71,33.57 v1(245.17,33.57) ; v1(273.11,27.76) 273.13,27.73 273.23,27.73 273.61,27.35 RA35.2 ; v1(158.23,13.21) 158.76,13.21 158.99,12.98 CD45.2 ; v1(256.95,26.92) 257.19,26.68 CA48.2 ; RA51.2 273.61,20.39 v1(274.07,19.94) 274.5,20.37 CA72.2 ; CT87.2 21.09,59.84 v1(21.05,59.8) ; PC206.2 v1(55.56,64.51) ; v1(49.38,38.83) 49.77,39.22 PC139.2 ; RE86.2 231.82,12.96 v1(232.29,13.44) ; v1(47.55,45.56) PC152.2 ; PC217.2 57.76,50.31 v1(57.76,51.38) 58.04,51.66 PC216.2 ; CE60.2 CE59.2 241.76,50.26 241.76,50.95 v1(241.79,50.97) ; CE64.2 262.68,61.96 v1(263.17,62.45) ; CC322.2 125.69,52.37 v1(125.27,52.79) ; v1(48.38,45.26) 48.51,45.13 PC138.2 ; v1(37.11,17.22) 37.11,16.83 PD2.1 ; v1(158.63,84.31) RV84.2 RV86.2 ; v1(172.42,86.43) 172.7,86.43 173.61,85.52 CV82.2 ; CA62.2 275.39,20.39 v1(275.85,19.94) 276.28,20.37 RA45.2 ; CE62.2 255.39,50.42 v1(254.95,50.86) 255.38,51.29 CE54.2 ; PD1.1 v1(34.79,15.73) ; RC338.2 149.51,59 v1(149.88,59.37) ; v1(83.33,16.79) 83.22,16.79 82.64,17.37 CD1.2 ; RD31.2 RD29.2 v1(43.74,13.97) ; v1(19.23,71.6) 19.44,71.4 RT305.2 RT136.2 ; v1(23.27,19.43) 24.25,19.43 CI46.2 ; PR930.2 26.69,46.91 PC938.2 26.68,47.55 PR953.2 26.45,47.96 26.98,48.5 PU903.3 27.01,48.8 v1(27.85,48.8) ; CT93.2 17.38,55.55 v1(17.89,55.04) ; v1(278.44,43.48) 278.52,43.56 CE61.2 ; CT90.2 20.38,65.88 v1(20.54,66.05) CT73.2 ; PC202.2 59.64,62.99 v1(59.72,63.06) ; CZ89.2 204.17,21.87 v1(203.69,22.35) 203.23,21.89 CZ88.2 ; v1(275.89,49.77) 275.7,49.96 RE85.2 ; PC128.2 38.56,42.02 PR116.2 38.34,41.54 v1(37.95,41.14) ; v1(44.38,10.75) CD57.2 CD58.2 ; v1(168.08,47.93) 168.18,47.93 168.69,47.42 RC411.2 ; RC75.2 148.64,36.45 v1(148.64,37.19) ; RC136.2 105.8,81.37 v1(105.8,81.96) ; PC941.2 33.08,31.11 32.44,31.75 32.44,31.92 ; RV92.2 v1(170.24,75.92) ; CD5.2 78.81,12.8 78.81,14.02 78.22,14.61 v1(77.99,14.61) ; CD47.2 192.68,18.61 v1(193.61,18.61) ; RA36.2 276.08,11.63 276.31,11.4 276.31,8.94 v1(276.1,8.74) ; CC296.2 108.81,38.94 CC177.2 CC179.2 109.24,41.11 v1(108.82,41.54) ; DA1.1 v1(283.42,8.15) ; RC1.2 135.21,65.89 v1(135.59,66.27) ; v1(67.19,94.37) 67.35,94.53 RV1.2 ; v1(152.57,65.76) 153.28,65.76 CC320.2 ; v1(145.43,13.52) 146.01,12.93 CD38.2 ; v1(279.61,25.57) 279.96,25.22 DI5.1 ; RN15.1 221.39,25.6 v1(221.16,25.6) ; CZ81.2 204.6,28.42 v1(204.27,28.75) ; RT100.2 26.19,67.78 CT84.2 v1(27.26,68.47) ; RT100.2 26.27,67.88 v1(26.27,68.43) ; RT100.2 CT74.2 CT83.2 24.38,67.81 RT96.2 ; RE550.2 256.11,43.05 RE56.2 255.63,42.57 255.63,42.34 v1(255.38,42.08) ; CT189.2 v1(10.62,74.32) v1(10.62,74.93) ; v1(58.86,71.67) 58.4,71.22 PC1213.2 ; CZ119.2 v1(230.56,44.88) ; PC605.1 v1(59.75,63.75) ; v1(289.87,48.69) 289.79,48.76 CV100.2 ; v1(56.44,64.51) 56.44,64.51 PC207.2 ; v1(104.96,78.66) 104.83,78.66 104.35,78.18 CC321.2 ; v1(246.46,18.33) RN30.2 RN52.2 ; CD26.2 CD25.2 90.96,10.38 v1(91,10.34) ; v1(275.9,53.01) 275.67,52.78 JTAG1.2 274.93,52.75 RE65.2 CE30.2 ; RL12.2 252.15,72.56 v1(251.77,72.18) ; v1(80.75,13.82) 80.58,13.82 79.85,13.09 CD3.2 ; v1(118.76,18.61) 119.01,18.36 CD18.2 CD19.2 ; CZ110.2 232.53,44.74 v1(231.96,44.74) 231.56,45.13 CZ109.2 ; RV118.2 v1(282.12,57.96) RV117.2 ; JSD1.6 v1(89.68,96.52) 89.68,95.71 90.5,94.89 90.5,94.24 90.04,93.79 89.77,93.79 89.32,93.34 QR1.3 ; RV96.2 159.24,78.38 v1(159.59,78.02) ; PR420.2 176,103.6 v1(176.28,103.32) ; v1(259.06,18) 259.83,18.78 CA53.1 ; RT377.2 RT103.2 21.62,55.34 v1(21.57,55.29) 21.57,56.16 CT85.2 ; CZ86.2 201.38,23.67 v1(201.55,23.85) ; CZ86.2 CZ85.2 ; CZ86.2 CZ87.2 ; RV90.2 165.92,75.92 v1(166.17,75.66) ; PC1211.2 52.61,74.38 PR1246.2 v1(51.57,74.39) 51.58,74.38 PQ1212.3 ; v1(70.92,73.01) 70.59,73.34 PC631.2 70.03,73.35 70.03,73.96 69.78,74.21 PC652.2 ; CZ130.2 239.55,10.71 v1(239.55,9.98) ; PQ1207.1 45.07,53.08 v1(45.14,53.01) ; v1(189.43,13.03) 189.43,12.58 CD41.2 ; v1(254.56,15.87) 254.92,16.23 CA33.2 ; RV116.2 v1(281.49,61.64) ; RV88.2 158.97,81.63 158.96,81.63 v1(158.96,82.47) ; QE12.3 264.81,60.46 v1(265.23,60.88) ; JSD1.15 v1(87.54,110.41) ; v1(73.56,104.19) 74.22,103.53 CV15.2 ; CD40.2 167.58,19.67 CD43.2 167.57,18.31 v1(167.07,17.81) ; CD20.2 114.88,15.69 114.88,16.51 113.96,17.43 v1(113.65,17.43) ; RV73.2 v1(165.54,89) ; QV7.3 73.29,109.33 v1(72.85,108.9) ; CR25.2 76,86.69 v1(75.7,86.99) 75.65,87.04 74.22,87.04 73.69,86.51 UV24.2 ; RC112.2 100.98,82.05 v1(100.99,82.04) 100.99,80.62 RC110.2 ; v1(172.5,105.58) 172.43,105.65 PC505.2 ; PC1180.2 92.7,58.59 93.01,58.91 v1(93.01,59.36) ; v1(69.52,102.54) 69.4,102.41 68.97,102.41 CA6.2 ; v1(162.08,77.34) 162.11,77.36 RV94.2 ; v1(134.08,10.39) 134.13,10.44 CD46.2 ; JSD1.18 v1(90.26,110.41) ; QN5.4 233.88,29.4 233.1,28.62 v1(232.59,28.62) 232.58,28.61 QN5.1 232.43,27.66 RN188.2 ; CL14.2 261.19,73.58 261.01,73.76 v1(261.01,74.21) ; v1(167.16,63.88) 167.05,63.99 CZ56.2 ; v1(279.12,45.21) 279.05,45.28 279.05,46.22 RV102.2 ; CD6.2 84.67,13.54 85.08,13.95 v1(85.61,13.95) ; CC24.2 154.91,42.99 v1(154.91,43.59) ; CE63.2 v1(275.14,59.1) ; CD12.2 77.43,12.61 v1(76.47,13.57) ; v1(39.22,46.69) 39.67,47.14 PC126.2 ; v1(247.83,53.89) 247.32,53.39 246.94,53.39 246.51,52.96 RE58.2 ; RT101.2 34.93,62.38 34.5,61.95 v1(34.32,61.95) ; PR310.2 PR302.2 v1(165.78,106.82) ; v1(30,82.11) 30.28,81.83 RT130.2 ; v1(127.56,108.25) 127.98,108.25 PC107.2 ; PC603.2 61.62,69.47 PC604.2 61.02,70.09 v1(61.02,70.15) ; RN9.1 220.32,23.21 219.16,22.04 v1(219.16,21.79) ; v1(118.33,21.55) 118.64,21.25 CD21.2 ; CA46.2 258.92,29.8 259.39,30.27 v1(259.39,30.55) ; v1(251.54,23.57) 251.9,23.21 RN54.2 ; CA5.2 68.97,101.39 69.19,101.39 v1(69.45,101.65) ; PC1139.2 126.99,64.95 126.8,64.75 v1(126.8,64.25) ; PC949.1 v1(28.14,50.48) ; v1(163.75,14.79) 163.89,14.79 164.81,13.87 CD39.2 ; RT144.2 RT304.2 19.21,72.74 v1(19.13,72.82) ; RN19.2 225.35,14.95 v1(224.9,14.49) ; v1(127.56,107.3) 127.92,107.3 PC108.2 ; v1(44.28,56.97) 43.88,56.57 43.88,54.88 43.37,54.38 PQ1207.4 ; RN5.2 239.98,16.67 240.49,17.18 v1(240.49,17.5) 240.48,17.51 CN31.2 ; v1(268.05,12.82) CA65.2 CA66.2 ; RD7.2 v1(118.33,11.31) ; CZ3.2 49.76,96.14 v1(50.35,95.55) 51,94.9 PC5.2 ; DA3.1 v1(283.47,9.88) ; v1(225.94,32.63) 226.06,32.51 RN183.2 ; RN60.2 v1(232.2,16.33) ; v1(18.98,49.6) 18.98,51.23 19.34,51.59 QV4.3 ; v1(248.09,32.81) 247.45,33.45 CZ127.2 CZ126.2 ; RT82.2 33.1,68.7 v1(33.1,69.03) ; CL18.2 v1(280.47,88.34) ; PQ3.3 v1(44.08,81.05) ; v1(44.08,81.05) 43.08,81.05 PR8.1 ; v1(44.08,81.05) 44.08,80.99 44.32,80.75 PC2.1 ; CC217.2 CC215.2 126.03,59.48 CC288.2 ; v1(142.74,41.46) 142.46,41.18 RC48.2 ; CD15.2 85.84,12.35 86.36,12.87 86.36,13 v1(87.09,13.72) ; UI1.2 26.12,17.6 v1(25.84,17.32) ; RT81.2 v1(34.93,66.52) ; v1(36.5,22.02) PC937.1 ; CD13.2 75.58,18.75 v1(75.66,18.67) ; RV75.2 v1(168.97,88.39) ; PR647.1 74.92,63.23 76.1,63.23 v1(76.14,63.27) ; v1(80,18.04) 80.43,18.04 81.57,19.18 CD9.2 ; CE8.2 v1(272.34,38.91) ; v1(49.25,45.26) 49.38,45.13 PC137.2 ; CE57.2 254.56,37.66 254.23,37.99 v1(254.23,38.38) ; CV104.2 CV105.2 278.4,52.03 v1(278.31,52.12) ; v1(124.68,57) 124.71,57.02 124.71,57.62 CC250.2 ; v1(160.96,102.87) 160.72,103.11 PC302.2 ; v1(209,32.76) 209.07,32.69 CZ117.2 ; PU503.4 215.82,12.25 215.8,12.22 v1(215.8,12.19) ; v1(279.1,34.92) CZ21.2 CZ19.2 ; RV82.2 v1(158.63,85.26) ; CR1.2 80.88,94.48 v1(80.48,94.87) ; PR927.2 22.59,46.97 PQ909.3 ; CZ200.2 v1(62.48,102.27) ; CE52.2 276.99,42.05 276.67,41.73 v1(276.28,41.73) ; RC436.1 100.13,77.52 v1(100.61,77.52) ; PR1249.2 48.32,73.76 v1(48.52,73.96) ; PC7.2 v1(52.72,97.13) ; RL13.2 v1(264.17,79.14) ; JSD1.11 80.95,97.89 v1(81.28,97.89) ; v1(26.5,50.64) 26.5,51 26.87,51.38 PR961.2 ; RC220.2 144.73,37 v1(144.92,37.19) ; DI2.1 20.6,20.21 v1(21.06,19.76) ; v1(285.27,55.58) 285.27,56.15 CV131.2 ; CI6.2 v1(31.45,16.46) ; v1(108.03,81.76) CC304.2 RC86.2 ; CD44.2 154.68,12.83 v1(154.68,14.13) ; v1(230.08,21.93) 229.61,22.4 RN13.1 RN21.2 ; PC140.2 v1(48.19,39.42) ; v1(113.09,109.9) 114.43,108.56 CZ39.2 ; YL1.2 v1(260.97,75.02) ; PC1212.2 54.75,70.35 PR1247.2 54.75,69.94 v1(55.43,69.26) ; v1(278.31,50.21) CV106.2 ; JSD1.21 v1(92.99,110.41) ; PC662.2 78.76,61.35 v1(78.68,61.27) ; v1(237.68,16.84) 237.41,17.12 RN72.2 ; CD61.2 141.14,10.67 v1(141.03,10.57) ; DV5.1 v1(290,60.12) ; RN61.2 241.06,19.94 v1(241.36,20.23) ; v1(209.02,31.4) 209.02,31.42 209.52,31.92 CZ116.2 ; v1(264.77,77.22) YL1.4 ; v1(22.38,74.21) 22.38,74.88 22.1,75.15 RT307.2 RT142.2 ; CD36.2 162.4,12.96 161.35,14 v1(160.69,14) ; v1(122.98,62.84) 123.29,62.84 PC1075.2 ; CI45.2 v1(23.68,18.78) ; RC163.2 91.46,68.23 v1(91.99,68.77) ; v1(60.13,83.49) 60.74,82.87 PQ7.3 61,82.87 61.92,81.95 PR24.2 ; RN11.1 RN17.1 ; 76.64,65.71 76.03,65.1 PC629.1 ; CA56.2 v1(262.51,13.06) ; CV128.2 v1(283.01,57.96) CV127.2 ; CZ20.2 278.96,39.24 v1(278.96,39.65) ; v1(282.63,42.97) 283.32,43.66 CV103.2 ; v1(128.34,56.98) 128.55,57.19 128.55,57.78 RC167.2 128.98,57.78 129.12,57.92 RC5.2 ; PR428.2 170.98,102.69 PC420.2 171.01,102.62 170.97,102.66 v1(169.98,102.66) ; RN38.2 243.36,20.85 243.11,20.6 v1(243.11,20.21) ; RE541.1 v1(275.65,66.09) ; PR514.2 PC513.2 220.83,10.19 v1(221.25,10.61) ; CD23.2 116.01,10.96 v1(116.01,10.5) 115.82,10.3 CD22.2 ; v1(62.87,84.69) 63.11,84.69 63.67,84.13 PC1217.2 63.67,83.74 PQ1.4 ; RD5.2 v1(117.49,14.81) ; CMOS1.2 153,45.23 CC25.2 152.91,45.37 v1(152.35,45.93) ; RN179.2 224.85,28.63 RN176.2 224.4,29.51 v1(224.16,29.27) ; CA61.2 254.57,20.93 v1(255.39,20.93) 255.53,20.8 CA70.2 256.3,20.71 RA62.1 CA54.2 ; RN62.2 RN31.2 236.39,16.99 v1(236.28,16.89) ; PC621.1 v1(68.64,57.96) ; CZ37.2 CZ41.2 v1(111.19,98.94) ; CV102.2 289.23,50.59 289.49,50.85 v1(289.87,50.85) ; v1(132.58,42.78) 132.71,42.78 133.33,43.4 CC213.2 133.29,43.69 RC88.2 RC89.2 ; v1(120.29,52.79) 120.14,52.95 CC297.2 ; PR427.2 176,54.69 PC410.2 176,54.67 175.84,54.82 v1(175.84,55.42) ; CA31.1 259.4,21.61 v1(260.18,21.61) ; RN41.2 RN39.2 244.66,18.79 v1(244.28,18.41) ; v1(247.65,42.35) QC6.3 248.83,42.35 249.32,41.87 CC340.2 ; CD10.2 91.02,17.43 v1(90.86,17.27) ; CN16.2 227.7,25.09 227.7,26.65 v1(227.89,26.84) ; PC1.2 v1(45.84,22.08) ; CD4.2 82.39,14.15 81.8,14.73 v1(81.47,14.73) ; CV130.2 v1(285.04,60.12) ; v1(259.03,62.71) 259.53,62.22 QE17.3 ; RD16.2 91.85,14.58 91.53,14.89 91.53,15.21 91.03,15.72 v1(90.83,15.72) ; RE55.2 v1(256.14,55.9) ; RE77.2 v1(271.45,61.9) ; CL12.2 v1(258.94,66.34) ; CV101.2 v1(289.87,51.48) ; CE31.2 v1(269.73,56.41) ; v1(254.98,52.03) 255.13,52.17 RE20.2 ; v1(171.96,104.75) 171.55,105.16 PR505.2 ; RV80.2 v1(158.63,86.22) ; JSD1.10 94.65,98.36 94.14,98.87 v1(94.14,99.54) ; v1(129.54,61.05) 129.54,60.65 CC313.2 ; PQ1214.1 v1(42.91,76.94) ; CC325.2 133.48,78.96 133.02,79.42 133.02,80.08 v1(132.31,80.79) ; CZ80.2 201.71,28.14 v1(201.71,28.85) ; CV96.2 v1(170.41,77.95) ; v1(287.33,50.21) 287.89,49.65 CV135.2 ; CE65.2 v1(256.39,61.26) ; PR1219.2 55.62,80.53 v1(55.39,80.31) 55.34,80.26 PC1206.2 ; v1(27.7,67.08) 28.13,67.08 CT71.2 ; CE14.2 v1(263.45,57.96) ; v1(40.44,88.57) 40.35,88.66 PD4.1 ; v1(289.87,46.91) RV123.1 ; v1(229.04,44.12) 229.37,44.45 CZ124.2 ; v1(21.39,68.98) 21.7,69.29 RT303.2 RT248.2 ; CT117.2 v1(24.31,82.11) ; v1(158.34,43.59) 158.34,41.74 156.32,39.72 RC349.2 ; PC3.2 48.86,83.07 48.7,83.23 v1(48.67,83.23) ; v1(249.22,28.81) 248.4,28.81 248.01,28.42 RN53.2 ; CT82.2 24.25,56.63 v1(23.68,56.05) ; v1(267.49,27.72) 267.49,26.46 266.99,25.95 CA22.2 ; DV6.1 v1(290,56.18) ; JSD1.12 84.37,111.3 84.18,111.11 v1(83.52,111.11) ; v1(290.5,53.64) CV133.2 ; QZ4.3 v1(242.99,48.97) ; PC668.2 v1(67.06,46.81) ; v1(32.41,37.28) 32.58,37.28 32.73,37.13 32.74,37.13 33.43,36.45 33.43,35.61 ; PC151.2 v1(166.81,107.29) ; RZ334.2 v1(117.18,98.94) ; RV76.2 v1(176.38,82.47) ; CV132.2 v1(290.5,52.37) ; RC3.2 v1(138.99,80.18) ; PC602.2 v1(58.35,66.41) ; v1(267.21,41.39) 267.21,40.84 RE95.1 ; CV81.2 v1(159.24,87.8) ; CR26.2 77.86,86.69 v1(78.16,86.99) ; PC203.2 PC231.2 57.59,62.43 v1(57.15,62) ; CZ197.2 236.55,42.54 237.36,43.34 237.84,43.34 CE22.2 238.15,43.89 v1(237.8,44.24) ; v1(172.98,104.29) PR419.2 ; CZ40.2 v1(114.64,98.97) ; PC645.2 v1(75.79,69.22) ; v1(174.22,79.85) RV97.2 ; UT7.2 v1(16.59,66.09) ; CR18.1 86.05,95.11 85.42,95.73 v1(85.42,95.93) ; v1(127.56,105.52) 127.92,105.52 PC106.2 ; CE16.2 v1(269.36,60.82) ; PR516.2 214.33,12.52 v1(214.84,12.01) ; CE66.2 v1(264.67,39.06) ; CV126.2 v1(283.01,62.25) ; CV129.2 v1(285.04,62.4) ; RL9.2 v1(261.29,64.05) ; CT72.2 v1(32.54,64.73) ; v1(264.04,72.56) CL13.2
  GND1 w0.203: 123.21,22.04 H15.1 ; H15.1 124.55,22.53 ; H15.1 124.55,18.87 ; H15.1 125.89,19.36 ; H15.1 126.38,20.7 ; H15.1 122.72,20.7 ; H15.1 125.89,22.04 ; H15.1 123.21,19.36 ; 91.15,47.46 H3.1 ; H3.1 93.49,49.8 ; H3.1 88.81,49.8 ; H3.1 91.15,52.14 ; H3.1 89.45,48.1 ; H3.1 92.85,51.5 ; H3.1 92.85,48.1 ; H3.1 89.45,51.5 ; 284.9,16.22 JUSB1.10 ; JUSB1.10 283.57,17.88 ; JUSB1.10 284.9,17.88 ; JUSB1.10 286.23,17.88 ; JUSB1.10 283.57,16.22 ; JUSB1.10 286.23,17.05 ; JUSB1.10 286.23,16.22 ; JUSB1.10 283.57,17.05 ; 4.81,63.77 H19.1 ; H19.1 4.81,61.09 ; H19.1 7.49,61.09 ; H19.1 4.32,62.43 ; H19.1 6.15,64.26 ; H19.1 7.98,62.43 ; H19.1 7.49,63.77 ; H19.1 6.15,60.6 ; JHDMI1.2 13.06,44.61 ; JHDMI1.2 12.02,44.15 ; JHDMI1.2 13.18,44.15 ; JHDMI1.2 12.14,44.61 ; JHDMI1.2 13.06,43.69 ; JHDMI1.2 12.14,43.69 ; JHDMI1.2 12.6,43.57 ; H16.1 126.48,13.2 ; H16.1 123.13,14.62 ; H16.1 124.55,15.13 ; H16.1 123.13,11.78 ; H16.1 122.62,13.2 ; H16.1 124.55,11.27 ; H16.1 125.97,11.78 ; H16.1 125.97,14.62 ; JCRT1.16 295.63,42.87 ; JCRT1.16 292.37,42.15 ; JCRT1.16 292.37,41.43 ; JCRT1.16 295.63,42.15 ; JCRT1.16 294,42.87 ; JCRT1.16 295.63,41.43 ; JCRT1.16 294,41.43 ; JCRT1.16 292.37,42.87 ; JUSB1.4 285.84,26.31 ; JUSB1.4 285.2,26.12 ; JUSB1.4 284.57,27.58 ; JUSB1.4 284.37,26.95 ; JUSB1.4 285.2,27.78 ; JUSB1.4 284.57,26.31 ; H18.1 7.49,79.19 ; H18.1 4.81,81.87 ; H18.1 4.32,80.53 ; H18.1 7.98,80.53 ; H18.1 4.81,79.19 ; H18.1 7.49,81.87 ; H18.1 6.15,78.7 ; H18.1 6.15,82.36 ; JUSB2.12 17.53,20.13 ; JUSB2.12 17.53,18.47 ; JUSB2.12 16.2,18.47 ; JUSB2.12 17.53,19.3 ; JUSB2.12 14.87,19.3 ; JUSB2.12 14.87,18.47 ; JUSB2.12 14.87,20.13 ; JUSB2.12 16.2,20.13 ; 293.24,57.92 JCRT1.6 ; JCRT1.6 293.38,58.44 ; JCRT1.6 293.9,58.59 ; JCRT1.6 293.38,57.41 ; JCRT1.6 294.42,58.44 ; H11.1 297.54,36.75 ; H11.1 295.3,35.26 ; H11.1 297.54,38.24 ; H11.1 293.06,36.75 ; H11.1 293.06,38.24 ; H11.1 297.54,35.26 ; H11.1 293.06,35.26 ; H11.1 295.3,38.24 ; 15.27,22.84 JUSB2.4 ; JUSB2.4 15.9,21.37 ; JUSB2.4 16.73,22.2 ; JUSB2.4 16.54,22.84 ; JUSB2.4 16.54,21.57 ; JUSB2.4 15.9,23.03 ; 285.87,23.45 JUSB1.7 ; JUSB1.7 286.07,22.82 ; JUSB1.7 287.34,22.82 ; JUSB1.7 286.07,24.09 ; JUSB1.7 287.34,24.09 ; JUSB1.7 286.7,22.62 ; JUSB1.7 286.7,24.28 ; 19.63,16.72 H23.1 ; H23.1 22.98,15.3 ; H23.1 21.05,17.23 ; H23.1 22.47,13.88 ; H23.1 22.47,16.72 ; H23.1 19.12,15.3 ; H23.1 21.05,13.37 ; H23.1 19.63,13.88 ; H10.1 289.39,38.09 ; H10.1 288.05,34.92 ; H10.1 289.88,36.75 ; H10.1 286.71,38.09 ; H10.1 289.39,35.41 ; H10.1 288.05,38.58 ; H10.1 286.22,36.75 ; H10.1 286.71,35.41 ; H9.1 284.89,92.26 ; H9.1 284.89,94.94 ; H9.1 285.38,93.6 ; H9.1 282.21,94.94 ; H9.1 281.72,93.6 ; H9.1 283.55,95.43 ; H9.1 283.55,91.77 ; H9.1 282.21,92.26 ; 5.77,17.17 JUSB2.13 ; JUSB2.13 6.95,17.17 ; JUSB2.13 8.13,18 ; JUSB2.13 8.13,17.17 ; JUSB2.13 5.77,18 ; 65.55,76.27 H34.1 ; H34.1 64.03,76.83 ; H34.1 67.63,78.35 ; H34.1 67.07,76.83 ; H34.1 65.55,80.43 ; H34.1 67.07,79.87 ; H34.1 63.47,78.35 ; H34.1 64.03,79.87 ; JUSB1.12 286.23,30.68 ; JUSB1.12 283.57,29.85 ; JUSB1.12 286.23,29.02 ; JUSB1.12 286.23,29.85 ; JUSB1.12 283.57,30.68 ; JUSB1.12 284.9,30.68 ; JUSB1.12 284.9,29.02 ; JUSB1.12 283.57,29.02 ; JUSBC1.2 8.23,75.8 ; JUSBC1.2 8.23,76.58 ; JUSBC1.2 5.57,76.58 ; JUSBC1.2 6.9,76.58 ; JUSBC1.2 8.23,75.02 ; JUSB2.7 15.04,25.06 ; JUSB2.7 13.77,25.06 ; JUSB2.7 14.4,24.87 ; JUSB2.7 15.04,26.33 ; JUSB2.7 13.77,26.33 ; JUSB2.7 14.4,26.53 ; JUSB2.7 15.23,25.7 ; JUSBC1.4 6.3,76.58 ; JUSBC1.4 7.03,76.58 ; JUSBC1.4 5.58,76.58 ; JUSBC1.4 7.03,74.57 ; JUSBC1.4 6.3,74.57 ; 293.24,48.76 JCRT1.10 ; JCRT1.10 293.38,49.28 ; JCRT1.10 293.38,48.25 ; 147.85,76 H2.1 ; H2.1 147.85,72.6 ; H2.1 149.55,76.64 ; H2.1 151.25,76 ; H2.1 147.21,74.3 ; H2.1 149.55,71.96 ; H2.1 151.89,74.3 ; H2.1 151.25,72.6 ; 296.83,94.38 SW1.5 ; SW1.5 296.59,93.62 ; SW1.5 297.59,92.61 ; SW1.5 296.83,92.86 ; SW1.5 298.6,93.62 ; SW1.5 297.59,94.62 ; SW1.5 298.35,94.38 ; SW1.5 298.35,92.86 ; JUSBC1.3 6.3,68.39 ; JUSBC1.3 6.3,66.38 ; JUSBC1.3 5.58,66.38 ; JUSBC1.3 7.03,66.38 ; JHDMI1.23 4.58,39.4 ; JHDMI1.23 4.58,38.37 ; JHDMI1.23 1.22,38.37 ; JHDMI1.23 1.22,39.4 ; JHDMI1.23 2.9,38.37 ; 15.55,36.22 H20.1 ; H20.1 14.21,39.39 ; H20.1 16.89,36.71 ; H20.1 16.89,39.39 ; H20.1 14.21,36.71 ; H20.1 15.55,39.88 ; H20.1 17.38,38.05 ; H20.1 13.72,38.05 ; JHDMI1.11 11.63,48.65 ; JHDMI1.11 10.47,48.65 ; JHDMI1.11 10.59,48.19 ; JHDMI1.11 11.51,48.19 ; JHDMI1.11 10.59,49.11 ; JHDMI1.11 11.51,49.11 ; JUSBC1.5 3.48,64.8 ; JUSBC1.5 0.42,65.63 ; JUSBC1.5 3.48,65.63 ; JUSBC1.5 3.48,66.46 ; JUSBC1.5 0.42,64.8 ; JUSBC1.5 1.6,66.46 ; JUSBC1.5 1.6,64.8 ; 293.38,55.12 JCRT1.7 ; JCRT1.7 293.38,56.15 ; JCRT1.7 293.24,55.63 ; 16.2,31.27 JUSB2.10 ; JUSB2.10 16.2,32.93 ; JUSB2.10 14.87,31.27 ; JUSB2.10 17.53,31.27 ; JUSB2.10 17.53,32.93 ; JUSB2.10 17.53,32.1 ; JUSB2.10 14.87,32.1 ; JUSB2.10 14.87,32.93 ; 290.53,92.86 SW1.4 ; SW1.4 290.53,94.38 ; SW1.4 292.29,93.62 ; SW1.4 291.29,94.62 ; SW1.4 292.05,92.86 ; SW1.4 292.05,94.38 ; SW1.4 290.29,93.62 ; SW1.4 291.29,92.61 ; JCRT1.5 294.42,47.1 ; JCRT1.5 293.38,48.14 ; JCRT1.5 293.24,47.62 ; JCRT1.5 293.38,47.1 ; JCRT1.5 293.9,46.96 ; 1.6,76.5 JUSBC1.6 ; JUSBC1.6 3.48,78.16 ; JUSBC1.6 3.48,76.5 ; JUSBC1.6 0.42,77.33 ; JUSBC1.6 3.48,77.33 ; JUSBC1.6 0.42,78.16 ; JUSBC1.6 1.6,78.16 ; 243.7,27.22 H7.1 ; H7.1 245.73,29.25 ; H7.1 243.7,31.28 ; H7.1 242.21,30.74 ; H7.1 245.19,30.74 ; H7.1 241.67,29.25 ; H7.1 242.21,27.76 ; H7.1 245.19,27.76 ; 292.37,61.53 JCRT1.17 ; JCRT1.17 295.63,62.25 ; JCRT1.17 295.63,62.97 ; JCRT1.17 295.63,61.53 ; JCRT1.17 294,62.97 ; JCRT1.17 292.37,62.25 ; JCRT1.17 292.37,62.97 ; JCRT1.17 294,61.53 ; 10.59,46.11 JHDMI1.5 ; JHDMI1.5 11.63,45.65 ; JHDMI1.5 11.51,46.11 ; JHDMI1.5 10.47,45.65 ; JHDMI1.5 10.59,45.19 ; JHDMI1.5 11.51,45.19 ; H14.1 151.05,107.68 ; H14.1 151.05,102.62 ; H14.1 154.09,102.62 ; H14.1 148.01,105.15 ; H14.1 154.09,107.68 ; H14.1 148.01,107.68 ; H14.1 154.09,105.15 ; H14.1 148.01,102.62 ; H4.1 151.25,48.1 ; H4.1 147.21,49.8 ; H4.1 151.25,51.5 ; H4.1 149.55,47.46 ; H4.1 147.85,48.1 ; H4.1 151.89,49.8 ; H4.1 149.55,52.14 ; H4.1 147.85,51.5 ; JSD1.23 95.7,106.47 ; JSD1.23 94.25,108.73 ; JSD1.23 95.7,108.73 ; JSD1.23 95.7,107.6 ; JSD1.23 94.98,106.47 ; JSD1.23 94.98,108.73 ; JSD1.23 94.25,107.6 ; JSD1.23 94.25,106.47 ; 9.97,41.78 JHDMI1.22 ; JHDMI1.22 11.25,40.02 ; JHDMI1.22 11.25,41.78 ; JHDMI1.22 12.53,40.02 ; JHDMI1.22 9.97,40.02 ; JHDMI1.22 12.53,40.9 ; JHDMI1.22 12.53,41.78 ; H21.1 10.34,36.75 ; H21.1 8.85,35.26 ; H21.1 7.36,36.75 ; H21.1 7.75,37.85 ; H21.1 7.75,35.65 ; H21.1 9.95,35.65 ; H21.1 8.85,38.24 ; H21.1 9.95,37.85 ; 5.77,33.4 JUSB2.11 ; JUSB2.11 6.95,34.23 ; JUSB2.11 8.13,33.4 ; JUSB2.11 5.77,34.23 ; JUSB2.11 8.13,34.23 ; 79.85,107.6 JSD1.22 ; JSD1.22 81.3,106.47 ; JSD1.22 81.3,108.73 ; JSD1.22 81.3,107.6 ; JSD1.22 80.58,106.47 ; JSD1.22 79.85,106.47 ; JSD1.22 79.85,108.73 ; JSD1.22 80.58,108.73 ; 265.97,74.45 H8.1 ; H8.1 268,76.48 ; H8.1 266.51,72.96 ; H8.1 270.03,74.45 ; H8.1 269.49,75.94 ; H8.1 266.51,75.94 ; H8.1 268,72.42 ; H8.1 269.49,72.96 ; JUSBC1.1 8.23,67.94 ; JUSBC1.1 8.23,67.16 ; JUSBC1.1 5.57,66.38 ; JUSBC1.1 6.9,66.38 ; JUSBC1.1 8.23,66.38 ; 88.81,74.3 H1.1 ; H1.1 89.45,76 ; H1.1 91.15,71.96 ; H1.1 93.49,74.3 ; H1.1 91.15,76.64 ; H1.1 92.85,76 ; H1.1 92.85,72.6 ; H1.1 89.45,72.6 ; H22.1 8.89,11.36 ; H22.1 9.38,12.7 ; H22.1 7.55,14.53 ; H22.1 8.89,14.04 ; H22.1 7.55,10.87 ; H22.1 6.21,14.04 ; H22.1 5.72,12.7 ; H22.1 6.21,11.36 ; 10.59,52.11 JHDMI1.17 ; JHDMI1.17 10.59,51.19 ; JHDMI1.17 11.63,51.65 ; JHDMI1.17 11.51,51.19 ; JHDMI1.17 10.47,51.65 ; JHDMI1.17 11.51,52.11 ; JHDMI1.20 12.53,55.4 ; JHDMI1.20 9.97,54.52 ; JHDMI1.20 11.25,54.52 ; JHDMI1.20 12.53,56.28 ; JHDMI1.20 11.25,56.28 ; JHDMI1.20 12.53,54.52 ; JHDMI1.20 9.97,56.28 ; 12.14,46.69 JHDMI1.8 ; JHDMI1.8 12.02,47.15 ; JHDMI1.8 13.18,47.15 ; JHDMI1.8 13.06,47.61 ; JHDMI1.8 12.14,47.61 ; JHDMI1.8 13.06,46.69 ; JUSB1.11 295.33,15.75 ; JUSB1.11 292.97,15.75 ; JUSB1.11 294.15,14.92 ; JUSB1.11 292.97,14.92 ; JUSB1.11 295.33,14.92 ; 293.38,52.83 JCRT1.8 ; JCRT1.8 293.38,53.86 ; JCRT1.8 293.24,53.34 ; 1.22,57.93 JHDMI1.21 ; JHDMI1.21 2.9,57.93 ; JHDMI1.21 1.22,56.9 ; JHDMI1.21 4.58,56.9 ; JHDMI1.21 4.58,57.93 ; JUSB1.13 295.33,31.15 ; JUSB1.13 294.15,31.98 ; JUSB1.13 295.33,31.98 ; JUSB1.13 292.97,31.98 ; JUSB1.13 292.97,31.15 ; 37.21,99.26 H17.1 ; H17.1 38.55,102.43 ; H17.1 39.89,101.94 ; H17.1 36.72,100.6 ; H17.1 38.55,98.77 ; H17.1 39.89,99.26 ; H17.1 37.21,101.94 ; H17.1 40.38,100.6
  IN1 w0.127: v1(139.14,70.8) 139.14,70.82 138.69,71.27 138.69,72.64 139.76,73.71 141.18,73.71 145.5,78.02 145.5,78.36 145.29,78.56 145.29,78.75 145.37,78.83 ; v1(139.14,70.8) 139.37,71.04 139.37,71.46 v1(140.97,73.05) 141.19,73.05 146.26,78.12 146.26,78.81 145.98,79.09 145.63,79.09 145.37,78.83 ; v1(139.14,70.8) 138.57,70.8 137.7,71.67 137.37,71.67 137.14,71.9 137.14,72.31 138.64,73.81 v1(138.64,74.04) 138.77,74.18 140.98,74.18 144.5,77.7 v1(144.5,77.95) 144.5,78.28 145.06,78.83 145.37,78.83
  GND2 w0.203: JUSBC1.1 8.23,67.94 ; JUSBC1.1 6.9,66.38 ; JUSBC1.1 5.57,66.38 ; JUSBC1.1 8.23,67.16 ; JUSBC1.1 8.23,66.38 ; H4.1 151.89,49.8 ; H4.1 151.25,48.1 ; H4.1 147.85,48.1 ; H4.1 151.25,51.5 ; H4.1 149.55,52.14 ; H4.1 149.55,47.46 ; H4.1 147.85,51.5 ; H4.1 147.21,49.8 ; 14.87,19.3 JUSB2.12 ; JUSB2.12 16.2,18.47 ; JUSB2.12 17.53,20.13 ; JUSB2.12 17.53,18.47 ; JUSB2.12 14.87,18.47 ; JUSB2.12 16.2,20.13 ; JUSB2.12 14.87,20.13 ; JUSB2.12 17.53,19.3 ; 286.07,22.82 JUSB1.7 ; JUSB1.7 286.7,24.28 ; JUSB1.7 286.7,22.62 ; JUSB1.7 285.87,23.45 ; JUSB1.7 286.07,24.09 ; JUSB1.7 287.34,22.82 ; JUSB1.7 287.34,24.09 ; H3.1 92.85,51.5 ; H3.1 89.45,51.5 ; H3.1 93.49,49.8 ; H3.1 91.15,47.46 ; H3.1 88.81,49.8 ; H3.1 89.45,48.1 ; H3.1 92.85,48.1 ; H3.1 91.15,52.14 ; JUSB2.10 17.53,32.93 ; JUSB2.10 17.53,31.27 ; JUSB2.10 16.2,32.93 ; JUSB2.10 14.87,32.1 ; JUSB2.10 17.53,32.1 ; JUSB2.10 16.2,31.27 ; JUSB2.10 14.87,32.93 ; JUSB2.10 14.87,31.27 ; 37.21,99.26 H17.1 ; H17.1 39.89,99.26 ; H17.1 37.21,101.94 ; H17.1 40.38,100.6 ; H17.1 38.55,102.43 ; H17.1 39.89,101.94 ; H17.1 38.55,98.77 ; H17.1 36.72,100.6 ; 284.9,29.02 JUSB1.12 ; JUSB1.12 286.23,29.85 ; JUSB1.12 283.57,30.68 ; JUSB1.12 286.23,30.68 ; JUSB1.12 283.57,29.02 ; JUSB1.12 283.57,29.85 ; JUSB1.12 286.23,29.02 ; JUSB1.12 284.9,30.68 ; H34.1 67.07,79.87 ; H34.1 64.03,76.83 ; H34.1 65.55,80.43 ; H34.1 67.63,78.35 ; H34.1 63.47,78.35 ; H34.1 65.55,76.27 ; H34.1 67.07,76.83 ; H34.1 64.03,79.87 ; JUSBC1.5 3.48,64.8 ; JUSBC1.5 1.6,64.8 ; JUSBC1.5 1.6,66.46 ; JUSBC1.5 0.42,65.63 ; JUSBC1.5 0.42,64.8 ; JUSBC1.5 3.48,65.63 ; JUSBC1.5 3.48,66.46 ; H16.1 125.97,11.78 ; H16.1 122.62,13.2 ; H16.1 124.55,11.27 ; H16.1 126.48,13.2 ; H16.1 124.55,15.13 ; H16.1 125.97,14.62 ; H16.1 123.13,14.62 ; H16.1 123.13,11.78 ; JSD1.23 95.7,107.6 ; JSD1.23 95.7,106.47 ; JSD1.23 94.25,106.47 ; JSD1.23 94.25,107.6 ; JSD1.23 94.98,106.47 ; JSD1.23 94.98,108.73 ; JSD1.23 94.25,108.73 ; JSD1.23 95.7,108.73 ; H8.1 269.49,75.94 ; H8.1 266.51,75.94 ; H8.1 266.51,72.96 ; H8.1 265.97,74.45 ; H8.1 269.49,72.96 ; H8.1 268,72.42 ; H8.1 270.03,74.45 ; H8.1 268,76.48 ; SW1.4 292.29,93.62 ; SW1.4 291.29,94.62 ; SW1.4 292.05,92.86 ; SW1.4 290.53,92.86 ; SW1.4 292.05,94.38 ; SW1.4 291.29,92.61 ; SW1.4 290.53,94.38 ; SW1.4 290.29,93.62 ; 151.05,102.62 H14.1 ; H14.1 148.01,102.62 ; H14.1 154.09,105.15 ; H14.1 154.09,107.68 ; H14.1 148.01,105.15 ; H14.1 154.09,102.62 ; H14.1 151.05,107.68 ; H14.1 148.01,107.68 ; 14.21,36.71 H20.1 ; H20.1 16.89,36.71 ; H20.1 14.21,39.39 ; H20.1 15.55,39.88 ; H20.1 17.38,38.05 ; H20.1 16.89,39.39 ; H20.1 13.72,38.05 ; H20.1 15.55,36.22 ; JHDMI1.2 13.06,43.69 ; JHDMI1.2 13.06,44.61 ; JHDMI1.2 12.02,44.15 ; JHDMI1.2 12.14,43.69 ; JHDMI1.2 13.18,44.15 ; JHDMI1.2 12.14,44.61 ; JHDMI1.2 12.6,43.57 ; H9.1 284.89,94.94 ; H9.1 285.38,93.6 ; H9.1 284.89,92.26 ; H9.1 283.55,95.43 ; H9.1 282.21,92.26 ; H9.1 281.72,93.6 ; H9.1 283.55,91.77 ; H9.1 282.21,94.94 ; H21.1 8.85,38.24 ; H21.1 7.75,37.85 ; H21.1 7.75,35.65 ; H21.1 9.95,37.85 ; H21.1 7.36,36.75 ; H21.1 10.34,36.75 ; H21.1 9.95,35.65 ; H21.1 8.85,35.26 ; 10.59,52.11 JHDMI1.17 ; JHDMI1.17 10.59,51.19 ; JHDMI1.17 11.51,51.19 ; JHDMI1.17 11.51,52.11 ; JHDMI1.17 10.47,51.65 ; JHDMI1.17 11.63,51.65 ; 123.21,19.36 H15.1 ; H15.1 122.72,20.7 ; H15.1 124.55,18.87 ; H15.1 125.89,22.04 ; H15.1 124.55,22.53 ; H15.1 125.89,19.36 ; H15.1 123.21,22.04 ; H15.1 126.38,20.7 ; JCRT1.17 295.63,61.53 ; JCRT1.17 294,62.97 ; JCRT1.17 292.37,62.25 ; JCRT1.17 292.37,62.97 ; JCRT1.17 295.63,62.25 ; JCRT1.17 292.37,61.53 ; JCRT1.17 294,61.53 ; JCRT1.17 295.63,62.97 ; H19.1 7.49,61.09 ; H19.1 4.81,61.09 ; H19.1 6.15,60.6 ; H19.1 7.98,62.43 ; H19.1 6.15,64.26 ; H19.1 7.49,63.77 ; H19.1 4.81,63.77 ; H19.1 4.32,62.43 ; 286.22,36.75 H10.1 ; H10.1 288.05,38.58 ; H10.1 289.39,38.09 ; H10.1 289.39,35.41 ; H10.1 286.71,38.09 ; H10.1 288.05,34.92 ; H10.1 286.71,35.41 ; H10.1 289.88,36.75 ; 5.58,76.58 JUSBC1.4 ; JUSBC1.4 7.03,74.57 ; JUSBC1.4 6.3,74.57 ; JUSBC1.4 6.3,76.58 ; JUSBC1.4 7.03,76.58 ; JSD1.22 81.3,107.6 ; JSD1.22 81.3,108.73 ; JSD1.22 79.85,107.6 ; JSD1.22 80.58,108.73 ; JSD1.22 79.85,106.47 ; JSD1.22 79.85,108.73 ; JSD1.22 81.3,106.47 ; JSD1.22 80.58,106.47 ; JUSB2.11 8.13,33.4 ; JUSB2.11 5.77,34.23 ; JUSB2.11 5.77,33.4 ; JUSB2.11 6.95,34.23 ; JUSB2.11 8.13,34.23 ; H22.1 9.38,12.7 ; H22.1 5.72,12.7 ; H22.1 8.89,11.36 ; H22.1 6.21,14.04 ; H22.1 8.89,14.04 ; H22.1 7.55,10.87 ; H22.1 7.55,14.53 ; H22.1 6.21,11.36 ; JUSB2.4 15.9,23.03 ; JUSB2.4 16.54,22.84 ; JUSB2.4 16.54,21.57 ; JUSB2.4 15.9,21.37 ; JUSB2.4 16.73,22.2 ; JUSB2.4 15.27,22.84 ; JUSBC1.6 1.6,78.16 ; JUSBC1.6 3.48,77.33 ; JUSBC1.6 3.48,76.5 ; JUSBC1.6 1.6,76.5 ; JUSBC1.6 0.42,78.16 ; JUSBC1.6 3.48,78.16 ; JUSBC1.6 0.42,77.33 ; JUSB2.7 15.04,26.33 ; JUSB2.7 13.77,25.06 ; JUSB2.7 15.23,25.7 ; JUSB2.7 14.4,26.53 ; JUSB2.7 13.77,26.33 ; JUSB2.7 15.04,25.06 ; JUSB2.7 14.4,24.87 ; JUSB2.13 8.13,17.17 ; JUSB2.13 5.77,18 ; JUSB2.13 6.95,17.17 ; JUSB2.13 8.13,18 ; JUSB2.13 5.77,17.17 ; 10.59,46.11 JHDMI1.5 ; JHDMI1.5 11.63,45.65 ; JHDMI1.5 10.47,45.65 ; JHDMI1.5 11.51,45.19 ; JHDMI1.5 10.59,45.19 ; JHDMI1.5 11.51,46.11 ; JUSB1.13 294.15,31.98 ; JUSB1.13 295.33,31.15 ; JUSB1.13 292.97,31.15 ; JUSB1.13 292.97,31.98 ; JUSB1.13 295.33,31.98 ; 243.7,27.22 H7.1 ; H7.1 245.19,30.74 ; H7.1 242.21,30.74 ; H7.1 243.7,31.28 ; H7.1 242.21,27.76 ; H7.1 241.67,29.25 ; H7.1 245.19,27.76 ; H7.1 245.73,29.25 ; JUSB1.10 286.23,16.22 ; JUSB1.10 283.57,16.22 ; JUSB1.10 283.57,17.05 ; JUSB1.10 286.23,17.05 ; JUSB1.10 286.23,17.88 ; JUSB1.10 284.9,17.88 ; JUSB1.10 283.57,17.88 ; JUSB1.10 284.9,16.22 ; 292.37,41.43 JCRT1.16 ; JCRT1.16 295.63,41.43 ; JCRT1.16 294,41.43 ; JCRT1.16 294,42.87 ; JCRT1.16 295.63,42.15 ; JCRT1.16 292.37,42.15 ; JCRT1.16 295.63,42.87 ; JCRT1.16 292.37,42.87 ; JHDMI1.11 11.51,48.19 ; JHDMI1.11 10.59,49.11 ; JHDMI1.11 10.59,48.19 ; JHDMI1.11 11.51,49.11 ; JHDMI1.11 10.47,48.65 ; JHDMI1.11 11.63,48.65 ; H1.1 92.85,72.6 ; H1.1 88.81,74.3 ; H1.1 93.49,74.3 ; H1.1 89.45,72.6 ; H1.1 92.85,76 ; H1.1 89.45,76 ; H1.1 91.15,76.64 ; H1.1 91.15,71.96 ; 293.38,48.14 JCRT1.5 ; JCRT1.5 293.9,46.96 ; JCRT1.5 293.24,47.62 ; JCRT1.5 293.38,47.1 ; JCRT1.5 294.42,47.1 ; 147.85,72.6 H2.1 ; H2.1 149.55,71.96 ; H2.1 151.25,72.6 ; H2.1 151.25,76 ; H2.1 147.21,74.3 ; H2.1 147.85,76 ; H2.1 151.89,74.3 ; H2.1 149.55,76.64 ; 5.58,66.38 JUSBC1.3 ; JUSBC1.3 7.03,66.38 ; JUSBC1.3 6.3,68.39 ; JUSBC1.3 6.3,66.38 ; H18.1 6.15,82.36 ; H18.1 4.81,79.19 ; H18.1 7.49,79.19 ; H18.1 4.81,81.87 ; H18.1 4.32,80.53 ; H18.1 6.15,78.7 ; H18.1 7.49,81.87 ; H18.1 7.98,80.53 ; H23.1 22.47,16.72 ; H23.1 19.63,13.88 ; H23.1 22.98,15.3 ; H23.1 19.12,15.3 ; H23.1 21.05,13.37 ; H23.1 21.05,17.23 ; H23.1 22.47,13.88 ; H23.1 19.63,16.72 ; JCRT1.6 294.42,58.44 ; JCRT1.6 293.9,58.59 ; JCRT1.6 293.38,57.41 ; JCRT1.6 293.24,57.92 ; JCRT1.6 293.38,58.44 ; JHDMI1.20 11.25,56.28 ; JHDMI1.20 11.25,54.52 ; JHDMI1.20 12.53,54.52 ; JHDMI1.20 12.53,56.28 ; JHDMI1.20 9.97,54.52 ; JHDMI1.20 9.97,56.28 ; JHDMI1.20 12.53,55.4 ; SW1.5 298.35,92.86 ; SW1.5 298.35,94.38 ; SW1.5 296.83,92.86 ; SW1.5 296.59,93.62 ; SW1.5 298.6,93.62 ; SW1.5 296.83,94.38 ; SW1.5 297.59,94.62 ; SW1.5 297.59,92.61 ; 9.97,41.78 JHDMI1.22 ; JHDMI1.22 11.25,41.78 ; JHDMI1.22 12.53,40.9 ; JHDMI1.22 11.25,40.02 ; JHDMI1.22 12.53,40.02 ; JHDMI1.22 9.97,40.02 ; JHDMI1.22 12.53,41.78 ; JUSBC1.2 8.23,75.02 ; JUSBC1.2 8.23,75.8 ; JUSBC1.2 6.9,76.58 ; JUSBC1.2 5.57,76.58 ; JUSBC1.2 8.23,76.58 ; 293.06,38.24 H11.1 ; H11.1 295.3,38.24 ; H11.1 297.54,35.26 ; H11.1 297.54,38.24 ; H11.1 297.54,36.75 ; H11.1 293.06,35.26 ; H11.1 293.06,36.75 ; H11.1 295.3,35.26 ; 293.24,53.34 JCRT1.8 ; JCRT1.8 293.38,53.86 ; JCRT1.8 293.38,52.83 ; JHDMI1.21 4.58,57.93 ; JHDMI1.21 1.22,56.9 ; JHDMI1.21 4.58,56.9 ; JHDMI1.21 2.9,57.93 ; JHDMI1.21 1.22,57.93 ; 2.9,38.37 JHDMI1.23 ; JHDMI1.23 1.22,38.37 ; JHDMI1.23 4.58,38.37 ; JHDMI1.23 1.22,39.4 ; JHDMI1.23 4.58,39.4 ; 293.38,49.28 JCRT1.10 ; JCRT1.10 293.24,48.76 ; JCRT1.10 293.38,48.25 ; 12.02,47.15 JHDMI1.8 ; JHDMI1.8 13.06,47.61 ; JHDMI1.8 13.06,46.69 ; JHDMI1.8 12.14,47.61 ; JHDMI1.8 13.18,47.15 ; JHDMI1.8 12.14,46.69 ; 284.37,26.95 JUSB1.4 ; JUSB1.4 285.84,26.31 ; JUSB1.4 285.2,27.78 ; JUSB1.4 284.57,26.31 ; JUSB1.4 285.2,26.12 ; JUSB1.4 284.57,27.58 ; JUSB1.11 295.33,14.92 ; JUSB1.11 295.33,15.75 ; JUSB1.11 292.97,15.75 ; JUSB1.11 294.15,14.92 ; JUSB1.11 292.97,14.92 ; 293.38,56.15 JCRT1.7 ; JCRT1.7 293.38,55.12 ; JCRT1.7 293.24,55.63
  IN3 w0.508: v1(278.26,19.94) v1(275.85,19.94) v1(274.07,19.94) 273.99,19.86 v1(273.99,17.57)
  VCC w0.203: 290.53,94.38 SW1.4 ; SW1.4 290.53,92.86 ; SW1.4 292.05,94.38 ; SW1.4 290.29,93.62 ; SW1.4 291.29,94.62 ; SW1.4 292.05,92.86 ; SW1.4 292.29,93.62 ; SW1.4 291.29,92.61 ; 282.21,94.94 H9.1 ; H9.1 285.38,93.6 ; H9.1 283.55,95.43 ; H9.1 284.89,92.26 ; H9.1 282.21,92.26 ; H9.1 283.55,91.77 ; H9.1 284.89,94.94 ; H9.1 281.72,93.6 ; JUSB2.7 15.04,26.33 ; JUSB2.7 15.23,25.7 ; JUSB2.7 14.4,26.53 ; JUSB2.7 13.77,25.06 ; JUSB2.7 13.77,26.33 ; JUSB2.7 14.4,24.87 ; JUSB2.7 15.04,25.06 ; JHDMI1.20 12.53,54.52 ; JHDMI1.20 12.53,56.28 ; JHDMI1.20 11.25,54.52 ; JHDMI1.20 9.97,56.28 ; JHDMI1.20 12.53,55.4 ; JHDMI1.20 11.25,56.28 ; JHDMI1.20 9.97,54.52 ; 6.3,74.57 JUSBC1.4 ; JUSBC1.4 6.3,76.58 ; JUSBC1.4 7.03,74.57 ; JUSBC1.4 7.03,76.58 ; JUSBC1.4 5.58,76.58 ; JHDMI1.11 11.51,48.19 ; JHDMI1.11 11.63,48.65 ; JHDMI1.11 10.59,49.11 ; JHDMI1.11 10.47,48.65 ; JHDMI1.11 10.59,48.19 ; JHDMI1.11 11.51,49.11 ; H22.1 8.89,11.36 ; H22.1 7.55,10.87 ; H22.1 7.55,14.53 ; H22.1 5.72,12.7 ; H22.1 6.21,11.36 ; H22.1 9.38,12.7 ; H22.1 8.89,14.04 ; H22.1 6.21,14.04 ; 0.42,64.8 JUSBC1.5 ; JUSBC1.5 3.48,65.63 ; JUSBC1.5 0.42,65.63 ; JUSBC1.5 1.6,66.46 ; JUSBC1.5 1.6,64.8 ; JUSBC1.5 3.48,66.46 ; JUSBC1.5 3.48,64.8 ; 4.32,62.43 H19.1 ; H19.1 7.98,62.43 ; H19.1 4.81,61.09 ; H19.1 4.81,63.77 ; H19.1 6.15,60.6 ; H19.1 6.15,64.26 ; H19.1 7.49,61.09 ; H19.1 7.49,63.77 ; JHDMI1.17 11.63,51.65 ; JHDMI1.17 11.51,52.11 ; JHDMI1.17 11.51,51.19 ; JHDMI1.17 10.59,52.11 ; JHDMI1.17 10.47,51.65 ; JHDMI1.17 10.59,51.19 ; 123.21,22.04 H15.1 ; H15.1 126.38,20.7 ; H15.1 125.89,22.04 ; H15.1 124.55,18.87 ; H15.1 124.55,22.53 ; H15.1 123.21,19.36 ; H15.1 122.72,20.7 ; H15.1 125.89,19.36 ; JUSB2.12 17.53,19.3 ; JUSB2.12 16.2,20.13 ; JUSB2.12 14.87,20.13 ; JUSB2.12 14.87,19.3 ; JUSB2.12 17.53,20.13 ; JUSB2.12 14.87,18.47 ; JUSB2.12 17.53,18.47 ; JUSB2.12 16.2,18.47 ; SW1.5 298.35,94.38 ; SW1.5 297.59,94.62 ; SW1.5 298.35,92.86 ; SW1.5 296.83,94.38 ; SW1.5 296.59,93.62 ; SW1.5 298.6,93.62 ; SW1.5 297.59,92.61 ; SW1.5 296.83,92.86 ; 0.42,78.16 JUSBC1.6 ; JUSBC1.6 3.48,78.16 ; JUSBC1.6 1.6,78.16 ; JUSBC1.6 3.48,76.5 ; JUSBC1.6 3.48,77.33 ; JUSBC1.6 1.6,76.5 ; JUSBC1.6 0.42,77.33 ; 5.57,76.58 JUSBC1.2 ; JUSBC1.2 8.23,75.8 ; JUSBC1.2 6.9,76.58 ; JUSBC1.2 8.23,75.02 ; JUSBC1.2 8.23,76.58 ; 91.15,47.46 H3.1 ; H3.1 92.85,51.5 ; H3.1 91.15,52.14 ; H3.1 89.45,48.1 ; H3.1 93.49,49.8 ; H3.1 89.45,51.5 ; H3.1 92.85,48.1 ; H3.1 88.81,49.8 ; 14.21,36.71 H20.1 ; H20.1 15.55,39.88 ; H20.1 16.89,39.39 ; H20.1 13.72,38.05 ; H20.1 15.55,36.22 ; H20.1 14.21,39.39 ; H20.1 16.89,36.71 ; H20.1 17.38,38.05 ; 16.2,31.27 JUSB2.10 ; JUSB2.10 17.53,31.27 ; JUSB2.10 14.87,32.93 ; JUSB2.10 17.53,32.1 ; JUSB2.10 16.2,32.93 ; JUSB2.10 17.53,32.93 ; JUSB2.10 14.87,32.1 ; JUSB2.10 14.87,31.27 ; 122.62,13.2 H16.1 ; H16.1 123.13,14.62 ; H16.1 125.97,11.78 ; H16.1 125.97,14.62 ; H16.1 124.55,15.13 ; H16.1 126.48,13.2 ; H16.1 123.13,11.78 ; H16.1 124.55,11.27 ; JUSB2.11 8.13,34.23 ; JUSB2.11 5.77,33.4 ; JUSB2.11 6.95,34.23 ; JUSB2.11 8.13,33.4 ; JUSB2.11 5.77,34.23 ; JUSB2.4 16.73,22.2 ; JUSB2.4 16.54,22.84 ; JUSB2.4 15.9,23.03 ; JUSB2.4 15.9,21.37 ; JUSB2.4 16.54,21.57 ; JUSB2.4 15.27,22.84 ; H21.1 8.85,38.24 ; H21.1 9.95,35.65 ; H21.1 7.36,36.75 ; H21.1 9.95,37.85 ; H21.1 7.75,35.65 ; H21.1 10.34,36.75 ; H21.1 8.85,35.26 ; H21.1 7.75,37.85 ; H18.1 7.49,81.87 ; H18.1 7.98,80.53 ; H18.1 7.49,79.19 ; H18.1 6.15,78.7 ; H18.1 4.32,80.53 ; H18.1 4.81,79.19 ; H18.1 4.81,81.87 ; H18.1 6.15,82.36 ; 6.9,66.38 JUSBC1.1 ; JUSBC1.1 5.57,66.38 ; JUSBC1.1 8.23,67.16 ; JUSBC1.1 8.23,66.38 ; JUSBC1.1 8.23,67.94 ; 6.95,17.17 JUSB2.13 ; JUSB2.13 8.13,17.17 ; JUSB2.13 5.77,17.17 ; JUSB2.13 5.77,18 ; JUSB2.13 8.13,18 ; JHDMI1.22 12.53,40.02 ; JHDMI1.22 12.53,40.9 ; JHDMI1.22 9.97,40.02 ; JHDMI1.22 9.97,41.78 ; JHDMI1.22 11.25,41.78 ; JHDMI1.22 11.25,40.02 ; JHDMI1.22 12.53,41.78 ; JHDMI1.2 13.18,44.15 ; JHDMI1.2 13.06,44.61 ; JHDMI1.2 12.6,43.57 ; JHDMI1.2 12.14,43.69 ; JHDMI1.2 12.02,44.15 ; JHDMI1.2 13.06,43.69 ; JHDMI1.2 12.14,44.61 ; 21.05,13.37 H23.1 ; H23.1 22.98,15.3 ; H23.1 19.12,15.3 ; H23.1 19.63,13.88 ; H23.1 22.47,16.72 ; H23.1 21.05,17.23 ; H23.1 19.63,16.72 ; H23.1 22.47,13.88 ; 1.22,38.37 JHDMI1.23 ; JHDMI1.23 4.58,39.4 ; JHDMI1.23 2.9,38.37 ; JHDMI1.23 1.22,39.4 ; JHDMI1.23 4.58,38.37 ; JHDMI1.8 13.18,47.15 ; JHDMI1.8 13.06,46.69 ; JHDMI1.8 12.14,47.61 ; JHDMI1.8 12.14,46.69 ; JHDMI1.8 13.06,47.61 ; JHDMI1.8 12.02,47.15 ; 10.59,46.11 JHDMI1.5 ; JHDMI1.5 10.59,45.19 ; JHDMI1.5 11.51,46.11 ; JHDMI1.5 11.63,45.65 ; JHDMI1.5 10.47,45.65 ; JHDMI1.5 11.51,45.19 ; 1.22,57.93 JHDMI1.21 ; JHDMI1.21 2.9,57.93 ; JHDMI1.21 4.58,57.93 ; JHDMI1.21 4.58,56.9 ; JHDMI1.21 1.22,56.9 ; JUSBC1.3 6.3,68.39 ; JUSBC1.3 7.03,66.38 ; JUSBC1.3 5.58,66.38 ; JUSBC1.3 6.3,66.38
  IN4 w0.254: v1(115.42,67.61) 115.42,67.38 115.07,67.03 111.33,67.03 109.7,65.4 108.54,65.4 108.44,65.3 98.58,65.3 98.35,65.07 94.22,65.07 93.63,65.66 93.07,65.66 v1(92.97,65.76)
  GND3 w0.203: JUSB1.13 295.33,31.98 ; JUSB1.13 292.97,31.98 ; JUSB1.13 294.15,31.98 ; JUSB1.13 295.33,31.15 ; JUSB1.13 292.97,31.15 ; 10.59,48.19 JHDMI1.11 ; JHDMI1.11 10.47,48.65 ; JHDMI1.11 11.63,48.65 ; JHDMI1.11 10.59,49.11 ; JHDMI1.11 11.51,48.19 ; JHDMI1.11 11.51,49.11 ; 38.55,98.77 H17.1 ; H17.1 37.21,101.94 ; H17.1 39.89,99.26 ; H17.1 38.55,102.43 ; H17.1 36.72,100.6 ; H17.1 40.38,100.6 ; H17.1 39.89,101.94 ; H17.1 37.21,99.26 ; 293.06,36.75 H11.1 ; H11.1 297.54,35.26 ; H11.1 293.06,35.26 ; H11.1 293.06,38.24 ; H11.1 297.54,38.24 ; H11.1 297.54,36.75 ; H11.1 295.3,35.26 ; H11.1 295.3,38.24 ; H4.1 151.25,48.1 ; H4.1 147.21,49.8 ; H4.1 149.55,47.46 ; H4.1 147.85,48.1 ; H4.1 149.55,52.14 ; H4.1 151.89,49.8 ; H4.1 151.25,51.5 ; H4.1 147.85,51.5 ; 290.29,93.62 SW1.4 ; SW1.4 291.29,92.61 ; SW1.4 292.29,93.62 ; SW1.4 291.29,94.62 ; SW1.4 292.05,94.38 ; SW1.4 290.53,94.38 ; SW1.4 292.05,92.86 ; SW1.4 290.53,92.86 ; H3.1 91.15,52.14 ; H3.1 88.81,49.8 ; H3.1 89.45,51.5 ; H3.1 92.85,48.1 ; H3.1 92.85,51.5 ; H3.1 89.45,48.1 ; H3.1 91.15,47.46 ; H3.1 93.49,49.8 ; 241.67,29.25 H7.1 ; H7.1 242.21,30.74 ; H7.1 245.73,29.25 ; H7.1 243.7,31.28 ; H7.1 243.7,27.22 ; H7.1 245.19,27.76 ; H7.1 242.21,27.76 ; H7.1 245.19,30.74 ; JUSB1.12 286.23,30.68 ; JUSB1.12 286.23,29.02 ; JUSB1.12 284.9,29.02 ; JUSB1.12 286.23,29.85 ; JUSB1.12 283.57,30.68 ; JUSB1.12 283.57,29.85 ; JUSB1.12 283.57,29.02 ; JUSB1.12 284.9,30.68 ; JHDMI1.20 12.53,55.4 ; JHDMI1.20 9.97,54.52 ; JHDMI1.20 11.25,56.28 ; JHDMI1.20 12.53,54.52 ; JHDMI1.20 9.97,56.28 ; JHDMI1.20 11.25,54.52 ; JHDMI1.20 12.53,56.28 ; 12.6,43.57 JHDMI1.2 ; JHDMI1.2 13.06,43.69 ; JHDMI1.2 12.14,44.61 ; JHDMI1.2 13.06,44.61 ; JHDMI1.2 13.18,44.15 ; JHDMI1.2 12.14,43.69 ; JHDMI1.2 12.02,44.15 ; H9.1 285.38,93.6 ; H9.1 283.55,95.43 ; H9.1 281.72,93.6 ; H9.1 282.21,94.94 ; H9.1 284.89,94.94 ; H9.1 284.89,92.26 ; H9.1 283.55,91.77 ; H9.1 282.21,92.26 ; H16.1 125.97,14.62 ; H16.1 126.48,13.2 ; H16.1 124.55,15.13 ; H16.1 124.55,11.27 ; H16.1 122.62,13.2 ; H16.1 125.97,11.78 ; H16.1 123.13,11.78 ; H16.1 123.13,14.62 ; 293.38,48.14 JCRT1.5 ; JCRT1.5 293.9,46.96 ; JCRT1.5 294.42,47.1 ; JCRT1.5 293.38,47.1 ; JCRT1.5 293.24,47.62 ; SW1.5 297.59,94.62 ; SW1.5 296.59,93.62 ; SW1.5 298.35,92.86 ; SW1.5 297.59,92.61 ; SW1.5 298.6,93.62 ; SW1.5 296.83,92.86 ; SW1.5 296.83,94.38 ; SW1.5 298.35,94.38 ; JHDMI1.5 11.51,46.11 ; JHDMI1.5 10.47,45.65 ; JHDMI1.5 11.51,45.19 ; JHDMI1.5 11.63,45.65 ; JHDMI1.5 10.59,45.19 ; JHDMI1.5 10.59,46.11 ; 16.2,31.27 JUSB2.10 ; JUSB2.10 14.87,31.27 ; JUSB2.10 14.87,32.1 ; JUSB2.10 16.2,32.93 ; JUSB2.10 17.53,32.1 ; JUSB2.10 17.53,31.27 ; JUSB2.10 17.53,32.93 ; JUSB2.10 14.87,32.93 ; H1.1 92.85,76 ; H1.1 93.49,74.3 ; H1.1 91.15,71.96 ; H1.1 88.81,74.3 ; H1.1 91.15,76.64 ; H1.1 89.45,72.6 ; H1.1 92.85,72.6 ; H1.1 89.45,76 ; JUSB2.12 16.2,20.13 ; JUSB2.12 17.53,19.3 ; JUSB2.12 14.87,18.47 ; JUSB2.12 14.87,19.3 ; JUSB2.12 17.53,18.47 ; JUSB2.12 14.87,20.13 ; JUSB2.12 17.53,20.13 ; JUSB2.12 16.2,18.47 ; JUSB2.13 8.13,18 ; JUSB2.13 8.13,17.17 ; JUSB2.13 5.77,18 ; JUSB2.13 6.95,17.17 ; JUSB2.13 5.77,17.17 ; JUSB2.4 16.54,21.57 ; JUSB2.4 15.9,21.37 ; JUSB2.4 16.73,22.2 ; JUSB2.4 15.27,22.84 ; JUSB2.4 16.54,22.84 ; JUSB2.4 15.9,23.03 ; 79.85,106.47 JSD1.22 ; JSD1.22 80.58,108.73 ; JSD1.22 79.85,107.6 ; JSD1.22 79.85,108.73 ; JSD1.22 81.3,107.6 ; JSD1.22 80.58,106.47 ; JSD1.22 81.3,108.73 ; JSD1.22 81.3,106.47 ; 286.71,35.41 H10.1 ; H10.1 289.39,35.41 ; H10.1 286.22,36.75 ; H10.1 288.05,34.92 ; H10.1 286.71,38.09 ; H10.1 289.39,38.09 ; H10.1 289.88,36.75 ; H10.1 288.05,38.58 ; JSD1.23 94.98,108.73 ; JSD1.23 94.25,107.6 ; JSD1.23 94.98,106.47 ; JSD1.23 94.25,106.47 ; JSD1.23 94.25,108.73 ; JSD1.23 95.7,108.73 ; JSD1.23 95.7,106.47 ; JSD1.23 95.7,107.6 ; 293.38,57.41 JCRT1.6 ; JCRT1.6 293.24,57.92 ; JCRT1.6 294.42,58.44 ; JCRT1.6 293.38,58.44 ; JCRT1.6 293.9,58.59 ; 10.59,52.11 JHDMI1.17 ; JHDMI1.17 11.51,52.11 ; JHDMI1.17 10.47,51.65 ; JHDMI1.17 11.63,51.65 ; JHDMI1.17 11.51,51.19 ; JHDMI1.17 10.59,51.19 ; H23.1 21.05,17.23 ; H23.1 22.47,13.88 ; H23.1 21.05,13.37 ; H23.1 19.63,16.72 ; H23.1 22.98,15.3 ; H23.1 19.63,13.88 ; H23.1 22.47,16.72 ; H23.1 19.12,15.3 ; JHDMI1.22 12.53,40.02 ; JHDMI1.22 9.97,41.78 ; JHDMI1.22 12.53,40.9 ; JHDMI1.22 12.53,41.78 ; JHDMI1.22 11.25,41.78 ; JHDMI1.22 11.25,40.02 ; JHDMI1.22 9.97,40.02 ; JUSB1.10 284.9,17.88 ; JUSB1.10 286.23,17.88 ; JUSB1.10 283.57,17.05 ; JUSB1.10 284.9,16.22 ; JUSB1.10 283.57,17.88 ; JUSB1.10 286.23,16.22 ; JUSB1.10 286.23,17.05 ; JUSB1.10 283.57,16.22 ; 293.38,53.86 JCRT1.8 ; JCRT1.8 293.38,52.83 ; JCRT1.8 293.24,53.34 ; JUSBC1.2 8.23,75.02 ; JUSBC1.2 5.57,76.58 ; JUSBC1.2 6.9,76.58 ; JUSBC1.2 8.23,76.58 ; JUSBC1.2 8.23,75.8 ; H15.1 125.89,22.04 ; H15.1 124.55,18.87 ; H15.1 123.21,19.36 ; H15.1 124.55,22.53 ; H15.1 123.21,22.04 ; H15.1 126.38,20.7 ; H15.1 122.72,20.7 ; H15.1 125.89,19.36 ; H2.1 151.89,74.3 ; H2.1 151.25,72.6 ; H2.1 147.85,72.6 ; H2.1 147.85,76 ; H2.1 147.21,74.3 ; H2.1 149.55,71.96 ; H2.1 151.25,76 ; H2.1 149.55,76.64 ; 293.24,48.76 JCRT1.10 ; JCRT1.10 293.38,48.25 ; JCRT1.10 293.38,49.28 ; JUSB2.7 15.04,25.06 ; JUSB2.7 13.77,25.06 ; JUSB2.7 15.23,25.7 ; JUSB2.7 14.4,26.53 ; JUSB2.7 15.04,26.33 ; JUSB2.7 14.4,24.87 ; JUSB2.7 13.77,26.33 ; JUSB2.11 6.95,34.23 ; JUSB2.11 8.13,34.23 ; JUSB2.11 8.13,33.4 ; JUSB2.11 5.77,33.4 ; JUSB2.11 5.77,34.23 ; H8.1 269.49,72.96 ; H8.1 266.51,72.96 ; H8.1 268,72.42 ; H8.1 265.97,74.45 ; H8.1 268,76.48 ; H8.1 269.49,75.94 ; H8.1 266.51,75.94 ; H8.1 270.03,74.45 ; JUSB1.4 285.2,27.78 ; JUSB1.4 285.84,26.31 ; JUSB1.4 284.57,27.58 ; JUSB1.4 285.2,26.12 ; JUSB1.4 284.37,26.95 ; JUSB1.4 284.57,26.31 ; H19.1 7.49,63.77 ; H19.1 4.81,63.77 ; H19.1 4.32,62.43 ; H19.1 4.81,61.09 ; H19.1 6.15,64.26 ; H19.1 6.15,60.6 ; H19.1 7.98,62.43 ; H19.1 7.49,61.09 ; JUSB1.11 295.33,14.92 ; JUSB1.11 292.97,14.92 ; JUSB1.11 294.15,14.92 ; JUSB1.11 295.33,15.75 ; JUSB1.11 292.97,15.75 ; H22.1 8.89,14.04 ; H22.1 7.55,10.87 ; H22.1 6.21,14.04 ; H22.1 5.72,12.7 ; H22.1 8.89,11.36 ; H22.1 7.55,14.53 ; H22.1 9.38,12.7 ; H22.1 6.21,11.36 ; H18.1 6.15,82.36 ; H18.1 7.49,81.87 ; H18.1 4.81,81.87 ; H18.1 4.32,80.53 ; H18.1 7.49,79.19 ; H18.1 6.15,78.7 ; H18.1 4.81,79.19 ; H18.1 7.98,80.53 ; 65.55,76.27 H34.1 ; H34.1 67.07,76.83 ; H34.1 67.07,79.87 ; H34.1 65.55,80.43 ; H34.1 63.47,78.35 ; H34.1 64.03,76.83 ; H34.1 67.63,78.35 ; H34.1 64.03,79.87 ; JUSB1.7 287.34,24.09 ; JUSB1.7 285.87,23.45 ; JUSB1.7 287.34,22.82 ; JUSB1.7 286.7,22.62 ; JUSB1.7 286.07,22.82 ; JUSB1.7 286.07,24.09 ; JUSB1.7 286.7,24.28 ; 1.6,64.8 JUSBC1.5 ; JUSBC1.5 3.48,66.46 ; JUSBC1.5 0.42,65.63 ; JUSBC1.5 1.6,66.46 ; JUSBC1.5 0.42,64.8 ; JUSBC1.5 3.48,64.8 ; JUSBC1.5 3.48,65.63 ; JUSBC1.1 8.23,67.94 ; JUSBC1.1 6.9,66.38 ; JUSBC1.1 5.57,66.38 ; JUSBC1.1 8.23,67.16 ; JUSBC1.1 8.23,66.38 ; JUSBC1.6 1.6,78.16 ; JUSBC1.6 3.48,78.16 ; JUSBC1.6 3.48,76.5 ; JUSBC1.6 0.42,78.16 ; JUSBC1.6 3.48,77.33 ; JUSBC1.6 1.6,76.5 ; JUSBC1.6 0.42,77.33 ; 294,41.43 JCRT1.16 ; JCRT1.16 294,42.87 ; JCRT1.16 292.37,41.43 ; JCRT1.16 295.63,42.87 ; JCRT1.16 292.37,42.87 ; JCRT1.16 292.37,42.15 ; JCRT1.16 295.63,42.15 ; JCRT1.16 295.63,41.43 ; 7.75,37.85 H21.1 ; H21.1 8.85,38.24 ; H21.1 9.95,37.85 ; H21.1 7.36,36.75 ; H21.1 9.95,35.65 ; H21.1 10.34,36.75 ; H21.1 7.75,35.65 ; H21.1 8.85,35.26 ; JHDMI1.21 2.9,57.93 ; JHDMI1.21 1.22,56.9 ; JHDMI1.21 4.58,56.9 ; JHDMI1.21 4.58,57.93 ; JHDMI1.21 1.22,57.93 ; 293.38,56.15 JCRT1.7 ; JCRT1.7 293.24,55.63 ; JCRT1.7 293.38,55.12 ; H20.1 16.89,39.39 ; H20.1 15.55,39.88 ; H20.1 13.72,38.05 ; H20.1 15.55,36.22 ; H20.1 17.38,38.05 ; H20.1 16.89,36.71 ; H20.1 14.21,39.39 ; H20.1 14.21,36.71 ; JHDMI1.8 13.06,46.69 ; JHDMI1.8 13.06,47.61 ; JHDMI1.8 12.14,47.61 ; JHDMI1.8 12.02,47.15 ; JHDMI1.8 12.14,46.69 ; JHDMI1.8 13.18,47.15 ; JUSBC1.4 6.3,76.58 ; JUSBC1.4 7.03,74.57 ; JUSBC1.4 6.3,74.57 ; JUSBC1.4 7.03,76.58 ; JUSBC1.4 5.58,76.58 ; JCRT1.17 294,62.97 ; JCRT1.17 295.63,62.97 ; JCRT1.17 292.37,62.25 ; JCRT1.17 295.63,62.25 ; JCRT1.17 295.63,61.53 ; JCRT1.17 292.37,62.97 ; JCRT1.17 292.37,61.53 ; JCRT1.17 294,61.53 ; H14.1 154.09,105.15 ; H14.1 148.01,107.68 ; H14.1 148.01,105.15 ; H14.1 154.09,107.68 ; H14.1 151.05,102.62 ; H14.1 154.09,102.62 ; H14.1 151.05,107.68 ; H14.1 148.01,102.62 ; 1.22,39.4 JHDMI1.23 ; JHDMI1.23 4.58,39.4 ; JHDMI1.23 1.22,38.37 ; JHDMI1.23 2.9,38.37 ; JHDMI1.23 4.58,38.37 ; JUSBC1.3 6.3,68.39 ; JUSBC1.3 5.58,66.38 ; JUSBC1.3 6.3,66.38 ; JUSBC1.3 7.03,66.38
  BOTTOM w0.102: 119.13,71.63 118.86,71.89 118.86,72.16 118.95,72.25 118.95,72.44 118.86,72.53 118.86,72.83 119.09,73.06
  BOTTOM w0.127: v3(263.03,78.42) 262.44,78.42 v1(262.44,78.42) ; 147.99,78.94 147.99,78.85 147.68,78.55 147.28,78.55 146.5,77.77 144.68,77.77 v1(144.5,77.95) 144.62,78.06 144.62,78.41 145.37,79.16 145.37,79.35 ; v3(58.86,72.35) v1(58.86,71.67) ; v1(279.32,54.68) v3(279.32,54.07)
  BOTTOM w0.152: UC1.BB60 106.73,51.33 106.73,50.46 v1(106.71,50.43) ; v1(99.21,69.62) 99.39,69.45 100.03,69.45 100.09,69.43 UC1.H71
  BOTTOM w0.178: v1(104.39,50.43) 104.39,50.43 104.39,50.82 UC1.BB64 ; v1(99.27,59.97) 99.27,59.96 99.39,59.83 UC1.AG71 ; v1(130.23,50.42) 130.23,50.42 130.2,50.46 UC1.BB18 ; UC1.AT71 99.38,54.83 v1(99.2,54.82) ; v1(119.16,50.36) 119.13,50.39 119.13,51.33 UC1.BB38 ; v1(99.21,57.2) 99.66,57.2 99.66,57.2 99.97,57.2 99.98,57.19 UC1.AM71 ; v1(109.39,50.43) 109.35,50.47 109.35,50.96 UC1.BB55 ; v1(121.43,49.75) 121.47,49.79 121.47,51.08 UC1.BB34 ; v1(124.23,50.18) 124.1,50.31 124.1,50.7 UC1.BB30 ; v1(116.49,50.39) 116.52,50.42 UC1.BB43 ; UC1.BB26 126.45,50.95 126.45,50.44 v1(126.5,50.39)
  BOTTOM w0.203: v1(132.9,58.57) 132.96,58.5 132.96,58.15 133.37,57.75 UC1.AM13 ; UC1.AU15 131.61,53.3 UC1.AW16 131.04,53.3 131.01,53.33 130.23,53.33 UC1.AW18 ; UC1.AW8 135.88,53.3 135.85,53.33 135.56,53.33 135.52,53.3 UC1.AW10 135.04,53.51 v1(134.77,53.78) 134.28,53.3 UC1.AW12 133.46,53.3 133.43,53.33 133.13,53.33 133.1,53.3 UC1.AW14 132.94,53.62 v1(132.94,53.85) ; v1(102.74,53.17) UC1.AY66 UC1.BA66 ; v1(102.74,53.17) 102.93,53.17 UC1.AW66 103.28,53.35 104.24,53.35 UC1.AW64 104.78,53.3 104.81,53.33 105.1,53.33 105.13,53.3 UC1.AW62 106,53.3 106.04,53.33 106.33,53.33 106.36,53.3 UC1.AW60 107.23,53.3 107.26,53.33 107.56,53.33 107.59,53.3 UC1.AW57 ; v1(102.74,53.17) 102.28,53.62 UC1.AV68 ; UC1.AV68 101.97,53.62 v1(101.78,53.44) ; UC1.AV68 102.25,53.63 102.25,54 102.3,54.05 102.3,54.24 102.25,54.41 UC1.AT68 102.25,55.21 102.28,55.24 102.28,55.54 102.25,55.57 UC1.AP68 102.25,56.44 102.28,56.47 102.28,56.77 102.25,56.8 UC1.AM68 ; 119.13,71.63 119.13,70.8 UC1.F37 119.91,70.54 v1(120.12,70.54) 120.31,70.54 UC1.F35 120.93,70.64 120.93,71.09 120.41,71.62 UC1.D34 ; UC1.AW55 109.73,53.3 109.76,53.33 110.06,53.33 110.09,53.3 UC1.AW53 110.96,53.3 110.99,53.33 111.29,53.33 111.32,53.3 UC1.AW51 ; 120.74,73.8 120.74,73.01 UC1.B34 ; UC1.AB15 132.46,62.33 131.84,62.33 UC1.AB16 ; UC1.AL52 111.88,59.06 111.69,59.25 110.95,59.25 v1(110.55,59.66) ; UC1.AV1 140.96,53.51 v1(141.09,53.37) ; UC1.BA1 140.49,51.6 140.03,51.6 UC1.BA2 ; v1(102.74,56.98) 102.44,57.28 UC1.AM68 ; UC1.AM46 113.71,57.85 UC1.AL48 ; UC1.AH67 102.57,59.21 102.33,58.96 v1(102.33,58.85) 101.99,58.51 UC1.AK68 101.92,58.44 102.25,58.11 102.3,58.06 102.3,57.72 102.25,57.67 UC1.AM68 ; UC1.AW43 116.61,53.29 116.14,53.29 116.1,53.33 115.8,53.33 115.77,53.3 UC1.AW45 114.9,53.3 114.87,53.33 114.58,53.33 114.55,53.3 UC1.AW47 113.74,53.3 113.71,53.33 113.41,53.33 113.38,53.3 UC1.AW49 ; 119.09,73.06 119.09,73.91 119.38,74.2 v1(119.38,74.24) ; UC1.AM43 115.54,57.85 UC1.AL45 ; UC1.AL55 110.05,57.85 UC1.AM55 ; UC1.AW38 119.5,53.3 119.53,53.33 119.83,53.33 119.86,53.3 UC1.AW36 120.73,53.3 120.76,53.33 121.05,53.33 121.08,53.3 UC1.AW34 121.57,53.45 v1(121.91,53.79) 122.41,53.3 UC1.AW32 123.26,53.3 123.29,53.33 123.58,53.33 123.61,53.3 UC1.AW30 124.48,53.3 124.51,53.33 124.81,53.33 124.84,53.3 UC1.AW28 125.71,53.3 125.74,53.33 126.04,53.33 126.07,53.3 UC1.AW26 126.94,53.3 126.97,53.33 127.26,53.33 127.29,53.3 UC1.AW23 128.26,53.3 128.29,53.33 128.59,53.33 128.62,53.3 UC1.AW21 ; UC1.AH63 UC1.AF63 ; UC1.AL66 103.32,57.49 103.36,57.45 103.74,57.45 103.79,57.49 UC1.AL65 103.95,57.49 104,57.45 104.38,57.45 104.42,57.49 UC1.AL64
  BOTTOM w0.254: UC1.AM8 136.57,57.85 UC1.AK8 136.57,58.41 136.31,58.67 v1(136.31,58.79) 135.01,58.79 134.62,58.4 UC1.AK11 ; UC1.AE69 101.27,61.31 v1(101.55,61.59) 101.92,61.22 UC1.AE68 UC1.AE67 UC1.AE66 103.22,61.23 103.59,61.59 ; UC1.F22 127.54,69.94 v1(127.39,69.94) ; UC1.AL38 v1(119.2,58.58) ; PU200.15 55.43,61.87 55.68,62.12 v1(55.68,62.28) ; UC1.AP18 130.63,56.05 130.4,55.83 130.26,55.83 v1(130.23,55.8) ; UC1.BA62 v1(105.57,52.79) UC1.AW62 ; v1(99.31,67.74) 99.57,67.99 100.21,67.99 UC1.K71 UC1.K70 101.83,68.08 UC1.K68 ; v1(119.23,78.23) 119.25,78.23 119.77,77.71 119.77,75.96 119.38,75.57 v1(119.38,74.24) ; v1(101.78,53.44) UC1.AV69 UC1.AV70 UC1.AV71 99.58,53.44 99.58,53.43 99.49,53.35 v1(99.49,53.29) ; v1(131.12,70.56) 131,70.56 UC1.E18 ; UC1.AW36 v1(120.29,52.79) UC1.BA36 ; v1(67.19,94.37) 67.21,94.37 67.25,94.34 68.38,94.34 JEDP1.23 ; UC1.D30 v1(122.89,72.16) UC1.B30 ; PC647.1 75.4,65.49 75.95,66.04 PR658.1 76.24,66.79 v1(76.51,67.05) ; UC1.AL58 v1(108.22,59.23) ; UC1.AD13 133.23,61.4 v1(132.92,61.09) 132.5,60.67 UC1.AF15 ; v1(102.16,74.17) 102.16,74.04 102.39,73.81 UC1.A67 ; UC1.D48 113.01,71.7 UC1.D47 113.63,71.68 113.63,71.24 113.61,71.22 ; v1(105.87,61.99) 105.87,62.02 105.85,62 105.85,61.99 105.8,61.94 105.73,61.88 105.64,61.79 UC1.AD62 105,61.56 104.55,61.1 UC1.AE64 ; UC1.B34 v1(120.41,72.17) UC1.D34 ; JSATA1.14 252.4,6.15 v1(252.4,6.14) ; UC1.AW14 132.62,52.83 v1(132.7,52.75) 132.62,52.68 UC1.BA14 ; UC1.AR16 131.9,55.08 v1(132,55.08) UC1.AR15 ; UC1.BA49 v1(112.93,52.79) UC1.AW49 ; v1(98.98,71.5) 99.19,71.3 99.84,71.3 99.9,71.24 UC1.E71 ; v1(103.45,70.66) 103.45,70.2 UC1.G66 ; UC1.P17 131.17,65.7 130.86,66.01 v1(130.86,66.09) ; UC1.P17 130.52,65.05 UC1.T18 ; UC1.P17 UC1.T17 ; v1(135.53,59.89) 135.53,60.02 135.27,60.28 UC1.AF10 ; UC1.F38 118.74,70.28 118.34,69.88 v1(118.26,69.88) ; UC1.AB8 136.57,62.36 v1(136.91,62.03) 136.91,61.74 UC1.AD8 ; 101.22,71.17 v1(101.19,71.17) ; 101.22,71.17 101.36,71.31 UC1.D69 ; 101.22,71.17 101.72,70.66 UC1.F68 ; v1(67.39,97.89) 67.39,98.12 67.62,98.35 JEDP1.15 ; UC1.P19 UC1.P20 129.22,65.72 129.56,66.06 v1(129.56,66.16) 129.87,66.48 UC1.N19 ; UC1.K65 103.85,68.27 v1(103.56,67.97) ; UC1.G60 106.96,69.63 v1(107.27,69.94) 107.58,69.63 UC1.G58 ; UC1.U63 v1(104.9,64.29) UC1.U64 ; UC1.AP20 129.51,56.09 v1(129.18,56.42) 129.5,56.74 UC1.AN20 ; UC1.K16 131.83,68.21 132.05,67.98 132.05,67.59 131.84,67.37 UC1.L16 131.73,67.28 131.26,67.28 UC1.L17 131.11,67.31 130.59,67.31 UC1.L18 ; UC1.K16 131.79,68.21 131.4,68.6 131,68.6 UC1.H18 130.51,68.86 130.51,68.23 UC1.K18 ; UC1.K16 132.02,68.41 132.02,68.55 UC1.H15 ; JUSBC1.A1 8.46,68.86 v1(8.54,68.78) ; UC1.AW28 v1(125.27,52.79) UC1.BA28 ; UC1.B62 105.59,72.62 105.59,72.26 105.79,72.06 v1(105.79,72.08) 105.71,72.01 105.71,71.83 UC1.D62 ; UC1.V16 131.78,63.98 131.22,63.98 ; UC1.V16 132.27,63.58 133.28,63.58 UC1.W13 ; UC1.V16 131.82,64.08 v1(132.16,64.41) 132.16,64.52 132.47,64.84 UC1.T15 ; UC1.AG19 UC1.AG18 130.52,60.03 130.78,60.28 v1(130.85,60.28) ; UC1.AG19 129.87,59.69 130.52,59.04 UC1.AJ18 130.94,58.58 130.95,58.58 ; UC1.AG19 129.71,59.83 129.7,59.84 129.32,59.84 129.31,59.83 UC1.AG20 129.22,59.78 128.88,59.44 v1(128.88,59.38) ; v1(128.88,62.74) 128.57,63.04 UC1.Y21 ; v1(128.88,62.74) 128.57,62.43 UC1.AB21 ; v1(128.88,62.74) 129.22,63.08 UC1.Y20 ; UC1.AT2 139.32,54.89 v1(139.14,54.71) 138.96,54.89 UC1.AT4 ; v1(98.27,51.33) 98.27,51.49 98.58,51.79 98.58,51.83 98.98,52.23 99.87,52.23 UC1.AY71 ; PR925.2 22.39,47.42 22,47.81 v1(21.71,47.81) ; CC269.2 94.59,94.51 v1(94.59,94.99) ; v1(12.12,74.62) 12.01,74.74 DT18.2 ; v1(104.19,67.94) 104.5,68.26 UC1.K64 UC1.K63 ; UC1.Y17 130.79,63.56 130.26,63.56 UC1.Y19 129.57,62.88 v1(129.57,62.78) 130.09,62.78 UC1.AB18 ; UC1.BA18 130.21,52.09 v1(130.21,52.61) 130.2,52.61 UC1.AW18 129.97,53.3 129.71,53.55 UC1.AU20 v1(129.25,54.44) UC1.AT20 ; UC1.AN42 116.97,56.74 v1(117.37,56.35) UC1.AN40 ; UC1.AN28 124.22,56.64 123.88,56.35 v1(123.77,56.35) UC1.AN30 ; v1(134.72,69.9) 134.89,69.9 135.17,69.63 UC1.G10 ; UC1.AK22 128.06,58.15 UC1.AK21 128.8,57.93 UC1.AM21 128.39,56.98 v1(128.34,56.98) ; UC1.U67 v1(102.89,64.29) UC1.U66 ; v1(121.91,53.79) 122.37,54.14 UC1.AU32 ; v1(132.94,53.85) 132.69,53.85 132.45,54.08 UC1.AU15 ; UC1.AU38 118.67,54.09 118.32,53.84 v1(118.34,53.84) ; v1(69.45,101.65) 69.24,101.85 JEDP1.8 ; UC1.D14 v1(132.8,72.17) UC1.B14 ; v1(135.69,55.71) 135.78,55.71 136.06,55.44 UC1.AR8 ; 103.59,61.59 v1(103.59,61.62) ; 103.59,61.59 103.59,61.54 103.87,61.25 UC1.AE65 UC1.AE64 ; UC1.E21 128.48,71.25 128.25,71.25 UC1.D22 127.86,71.68 v1(127.86,72.18) 127.84,72.2 UC1.B22 ; UC1.F32 122.4,70.28 122.05,69.93 v1(121.97,69.93) ; JNGFF2.3 259.25,30.41 v1(259.39,30.55) 259.39,30.53 259.66,30.26 259.66,29.99 259.75,29.89 JNGFF2.5 ; v1(113.16,72.16) 113.16,72.49 UC1.B48 ; UC1.AD16 131.57,61.77 v1(131.57,61.92) 131.57,62.09 UC1.AB16 ; v1(128.88,59.38) 128.57,59.69 UC1.AG21 ; v1(128.88,59.38) 128.88,59.33 UC1.AJ20 ; UC1.L20 128.57,66.72 UC1.N21 128.57,66.45 v1(128.22,66.09) 128.56,65.75 128.56,65.71 UC1.P21 ; UC1.AR46 v1(114.62,55.08) UC1.AR45 ; UC1.AL28 124.68,57.87 124.77,57.96 UC1.AK27 v1(125.14,59.24) ; LGA1.8 245.76,9.8 246.11,9.44 246.84,9.44 ; UC1.AL35 v1(121.02,58.57) ; UC1.AD21 128.59,61.49 129.21,61.49 UC1.AD20 129.22,61.37 v1(129.54,61.05) 129.73,61.25 129.73,61.37 UC1.AD19 ; v1(67.38,91.72) 67.51,91.85 JEDP1.28 ; UC1.AT58 v1(107.31,55.08) UC1.AR58 ; UC1.B66 UC1.D66 103.06,71.61 v1(103.43,71.25) 103.7,71.25 UC1.E65 ; UC1.AR55 109.59,55.41 109.57,55.4 v1(109.14,55.05) ; 145.37,79.35 145.37,81.23 CC335.2 145.63,82.01 145.44,82.01 145.17,82.29 145.17,85.11 v1(144.99,85.29) 144.99,85.44 145.24,85.7 149.14,85.7 149.33,85.5 149.33,82.29 148.79,81.75 CC334.2 149.15,81.2 149.15,80.11 v1(148.89,79.84) 147.99,78.94 ; UC1.AR5 137.85,55.44 137.7,55.28 137.66,55.28 v1(137.46,55.13) ; v1(134.77,53.78) 135.2,54.09 UC1.AU10 ; v1(66.6,92.86) 67.09,93.35 JEDP1.25 ; UC1.N65 v1(104.24,66.17) ; v1(66.73,91.72) 66.73,91.79 67.19,92.25 67.62,92.25 67.72,92.35 JEDP1.27 ; v1(118.26,69.88) 118.28,69.86 UC1.J38 118.28,68.51 v1(118.29,68.5) ; v1(118.26,69.88) 118.19,69.88 117.82,70.24 UC1.F40 ; UC1.AP10 135.13,56.09 134.85,55.86 v1(134.78,55.8) 134.57,55.8 134.28,55.52 UC1.AR11 ; UC1.E56 108.65,70.93 108.36,71.22 v1(108.26,71.22) 108.02,71.46 UC1.D58 UC1.B58 ; UC1.AM25 125.77,57.39 v1(125.6,57.22) ; UC1.U69 v1(100.94,64.29) UC1.U70 ; v1(113.71,57) UC1.AM46 ; UC1.C1 v1(140.97,73.05) ; v1(128.3,64.42) 128.3,64.58 UC1.T21 ; v1(131.67,71.45) 131.96,71.17 132.22,71.17 132.25,71.13 UC1.E15 132.59,70.79 132.89,70.79 133.37,70.31 UC1.F13 ; CC21.2 118.1,81.5 118.1,84.69 118.36,84.95 122.1,84.95 122.38,84.67 122.38,81.83 122.41,81.81 122.41,80.9 123.22,80.09 123.22,78.63 122.63,78.05 122.63,76.52 121.65,75.54 121.65,74.87 120.74,73.96 120.74,73.8 ; JSATA1.12 251.4,6.36 v1(251.17,6.13) ; UC1.AH64 104.58,59.18 v1(104.82,58.82) ; UC1.AR20 129.6,55.44 v1(129.18,55.1) ; UC1.B10 135.28,72.21 v1(135.23,72.16) 135.28,72.11 UC1.D10 ; v1(120.11,56.32) 120.2,56.32 120.57,56.64 UC1.AN35 ; 130.95,58.58 UC1.AK18 ; 130.95,58.58 131.31,58.58 131.74,58.15 UC1.AK16 ; UC1.D39 118.11,71.84 v1(118.11,72.21) 118.11,72.5 UC1.B39 ; UC1.AL66 103.22,57.47 v1(102.74,56.98) ; UC1.AE64 UC1.AF63 ; UC1.K67 102.55,68.29 v1(102.87,67.97) 103.2,68.3 UC1.K66 ; UC1.AN58 v1(107.31,56.35) ; UC1.BA32 v1(122.77,52.79) UC1.AW32 ; v1(130.85,60.28) 131.17,59.96 UC1.AG17 UC1.AG16 ; v1(130.85,60.28) 130.85,60.36 131.16,60.67 UC1.AF17 ; UC1.AW57 v1(108.05,52.79) UC1.BA57 ; UC1.J13 UC1.J11 134.28,67.95 134.56,67.68 UC1.L11 135.12,67.18 135.12,66.89 UC1.N10 135.59,66.41 v1(135.59,66.27) ; UC1.AM55 109.57,57.37 v1(109.14,57) ; v1(67.09,86.46) 67.19,86.46 67.3,86.35 JEDP1.39 ; UC1.AR50 v1(111.88,55.08) UC1.AR52 v1(110.97,55.08) ; 113.61,71.22 v1(113.64,71.22) ; 113.61,71.22 113.9,70.93 UC1.E46 ; v1(104.82,58.82) UC1.AK63 105.83,57.53 UC1.AM61 ; v1(104.82,58.82) UC1.AH63 ; PU402.6 172.45,101.65 172.1,101.99 v1(172.08,101.99) ; JEDP1.24 66.92,93.85 66.57,94.2 v1(66.57,94.36) ; v1(112.79,55.71) 112.97,55.71 113.24,55.44 UC1.AR48 ; UC1.AL32 122.85,58.35 122.79,58.42 122.79,59.35 v1(122.73,59.41) ; UC1.AW41 v1(117.82,52.79) UC1.BA41 ; UC1.AM61 v1(105.48,57) ; UC1.AM61 106,57.45 106.79,57.45 UC1.AM60 ; v1(13.47,71.01) 13.44,71.04 13.06,71.04 DT6.2 ; UC1.AH13 133.2,59.15 133.2,58.87 v1(132.9,58.57) UC1.AJ15 ; UC1.B18 v1(130.32,72.18) UC1.D18 ; v1(121.94,55.71) 121.95,55.72 UC1.AP32 ; 137.78,71.66 138.34,72.21 UC1.C5 ; 137.78,71.66 UC1.D6 ; 137.78,71.66 137.79,71.66 UC1.F4 v1(139.14,70.8) UC1.F2 UC1.F1 ; UC1.AN32 v1(121.94,56.35) ; UC1.BA10 v1(135.04,52.79) UC1.AW10 ; UC1.AN63 104.91,56.64 104.89,56.63 104.77,56.5 104.74,56.5 v1(104.57,56.35) ; UC1.U10 135.27,64.19 UC1.W9 135.92,63.09 v1(135.99,63.02) ; v1(120.12,68.5) 120.11,68.51 UC1.J35 120.12,69.17 v1(120.12,70.54) ; UC1.B53 v1(110.5,72.15) UC1.D53 110.51,71.65 UC1.E53 110.73,70.93 v1(111,71.2) ; UC1.AA68 v1(102.26,62.46) ; UC1.AL2 139.36,57.54 v1(139.17,57.73) 138.98,57.54 UC1.AL4 UC1.AJ4 138.58,58.21 138.13,58.66 138.13,58.67 138.1,58.72 137.87,59.1 UC1.AH6 ; UC1.BA45 v1(115.34,52.79) ; UC1.AM27 v1(124.68,57) ; UC1.F27 UC1.F28 124.02,70.28 123.81,70.07 v1(123.81,69.95) 123.77,69.91 UC1.J28 ; 131.22,63.98 130.57,63.98 UC1.V18 130.52,64.04 130.23,64.34 v1(130.23,64.44) ; 131.22,63.98 UC1.V17 ; UC1.W6 137.91,63.54 v1(138.25,63.19) 138.6,62.85 UC1.AA4 UC1.AA2 ; UC1.J32 122,69.22 122,69.9 v1(121.97,69.93) ; v1(127.39,69.94) 127.31,69.94 UC1.F23 ; v1(127.39,69.94) 127.7,69.63 UC1.G22 127.81,69.56 127.81,69.16 127.88,69.09 UC1.K22 ; LGA1.6 246.57,10.5 246.8,10.27 ; UC1.AP38 118.37,55.78 118.33,55.75 v1(118.33,55.71) ; v1(99.64,73.89) 100.19,73.89 100.43,73.65 UC1.A70 ; LGA1.5 246.58,11 246.91,10.68 ; v1(135.58,70.59) 135.64,70.59 135.94,70.28 UC1.F8 ; UC1.AP35 v1(120.11,55.71) ; JSATA1.4 v1(247.4,6.12) ; UC1.AP23 v1(126.51,55.71) ; v1(138.18,67.23) 138.18,67.04 UC1.N6 138.03,66.58 138.03,65.83 UC1.R6 138.48,65.67 UC1.T4 UC1.T2 ; v1(116.46,68.5) 116.45,68.51 UC1.J42 ; UC1.AA65 v1(104.22,62.48) ; UC1.L2 139.6,68.13 v1(139.14,68.13) 138.67,68.13 UC1.L4 ; UC1.G52 v1(111,69.93) ; UC1.AT42 116.87,54.79 v1(116.41,55.08) 116.87,55.44 UC1.AR42 ; v1(105.37,70.04) 105.33,70.04 UC1.G63 104.97,69.66 UC1.K61 ; UC1.G5 UC1.G6 136.75,69.9 v1(136.52,69.9) ; UC1.BB67 102.39,50.59 v1(102.06,50.27) ; UC1.AN37 119.65,56.62 119.31,56.32 v1(119.2,56.32) 119.08,56.32 118.74,56.62 UC1.AN38 ; UC1.AT28 v1(123.77,55.08) UC1.AR28 ; UC1.AR63 v1(104.57,55.08) UC1.AT63 ; CN1.2 245.42,17.6 245.01,17.19 CN2.2 ; UC1.AR43 v1(116.45,55.71) UC1.AP42 ; JSATA1.18 254.4,6.15 v1(254.4,6.14) ; UC1.AM45 v1(114.62,57) ; UC1.G55 109.28,69.94 v1(109.21,69.94) ; v1(115.54,57) UC1.AM43 ; UC1.B71 99.55,73.19 v1(99.26,72.9) ; UC1.AW23 v1(127.75,52.79) UC1.BA23 ; JDIMM1.192 v1(99.93,10.32) ; JSATA1.7 v1(248.9,5.5) ; UC1.AK69 101.26,58.51 101.44,58.69 101.75,58.69 UC1.AK68 ; UC1.D26 125.36,72.14 v1(125.37,72.14) 125.57,72.35 UC1.C25 UC1.D25 ; UC1.AP63 v1(104.57,55.71) ; UC1.AR23 v1(126.51,55.08) UC1.AT23 ; UC1.A5 138.34,73.74 v1(138.64,74.04) ; UC1.D45 115.41,71.7 UC1.D44 115.48,71.68 v1(115.48,72.16) 115.43,72.21 115.43,72.65 UC1.B44 ; v1(12.12,76.4) 12.03,76.31 DT17.2 ; v1(121.97,69.93) 121.94,69.95 121.92,69.95 121.59,70.28 UC1.F33 ; v1(135.66,68.61) 135.67,68.61 135.86,68.61 136.11,68.36 UC1.J8 136.12,68.33 136.57,67.87 UC1.L8 ; UC1.AR35 v1(120.11,55.08) UC1.AT35 ; UC1.N68 v1(102.26,66.17) ; UC1.AP58 v1(107.31,55.71) ; UC1.G48 v1(112.8,69.9) ; v1(66.86,104.06) 67.07,103.85 JEDP1.4 ; PU401.6 174.97,53.02 v1(175.04,53.08) 175.16,53.21 PR412.1 ; UC1.AW53 v1(110.52,52.79) UC1.BA53 ; v1(95.64,102.26) JXDP1.32 ; v1(265.33,30.07) 265.33,29.94 265.25,29.86 JNGFF2.27 ; UC1.AF4 138.94,60.2 v1(139.14,59.99) 139.34,60.2 UC1.AF2 UC1.AF1 ; UC1.D11 v1(134.06,71.36) UC1.E11 ; JEDP1.6 69.21,102.85 v1(69.52,102.54) ; UC1.AR53 v1(110.05,55.08) ; UC1.AP70 v1(101.64,56) UC1.AP68 ; v1(75.77,68.37) PC651.1 ; UC1.AP28 v1(123.77,55.71) ; v1(125.39,68.1) 125.6,68.31 UC1.J25 ; UC1.E50 v1(111.97,71.29) ; LGA1.7 246.81,9.95 ; UC1.AT56 v1(108.22,54.44) ; UC1.BA71 99.88,51.58 99.74,51.58 99.7,51.61 v1(99.24,51.61) 99.47,51.38 99.47,51.03 99.47,51.02 UC1.BB70 ; UC1.BA2 UC1.AY3 139.16,52.31 138.42,53.04 137.75,53.04 137.49,53.3 UC1.AW6 137.29,53.17 137.29,52.64 v1(137.34,52.59) 137.34,52.56 137.33,52.55 137.33,52.21 UC1.BA6 137.46,51.94 137.46,51.94 137.46,51.48 137.46,51.48 UC1.BB6 ; UC1.AN33 v1(121.02,56.35) ; v1(13.52,68.8) DT5.2 ; UC1.AN23 v1(126.51,56.35)
  BOTTOM w0.279: v1(215.6,28.72) 214.79,29.54 214.79,31.29 215.07,31.57 216.67,31.57 216.98,31.25 JNGFF1.30 ; JXDP1.26 v1(97.14,102.26) ; JXDP1.7 v1(101.64,100) ; v1(96.12,95.98) 96.12,96.13 95.64,96.62 JXDP1.31 ; JXDP1.19 98.64,99.18 98.28,99.54 v1(97.29,99.54) 97.29,99.44 97.14,99.29 JXDP1.25 ; JXDP1.37 v1(94.14,99.54) ; v1(101.64,102.26) 102.86,102.26 103.14,102.54 JXDP1.2 ; v1(101.64,102.26) JXDP1.8 ; v1(101.64,102.26) 101.13,101.75 100.42,101.75 100.14,102.03 JXDP1.14 ; JXDP1.38 v1(94.14,102.26) ; v1(91.67,99.92) 91.67,99.69 91.14,99.16 JXDP1.49 ; JXDP1.20 98.64,102.26 v1(98.63,102.26) ; JXDP1.59 v1(88.64,99.89) ; JXDP1.50 v1(91.14,105.56) ; JXDP1.13 100.14,99.77 v1(100.36,100)
  BOTTOM w0.305: v1(271.33,8.3) 271.33,8.56 271.6,8.83 JNGFF3.39 ; JDIMM2.234 192.43,10.67 v1(192.21,10.45) ; JNGFF2.51 271.25,27.78 v1(271.38,27.66) ; v1(156.38,10.37) 156.42,10.41 JDIMM2.98 ; JDIMM1.36 v1(58.93,13.01) ; JDIMM2.210 v1(186.43,10.42) ; JNGFF1.7 210,36.82 v1(210,36.22) ; v1(267.49,27.72) 267.15,27.72 266.75,28.12 JNGFF2.33 ; v1(208.35,15.33) 208.2,15.18 JAPS1.14 ; v1(273.11,27.76) 273.11,27.84 272.75,28.19 JNGFF2.57 ; v1(209,32.76) 209.23,33 JNGFF1.23 ; v1(183.12,10.45) 182.93,10.65 JDIMM2.196 ; v1(274.71,8.56) 274.71,9.11 274.6,9.22 JNGFF3.27 ; v1(208.96,28.94) 209.02,29 JNGFF1.39 ; JNGFF2.73 276.75,28.92 276.75,27.57 276.41,27.22 v1(275.9,27.22) 275.9,27.48 276.25,27.83 JNGFF2.71 ; JNGFF1.63 210.95,23 211.26,22.7 211.26,21.8 210.95,21.5 JNGFF1.69 209.25,21.5 208.72,20.96 v1(208.72,19.99) ; JNGFF3.21 v1(276.1,8.74) ; v1(136.52,69.9) 136.52,70.43 UC1.E6 ; JESPI.9 248.37,38.09 247.99,38.46 247.08,38.46 246.82,38.73 246.82,39.04 ; JNGFF2.45 269.75,27.82 v1(269.62,27.69) ; JDIMM1.210 104.43,10.54 v1(104.38,10.49) ; JNGFF1.57 208.85,24.5 v1(208.84,24.51) 209,24.66 209,25.78 209.22,26 JNGFF1.51 ; JDIMM2.184 179.93,10.46 v1(179.97,10.42) ; JNGFF3.57 v1(267.1,8.86) ; JDIMM2.68 v1(148.93,10.21) ; UC1.N13 v1(133.75,66.3) 133.32,65.87 UC1.R13 133.05,65.67 132.47,65.09 UC1.T15 ; v1(134.08,10.39) 134.42,10.74 JDIMM2.10 ; JNGFF3.45 v1(270.1,8.86) ; v1(232.29,13.44) 232.73,13.44 232.91,13.26 JDEG1.10 ; JDIMM1.68 v1(66.93,10.37) ; JDIMM2.226 190.43,10.73 v1(190.74,10.42) ; v1(211.54,31.62) 211.54,31.64 211.56,31.62 211.56,30.96 211.1,30.5 JNGFF1.33 ; v1(147.93,10.21) JDIMM2.64 ; RC316.2 164.52,48.59 164.01,48.08 v1(164.01,47.98) ; v1(134.61,81.26) 134.55,81.32 UZ21.5 ; JDIMM2.252 196.93,10.81 196.57,10.46 v1(195.89,10.46) ; JNGFF1.24 216.96,32.75 216.59,33.12 216.59,33.87 216.97,34.25 JNGFF1.18 218.56,34.25 218.9,34.59 v1(218.9,35.1) ; JDIMM2.214 v1(187.43,10.43) ; v1(30,82.11) 30.01,82.11 30.01,81.68 29.37,81.04 JDB1.8 ; JDB1.6 28.48,76.63 v1(28.92,76.19) ; JNGFF1.29 209.12,31.5 v1(209.02,31.4) ; JDIMM2.22 v1(137.42,10.5) ; JNGFF2.11 261.25,30.01 v1(261.33,30.08) ; JNGFF2.39 268.25,28.15 268.1,28 v1(268.1,27.74) ; JNGFF1.36 217.73,29.75 218.48,29.75 218.88,30.14 218.88,30.86 218.48,31.25 217.73,31.25 JNGFF1.30 ; JDIMM1.214 v1(105.43,10.47) ; v1(206.91,28.88) 206.91,28.29 207.7,27.5 JNGFF1.45 ; JDIMM1.206 v1(103.43,10.46) ; v1(141.93,10.39) JDIMM2.40 ; JNGFF3.33 v1(273.1,11.2) ; v1(210.2,16.35) JAPS1.10 210.2,13.95 210.46,13.69 210.9,13.69 211.2,13.99 JAPS1.8 ; JDIMM2.106 v1(158.42,10.42) ; JAPS1.12 v1(209.2,15.33) ; JDIMM1.19 v1(54.68,18.7) ; JNGFF3.51 v1(268.6,8.86)
  BOTTOM w0.356: v1(251.97,18.82) 251.97,19.6 DA6.1 ; v1(94.59,94.99) 94.54,94.99 94.46,94.91 CC28.2 ; v1(75.29,90.57) CR7.2 75.29,91.66 CR4.2 75.32,92.05 CR3.2
  BOTTOM w0.381: DA7.1 251.77,15.52 251.77,14.47 251.79,14.46 251.79,14.45 252.11,14.13 252.11,14.13 252.15,14.09 v1(252.31,14.09) ; CC305.2 107.8,81.76 v1(108.03,81.76) ; v1(150.4,86.71) 150.1,87.01 UC12.3 ; v1(261.52,36.24) 261.52,37.36 262.06,37.89 CZ198.2 ; 98.83,94.98 98.39,94.55 CC307.2 ; v1(76.78,97.57) 76.31,98.03 CR21.2 ; 17.23,54.56 17.71,55.04 v1(17.89,55.04) ; 17.23,54.56 CV40.2 ; 17.23,54.56 CV41.2 ; CC319.2 148.02,65.03 v1(147.81,65.03) ; CE36.2 105.21,96.54 v1(105.52,96.85) ; v1(132.31,80.79) 132.27,80.76 131.77,80.76 CZ101.2 ; UC1.H15 132.38,68.98 v1(132.03,69.33) ; CR6.2 74.9,94.61 v1(74.65,94.36) ; RC109.2 98.4,95.42 v1(98.84,94.99) ; CA47.2 260.88,26.3 259.95,25.37 JSPK1.7 ; CV39.2 18.72,53.26 18.37,53.62 v1(17.91,53.62) ; CC10.2 154.46,48.92 v1(154.87,49.32) ; CC26.2 149.15,55.6 v1(149.15,55.11) ; 162.36,52.27 162.13,52.27 161.71,51.85 CC9.2 ; v1(203.69,22.35) 204.78,21.26 CZ90.2 ; CC301.2 106.56,86.97 106.1,86.51 v1(106.1,86.43) ; CA45.2 267.49,26.38 v1(267.49,27.72) ; v1(83.52,111.11) 84.08,110.55 CR19.1 84,110.46 83.62,110.08 CR20.1 ; UZ35.3 138.84,87.45 v1(138.55,87.74)
  BOTTOM w0.406: DI4.3 v1(283.06,25.32) ; 11.99,72.82 v1(13.14,72.82) ; JDEG1.12 231.15,10.32 v1(230.94,10.52) ; v1(18.79,21.38) 19.23,21.38 19.36,21.26 DI1.3
  BOTTOM w0.457: v1(207.95,16.51) 207.95,16.4 207.62,16.06 207.32,16.06 RD21.2 ; CC318.2 154.1,63.84 153.65,64.3 v1(153.65,64.38) ; CC226.2 v1(123.7,80.91) ; CC195.2 130.61,79.78 130.17,79.35 v1(130.03,79.35) ; CC220.2 126.71,79.21 v1(125.28,77.77) ; RA37.2 v1(278.39,19.33) ; CR15.2 v1(81.67,100.05) ; PQ1216.3 35.81,47.33 36.25,47.33 v1(36.49,47.09) ; CT213.2 33.74,78.96 33.74,79.6 v1(33.91,79.78)
  BOTTOM w0.508: PC614.1 71.1,61.44 70.73,61.07 v1(70.73,60.5) ; JEDP1.43 64.5,96.75 65.66,97.91 v1(66.78,97.91) ; CC312.2 v1(110.37,86.78) ; PR631.1 66.22,63.29 66.48,63.04 v1(66.83,63.04) ; v1(153.7,53.06) 153.67,53.08 RC268.2 ; v1(89.68,96.52) 89.68,95.94 89.29,95.56 CC33.2 89.08,94.78 88.26,93.97 RC139.2 ; CC300.2 100,81.05 v1(100.99,82.04) ; PR103.2 143.18,101.14 143.69,100.63 v1(144.07,100.63) ; CC210.2 v1(137.32,82.44) ; JSIM1.11 v1(109.91,102.41) ; CC22.2 v1(120.4,80.97) ; CC303.2 110.1,81.24 v1(110.67,81.81) ; v1(57.08,75.99) 57.18,76.09 PC10.2 ; CZ17.2 CZ18.2 259.39,39.92 v1(259.01,40.31) ; v1(248.09,32.81) 246.54,32.81 JESPI.11 ; PR415.2 175.84,54.72 v1(175.84,55.42) ; v1(123.86,83.71) 123.9,83.74 CC221.2 ; 47.85,99.32 JIR1.2 ; PC401.2 169.04,48.38 169.37,48.05 v1(170.01,48.05) ; RC556.2 RC554.2 156.85,68.33 157.12,68.07 v1(157.12,67.9) ; PC1192.2 86.85,65.53 v1(86.29,66.09) ; v1(52.17,80.01) 52.15,79.98 PC11.2 ; CC216.2 138.82,80.01 v1(138.99,80.18) ; v1(62.22,54.53) 62.15,54.46 PC687.2 ; v1(152.57,65.76) 152.16,66.17 RC372.2 RC401.2 ; 48.65,98.55 JIR1.3 ; CC306.2 v1(82.97,105.56) ; v1(25.3,41.78) 25.3,40.99 PC931.1 ; v1(25.3,41.78) 25.89,41.78 PC933.2 ; v1(25.3,41.78) 25.3,42.67 PR960.1 ; v1(177.83,90.29) 177.98,89.96 JFAN1.1 ; PC108.2 127.92,106.41 v1(127.56,106.41) ; v1(33.81,73.43) RT302.2 RT138.2 ; CR5.2 74.05,94.96 v1(74.65,94.36) ; CC7.2 v1(161.68,47.79) ; JSIM1.15 124.66,103.06 v1(124.13,102.54) ; CC32.2 v1(83.88,97.84) ; 98.83,94.98 v1(98.84,94.99) ; v1(172.5,105.58) 172.5,106.37 173.22,107.1 PU501.2 ; CZ105.2 136.04,90.75 135.47,91.33 v1(135.47,91.62) ; PH603.1 v1(71.29,55.27) ; PR207.1 v1(57.47,64.52) ; v1(259.93,11.45) 259.98,11.5 259.98,13.17 JSPK1.8 ; 170.69,95.77 171.61,95.77 172,95.37 174.33,95.37 175.14,96.18 175.14,96.49 v1(175.75,97.1) ; 180.37,48.38 180.52,48.38 181.69,49.55 181.69,52.56 180.87,53.39 v3(180.8,53.39) 180.58,53.61 PR416.2 ; v1(119.23,78.23) 119.19,78.27 119.19,78.58 118.63,79.13 CC21.2 ; v1(256.95,26.92) 257.65,27.62 JNGFF2.76 ; PR506.2 v1(177.45,103.45) ; v1(52.25,93.39) 52.25,92.83 PQ6.3 ; v1(162.36,52.93) CC8.2 162.36,52.27 ; CL22.1 v1(261.8,80.06) ; JSPK1.6 258.1,15.75 v1(258.86,14.99) ; RD23.2 v1(203.93,16.98) ; v1(49.25,90.65) 49.95,91.35 PR30.2 ; v1(44,70.46) 44,70.4 CT70.2 ; CC302.2 146.36,86.69 v1(146.84,86.2) ; JFAN1.5 v1(174.68,88.38) ; RT413.2 30.18,82.29 v1(30,82.11) ; CR22.2 78.12,99.61 77.61,100.12 76.48,100.12 v1(76.46,100.1) ; v1(156.65,77.72) 156.49,77.87 CC225.2 ; v1(287.33,50.21) 287.46,50.08 CV134.2 ; PC644.2 64.67,73.36 v1(64.44,73.14) ; v1(76.14,63.27) 76.02,63.14 75.5,63.14 PC641.2 ; H4.1 150.19,50.44 151.28,51.53 152.12,52.37 RC4.2 ; PC204.2 49.36,59.97 v1(49.36,59.66) ; PC107.2 127.92,109.08 v1(127.56,109.08) ; RC122.2 v1(102.01,91.66) ; CC212.2 149.56,61.54 149.57,61.53 CC222.2 150.31,61.44 v1(150.31,60.63) ; PC119.2 38.92,46.99 v1(39.22,46.69) ; v1(239.55,9.98) 239.21,10.32 JDEG1.11 ; v1(242.83,18.46) 243.51,17.78 244.71,17.78 244.8,17.87 CN1.2 ; PR206.2 56.52,64.43 v1(56.44,64.51) ; v1(165.66,59.66) 165.26,60.06 UC5.4 ; CC310.2 104.54,88.87 104.93,88.48 v1(104.93,87.09) 104.93,87.09 RC113.2 ; PC9.2 v1(54.28,91.52) ; UT6.4 v1(55.91,66.09) ; v1(87.49,64.31) 87.13,64.68 PH601.1 ; v1(49.51,88.34) 50.97,88.34 PU1.3 ; v1(91.21,90.42) 90.78,90.85 90.78,91.61 91.29,92.12 RC219.2 ; JNGFF2.77 278.35,29.98 277.94,30.39 v1(276.66,30.39) ; UV4.2 v1(289.04,43.92) ; v1(149.88,59.37) 149.37,59.37 CC204.2 149.24,59.22 CC23.2 ; CC219.2 132.69,80.91 132.58,80.79 v1(132.31,80.79) ; JSIM1.12 v1(111.39,94.41) ; v1(260.18,21.61) 260.18,21.66 260.2,21.69 260.2,22.75 259.95,23.01 JSPK1.7 ; PC111.2 v1(140.26,100.38) ; RC227.2 150.45,89.45 v1(150.58,89.58) ; v1(14.28,81.33) 14.13,81.48 DT4.1 12.15,81.48 v1(11.99,81.33) ; v1(70.92,73.01) 70.6,73.33 PC601.2 ; JSIM1.16 v1(122.91,109.57) ; v1(77.14,88.21) 76.75,88.61 RR4.2 ; PR302.2 v1(165.78,106.82) ; JFAN1.6 v1(180.72,83.58) ; v1(17.07,50.41) UV2.2
  vias: v1(0.43,15.33) v1(0.43,11.52) v1(0.69,56.38) v1(1.17,38.03) v1(1.21,35.17) v1(2.57,18.47) v1(2.72,13.76) v1(2.71,9.13) v1(3.09,32.93) v1(3.15,58.9) v1(3.67,10.21) v1(4.14,80.53) v1(4.14,62.43) v1(4.12,37.26) v1(4.12,34.59) v1(5.03,56.28) v1(5.15,82.27) v1(5.15,78.79) v1(5.15,64.17) v1(5.15,60.69) v1(5.31,83.37) v1(5.54,12.7) v1(6.15,40.02) v1(6.55,14.44) v1(6.55,10.96) v1(6.52,9.13) v1(7.04,57.4) v1(7.15,82.27) v1(7.15,78.79) v1(7.15,64.17) v1(7.15,60.69) v1(7.19,36.75) v1(7.87,74.86) v1(8.02,38.19) v1(8.02,35.31) v1(8.16,80.53) v1(8.16,62.43) v1(8.58,67.51) v1(8.58,66.93) v1(8.58,66.33) v1(8.55,14.44) v1(8.55,10.96) v1(8.64,76.23) v1(8.64,75.65) v1(8.64,75.07) v1(8.84,56.28) v1(9.07,65.96) v1(9.56,12.7) v1(9.68,38.19) v1(9.68,35.31) v1(9.88,83.36) v1(9.94,68.83) v1(9.96,40.14) v1(10.19,18.47) v1(10.49,9.14) v1(10.51,36.75) v1(10.71,32.93) v1(11.23,64.69) v1(11.23,63.42) v1(11.23,62.15) v1(11.23,60.88) v1(11.37,10.19) v1(11.76,34.39) v1(12.93,83.37) v1(13.54,38.05) v1(13.75,31.26) v1(13.75,19.83) v1(13.77,14.78) v1(14.14,9.13) v1(14.28,63.45) v1(14.25,62.76) v1(14.25,62.12) v1(14.28,61.51) v1(14.55,39.79) v1(14.55,36.31) v1(15.65,64.51) v1(16.04,76.91) v1(16.04,75.13) v1(16.18,33.45) v1(16.55,39.79) v1(16.55,36.31) v1(16.69,72.21) v1(16.74,83.37) v1(16.74,70.35) v1(17.56,38.05) v1(17.78,73.58) v1(17.78,69.92) v1(17.81,71.75) v1(17.95,9.13) v1(18.72,60.88) v1(18.72,58.97) v1(18.98,47.8) v1(18.98,46.02) v1(18.98,44.24) v1(18.94,15.3) v1(19.44,23.08) v1(20,17.13) v1(20,13.47) v1(20.55,83.37) v1(20.63,81.71) v1(20.98,30.21) v1(21.02,30.82) v1(21.26,81.71) v1(21.34,38.85) v1(21.34,38.26) v1(21.47,44.19) v1(21.61,46) v1(21.65,30.82) v1(21.62,30.21) v1(21.72,32.13) v1(21.73,31.52) v1(21.76,9.13) v1(21.94,42.52) v1(22.1,17.13) v1(22.1,13.47) v1(22.24,30.79) v1(22.25,30.21) v1(23.04,72.34) v1(23.16,15.3) v1(23.65,25.83) v1(23.72,31.38) v1(23.77,25.18) v1(24.19,74.21) v1(24.36,83.37) v1(24.38,31.38) v1(24.31,25.83) v1(24.36,25.2) v1(24.58,47.49) v1(24.85,72.34) v1(25,25.85) v1(25.04,31.38) v1(25.04,25.23) v1(25.07,11.6) v1(25.58,25.85) v1(25.57,9.13) v1(25.66,63.23) v1(25.7,31.38) v1(25.73,62.63) v1(25.71,60.44) v1(25.71,25.23) v1(26.19,25.83) v1(26.24,63.33) v1(26.29,25.23) v1(26.69,76.19) v1(26.69,74.78) v1(26.92,60.35) v1(27.5,60.32) v1(27.8,76.19) v1(27.8,74.78) v1(27.8,73.36) v1(28.09,60.32) v1(28.07,22.18) v1(28.07,21.56) v1(28.17,83.37) v1(28.3,54.35) v1(28.59,63.27) v1(28.68,60.88) v1(28.67,60.28) v1(28.67,22.18) v1(28.67,21.55) v1(28.92,74.78) v1(29.28,22.18) v1(29.28,21.55) v1(29.37,20.94) v1(29.39,20.3) v1(29.38,9.13) v1(29.87,22.18) v1(29.87,21.55) v1(29.94,45.16) v1(29.94,44.04) v1(29.94,42.92) v1(29.95,20.94) v1(29.98,20.3) v1(29.9,11.6) v1(30.19,36.41) v1(30.19,35.1) v1(30.19,33.78) v1(30.19,32.47) v1(30.18,30.9) v1(30.18,29.58) v1(30.18,28.27) v1(30.18,26.96) v1(30.51,22.18) v1(30.51,21.55) v1(30.54,20.94) v1(30.56,20.3) v1(31.05,45.16) v1(31.05,44.04) v1(31.05,42.92) v1(31.2,36.41) v1(31.2,35.1) v1(31.2,33.78) v1(31.13,32.47) v1(31.19,30.9) v1(31.19,29.58) v1(31.19,28.27) v1(31.11,26.96) v1(31.14,22.18) v1(31.14,21.55) v1(31.12,20.94) v1(31.14,20.3) v1(31.98,83.37) v1(32.17,45.16) v1(32.17,44.04) v1(32.17,42.92) v1(32.19,30.9) v1(32.19,29.58) v1(32.19,28.27) v1(32.21,36.41) v1(32.21,35.1) v1(32.21,33.78) v1(33.19,9.13) v1(33.76,76.65) v1(33.71,75.15) v1(34.47,78.3) v1(34.88,75.1) v1(35.28,51.57) v1(35.28,50.99) v1(35.28,50.38) v1(35.28,49.79) v1(35.51,77.03) v1(35.64,79.65) v1(35.87,51.57) v1(35.87,50.99) v1(35.87,50.38) v1(35.87,49.79) v1(35.98,83.75) v1(36.25,78.33) v1(36.3,53.77) v1(36.3,53.18) v1(36.43,94.56) v1(36.43,90.75) v1(36.43,86.94) v1(36.45,51.57) v1(36.45,50.99) v1(36.45,50.38) v1(36.45,49.79) v1(36.54,100.6) v1(37,9.13) v1(37.55,102.34) v1(37.55,98.86) v1(37.9,87.6) v1(37.9,86.97) v1(37.9,86.33) v1(38.49,87.6) v1(38.49,86.97) v1(38.49,86.33) v1(39.07,87.6) v1(39.07,86.97) v1(39.07,86.33) v1(39.55,102.34) v1(39.55,98.86) v1(39.65,87.6) v1(39.65,86.97) v1(39.65,86.33) v1(40.24,87.6) v1(40.24,86.97) v1(40.24,86.33) v1(40.56,100.6) v1(40.81,9.13) v1(41.18,47.32) v1(41.15,41.32) v1(41.38,40.76) v1(41.53,37.18) v1(41.53,36.57) v1(41.79,47.32) v1(41.87,44.74) v1(42.09,35.86) v1(42.12,37.16) v1(42.12,36.57) v1(42.7,97.46) v1(42.7,96.82) v1(42.7,37.13) v1(42.7,36.55) v1(42.73,35.86) v1(43.11,79.29) v1(43.29,97.46) v1(43.29,96.82) v1(43.36,37.13) v1(43.36,36.5) v1(43.36,35.86) v1(43.87,97.46) v1(43.87,96.82) v1(44.22,101.87) v1(44.62,9.13) v1(44.89,27.48) v1(44.89,26.79) v1(45.25,77.53) v1(45.39,27.1) v1(48.41,102.87) v1(48.43,9.13) v1(49.56,100.12) v1(49.56,99.54) v1(50.14,100.12) v1(50.14,99.54) v1(50.18,18.77) v1(50.17,17.25) v1(50.73,100.12) v1(50.73,99.54) v1(51.91,15.4) v1(51.92,13.87) v1(52.13,26.16) v1(52.13,25.56) v1(52.22,102.87) v1(52.24,9.13) v1(52.64,18.52) v1(52.8,15.98) v1(52.82,48.6) v1(52.82,47.96) v1(53.52,47.67) v1(53.58,14.73) v1(53.53,13.21) v1(53.83,55.29) v1(53.83,54.71) v1(53.83,54.12) v1(53.83,53.49) v1(54.49,55.22) v1(54.7,17.17) v1(54.75,15.4) v1(55.07,55.22) v1(55.11,13.9) v1(55.55,74.52) v1(55.63,54.89) v1(55.63,54.3) v1(56.03,102.87) v1(56.05,9.13) v1(56.24,59.4) v1(56.37,95.78) v1(56.37,94.97) v1(56.37,94.38) v1(56.6,56.14) v1(56.78,13.85) v1(56.84,56.7) v1(56.96,17.81) v1(56.99,16.28) v1(57.36,59.42) v1(58.07,93.9) v1(58.02,58.59) v1(58.35,58.09) v1(58.6,59.61) v1(58.63,58.62) v1(58.79,17.6) v1(58.99,15.22) v1(59.84,102.87) v1(59.86,9.13) v1(60.01,58.29) v1(60.13,56.05) v1(60.16,17.94) v1(60.16,16.41) v1(60.58,59.08) v1(60.61,58.2) v1(60.82,14.71) v1(60.99,58.66) v1(60.93,13.14) v1(61.27,78.79) v1(61.27,78.15) v1(61.4,58.24) v1(62.43,109.74) v1(62.43,105.93) v1(62.47,17.05) v1(62.55,18.57) v1(62.88,14.25) v1(63.47,109.66) v1(63.47,109.08) v1(63.47,108.44) v1(63.47,107.81) v1(63.47,107.17) v1(63.48,106.55) v1(63.48,105.96) v1(63.49,105.3) v1(63.49,104.72) v1(63.58,50.78) v1(63.67,9.13) v1(64.06,100.94) v1(64.06,100.3) v1(64.06,99.46) v1(64.06,98.88) v1(64.11,108.49) v1(64.19,88.34) v1(64.18,18.37) v1(64.19,16.13) v1(64.2,62.07) v1(64.5,61.46) v1(64.83,88.34) v1(64.81,62) v1(64.96,14.6) v1(64.93,13.03) v1(65.15,111.67) v1(65.26,50.02) v1(65.46,88.34) v1(65.52,104.78) v1(65.52,104.2) v1(65.52,103.62) v1(65.87,50.02) v1(66.15,91.72) v1(66.18,18.77) v1(66.16,17.25) v1(66.35,84.5) v1(66.73,97.3) v1(66.86,105.84) v1(66.83,99.59) v1(66.85,68.53) v1(66.85,67.01) v1(66.85,65.48) v1(66.89,14.25) v1(66.93,84.5) v1(66.94,52.65) v1(66.91,52.04) v1(66.91,51.3) v1(66.92,50.5) v1(67.31,97.3) v1(67.35,56.43) v1(67.35,55.85) v1(67.34,55.27) v1(67.34,54.68) v1(67.48,9.13) v1(67.52,84.5) v1(67.57,52.65) v1(67.54,52.04) v1(67.54,51.3) v1(67.56,50.5) v1(67.97,82.11) v1(67.94,56.43) v1(67.94,55.85) v1(67.92,55.27) v1(67.94,54.68) v1(68.01,15.45) v1(68.09,13.24) v1(68.18,52.04) v1(68.18,51.3) v1(68.21,52.65) v1(68.2,50.5) v1(68.37,68.53) v1(68.37,67.01) v1(68.37,65.48) v1(68.44,56.14) v1(68.44,55.55) v1(68.48,54.96) v1(68.43,54.35) v1(68.56,82.11) v1(68.72,18.75) v1(68.84,111.64) v1(68.85,17.22) v1(68.98,55.28) v1(68.97,54.63) v1(68.92,15.7) v1(69.53,10.37) v1(69.64,13.77) v1(69.89,68.53) v1(69.89,67.01) v1(69.89,65.48) v1(70.29,104.06) v1(70.92,104.06) v1(71.02,87.5) v1(71.18,18.71) v1(71.29,9.13) v1(71.34,10.34) v1(71.45,17.23) v1(71.56,107.62) v1(71.68,103.65) v1(71.61,87.5) v1(71.82,14.2) v1(72.19,87.5) v1(72.18,18.62) v1(72.2,17.48) v1(72.32,77.73) v1(72.49,112.5) v1(72.79,13.97) v1(72.71,13.21) v1(72.83,101.93) v1(72.88,100.63) v1(73.12,10.34) v1(74.15,55.72) v1(74.15,55.11) v1(74.6,60.12) v1(74.6,59.48) v1(74.68,56.03) v1(74.68,55.44) v1(74.68,54.86) v1(74.71,77.29) v1(74.72,76.5) v1(74.72,56.63) v1(75.1,9.13) v1(75.26,56.03) v1(75.26,55.44) v1(75.26,54.86) v1(75.27,13.11) v1(75.33,56.61) v1(75.33,13.72) v1(75.63,17.86) v1(75.77,81) v1(75.85,56.03) v1(75.85,55.44) v1(75.85,54.86) v1(75.99,112.66) v1(75.93,79.71) v1(75.93,78.95) v1(75.93,78.21) v1(75.93,77.42) v1(75.95,71.24) v1(75.95,70.66) v1(75.91,56.61) v1(76.23,73.64) v1(76.23,73.05) v1(76.31,80.36) v1(76.43,60.97) v1(76.43,60.38) v1(76.47,15.12) v1(76.51,79.71) v1(76.51,78.95) v1(76.51,78.21) v1(76.51,77.42) v1(76.53,71.24) v1(76.53,70.66) v1(76.52,69.05) v1(76.51,67.64) v1(76.89,83.66) v1(76.89,80.36) v1(76.9,82.98) v1(76.9,82.39) v1(76.9,81.73) v1(76.9,81.15) v1(77.04,60.96) v1(77.04,60.37) v1(77.05,17.02) v1(77.5,83.59) v1(77.5,83) v1(77.5,82.34) v1(77.5,81.76) v1(77.49,81.16) v1(77.48,80.36) v1(77.63,60.96) v1(77.63,60.37) v1(77.6,47.19) v1(78.05,83.37) v1(78.05,82.71) v1(78.05,82.13) v1(78.19,47.19) v1(78.25,94.87) v1(78.25,92.64) v1(78.55,83.68) v1(78.58,17.53) v1(78.91,9.13) v1(79.05,60.75) v1(79.37,93.75) v1(79.44,74.19) v1(79.62,112.67) v1(79.94,86.99) v1(79.97,16.51) v1(80.03,74.19) v1(80.12,62.44) v1(80.12,61.81) v1(80.12,61.17) v1(80.1,14.99) v1(80.32,32.53) v1(80.48,92.64) v1(80.75,32.94) v1(80.88,62.44) v1(80.88,61.81) v1(80.88,61.17) v1(80.98,88.13) v1(81.18,33.4) v1(81.5,16.26) v1(81.62,62.44) v1(81.62,61.81) v1(81.62,61.17) v1(81.64,54.75) v1(81.84,55.33) v1(82.22,54.89) v1(82.41,62.47) v1(82.41,61.82) v1(82.41,61.18) v1(82.64,59.78) v1(82.72,9.13) v1(83.28,18.32) v1(83.44,112.66) v1(83.43,59.79) v1(83.5,13.85) v1(85.27,18.7) v1(85.4,16.25) v1(86.53,9.13) v1(87.05,72.31) v1(87.05,71.67) v1(87.05,71.04) v1(87.18,16) v1(87.23,112.66) v1(87.61,86.04) v1(87.69,71.04) v1(88.19,14.5) v1(89.08,64.31) v1(89.2,69.82) v1(89.26,82.47) v1(89.22,69.22) v1(89.39,64.82) v1(89.41,63.8) v1(89.54,83) v1(89.52,17.57) v1(89.78,69.81) v1(89.72,64.31) v1(89.84,82.47) v1(89.86,69.22) v1(90.02,64.82) v1(90.05,63.8) v1(90.12,83) v1(90.35,64.31) v1(90.34,9.13) v1(90.53,81.89) v1(90.78,63.9) v1(90.81,87.92) v1(90.81,82.42) v1(91.03,112.66) v1(91.11,81.91) v1(91.5,83) v1(91.5,82.42) v1(91.62,96.06) v1(91.93,82.01) v1(92.13,105.61) v1(92.35,87.92) v1(92.48,54.89) v1(92.88,18.19) v1(92.88,16.64) v1(92.85,15.06) v1(93.21,13.9) v1(93.69,54.9) v1(93.99,17.96) v1(94.15,9.13) v1(94.26,56.82) v1(94.33,59.28) v1(94.58,14.73) v1(94.87,112.67) v1(94.83,18.75) v1(94.83,16.23) v1(95.33,13.99) v1(95.56,88.06) v1(95.63,59.28) v1(95.77,60.42) v1(96.19,88.06) v1(96.19,87.42) v1(96.15,14.02) v1(96.21,56.82) v1(96.2,13.21) v1(96.66,16.36) v1(96.79,18.75) v1(97.59,60.35) v1(97.51,59.31) v1(97.76,46.23) v1(97.79,44.37) v1(97.98,14.2) v1(97.92,13.03) v1(97.93,10.32) v1(97.96,9.13) v1(98.18,47.94) v1(98.24,18.7) v1(98.26,17.17) v1(98.69,112.67) v1(99.96,14.13) v1(100.02,46.1) v1(100.35,47.8) v1(100.34,17.71) v1(100.37,16.18) v1(100.93,13.29) v1(101.41,111.72) v1(101.77,9.13) v1(102.18,18.72) v1(102.17,17.2) v1(102.31,45.19) v1(102.4,13.26) v1(102.59,47.04) v1(102.86,77.77) v1(103.49,14.3) v1(103.62,76.69) v1(104.06,43.1) v1(104.15,99.36) v1(104.44,47.8) v1(104.44,45.95) v1(104.44,44.17) v1(104.87,17.83) v1(105.48,14.43) v1(105.58,9.13) v1(106.08,67.53) v1(106.27,112.36) v1(106.28,66.47) v1(106.35,60.5) v1(106.39,18.8) v1(106.59,16.44) v1(106.54,14.81) v1(106.71,64.29) v1(107.04,61.95) v1(107.06,47.12) v1(107.03,45.24) v1(107.03,43.38) v1(107.12,111.04) v1(107.43,13.51) v1(107.92,64.3) v1(108.16,78.46) v1(108.23,61.95) v1(108.43,13.19) v1(108.43,10.45) v1(108.55,14.71) v1(108.64,67.61) v1(108.87,65.89) v1(108.98,16.11) v1(109.01,17.65) v1(109.12,64.3) v1(109.22,46.43) v1(109.24,44.6) v1(109.24,42.7) v1(109.39,9.13) v1(109.43,10.47) v1(110.08,112.36) v1(110.55,61.44) v1(110.55,60.85) v1(110.55,60.24) v1(110.54,45.99) v1(110.51,44.01) v1(110.64,77.47) v1(110.95,10.55) v1(111.24,17.68) v1(111.29,16.16) v1(111.24,14.63) v1(111.43,13.13) v1(111.69,62.4) v1(111.73,78.46) v1(111.71,65.12) v1(111.71,64.54) v1(111.71,63.95) v1(111.91,42.01) v1(112.42,45.03) v1(112.42,43.08) v1(112.52,46.46) v1(112.62,48.36) v1(112.68,18.46) v1(112.97,15.42) v1(112.93,13.06) v1(113.09,24.56) v1(113.19,63.09) v1(113.2,9.13) v1(113.28,25.19) v1(113.8,78.69) v1(113.8,63.09) v1(113.89,111.27) v1(113.91,24.56) v1(114.06,14.68) v1(114.1,83.05) v1(114.21,21.44) v1(114.38,77.01) v1(114.66,81.43) v1(115.14,46.2) v1(115.14,44.27) v1(115.62,69.95) v1(115.75,63.95) v1(115.75,62.73) v1(115.75,61.56) v1(115.78,60.39) v1(116.29,77.18) v1(116.59,79.02) v1(116.56,48.46) v1(116.71,46.38) v1(116.72,44.37) v1(117.01,9.13) v1(117.4,67.61) v1(118.03,78.21) v1(118.19,64.05) v1(118.19,62.81) v1(118.19,61.64) v1(118.19,60.47) v1(118.31,111.27) v1(118.93,75.74) v1(119.25,48.34) v1(119.28,44.5) v1(119.3,46.3) v1(120.53,64.69) v1(120.55,62.84) v1(120.58,61.64) v1(120.55,60.45) v1(120.65,48.11) v1(120.65,46.3) v1(120.62,44.42) v1(120.62,43.21) v1(120.82,9.13) v1(120.91,67.61) v1(121.9,61.01) v1(121.9,60.42) v1(122.06,74.37) v1(122.17,90.6) v1(122.38,112.34) v1(122.44,13.2) v1(122.54,20.7) v1(122.76,60.83) v1(122.91,65.99) v1(122.94,64.72) v1(122.91,62.1) v1(122.91,61.51) v1(123.01,47.14) v1(123.04,45.21) v1(123.06,43.28) v1(123.09,42.04) v1(123.5,15.03) v1(123.5,11.37) v1(123.55,22.44) v1(123.55,18.96) v1(123.95,90.6) v1(124.52,92.68) v1(124.63,9.13) v1(124.84,47.07) v1(124.84,45.14) v1(124.84,43.21) v1(125.1,92.68) v1(125.33,111.27) v1(125.33,64.57) v1(125.55,22.44) v1(125.55,18.96) v1(125.68,92.68) v1(125.6,15.03) v1(125.6,11.37) v1(125.83,90.55) v1(126.17,61.96) v1(126.14,47.32) v1(126.14,45.47) v1(126.11,43.59) v1(126.56,20.7) v1(126.66,13.2) v1(127.56,104.69) v1(127.89,76.04) v1(127.85,45.28) v1(128.1,46.56) v1(128.44,9.13) v1(128.83,112.4) v1(130.1,86.36) v1(130.32,17.6) v1(131.04,86.41) v1(131.84,17.6) v1(131.95,86.31) v1(131.95,79) v1(132.21,76.7) v1(132.25,9.13) v1(132.47,14.86) v1(132.42,10.37) v1(132.52,112.67) v1(133.74,15.16) v1(133.86,26.84) v1(133.81,16.4) v1(134.55,18.03) v1(135.07,25.76) v1(135.18,13.51) v1(135.56,110.66) v1(135.69,25.76) v1(136.06,9.13) v1(136.33,25.76) v1(136.36,13.85) v1(136.77,17.65) v1(136.71,15.16) v1(137.17,15.93) v1(137.58,14.13) v1(137.72,76.37) v1(138.68,18.02) v1(138.71,78.39) v1(138.84,77.5) v1(139.02,14.27) v1(139.4,16.05) v1(139.44,112.67) v1(139.42,47.15) v1(139.87,9.13) v1(140.26,106.35) v1(140.26,105.71) v1(140.88,13.62) v1(141.61,47.19) v1(141.73,18.04) v1(141.74,16.52) v1(141.8,14.15) v1(142.55,59.36) v1(142.61,15.92) v1(142.75,46.75) v1(142.93,106.6) v1(143.25,112.67) v1(143.26,45.96) v1(143.22,13.31) v1(143.45,18.03) v1(143.68,9.13) v1(144.1,58.21) v1(144.34,13.95) v1(144.71,15.94) v1(145.23,58.21) v1(145.31,18.03) v1(145.57,109.57) v1(145.53,58.72) v1(145.79,106.09) v1(145.98,106.73) v1(146.04,108) v1(146.04,107.36) v1(146.16,109.57) v1(146.22,14.86) v1(146.68,108) v1(146.61,16.3) v1(146.74,109.58) v1(147.06,112.67) v1(147.18,18.04) v1(147.31,108.76) v1(147.46,14.13) v1(147.49,9.13) v1(147.84,105.15) v1(148.26,109.58) v1(149.1,30.24) v1(149.06,14.13) v1(149.59,107.68) v1(149.59,102.62) v1(149.68,30.24) v1(149.92,17.45) v1(150.27,30.24) v1(150.87,112.67) v1(150.9,30.24) v1(151.3,9.13) v1(151.4,15.47) v1(151.42,13.31) v1(152.51,107.68) v1(152.51,102.62) v1(152.54,13.33) v1(152.77,14.71) v1(153.1,17.15) v1(153.47,14.86) v1(154.26,105.15) v1(154.68,112.67) v1(154.64,17.12) v1(155.11,9.13) v1(155.92,14.23) v1(156.07,61.35) v1(156.07,59.83) v1(156.21,55.01) v1(156.21,54.43) v1(156.8,15.23) v1(157.32,13.16) v1(157.6,61.35) v1(157.6,59.83) v1(157.6,58.3) v1(158.17,17.47) v1(158.36,16.11) v1(158.49,112.67) v1(158.92,9.13) v1(159.12,59.83) v1(160.33,15.41) v1(160.77,105.22) v1(160.72,55.88) v1(161.51,108.82) v1(161.51,108.24) v1(161.52,107.64) v1(162.07,18.34) v1(162.15,108.82) v1(162.15,108.24) v1(162.13,107.64) v1(162.17,16.64) v1(162.17,15.12) v1(162.3,112.67) v1(162.78,108.82) v1(162.78,108.24) v1(162.77,107.64) v1(162.73,9.13) v1(163.35,107.67) v1(163.31,84.44) v1(163.31,83.17) v1(163.31,81.9) v1(163.72,18.16) v1(163.75,16.62) v1(163.82,13.26) v1(164.67,63.42) v1(164.77,16.07) v1(165.49,84.44) v1(165.49,83.17) v1(165.49,81.9) v1(165.57,17.73) v1(165.98,104.1) v1(165.98,103.51) v1(165.98,102.88) v1(165.98,102.24) v1(166.3,70.86) v1(166.21,15.37) v1(166.59,10.42) v1(166.54,9.13) v1(166.63,77.34) v1(166.82,110.67) v1(166.88,70.46) v1(167.03,101.33) v1(167.03,100.75) v1(167.03,100.11) v1(167.03,99.49) v1(167.03,98.85) v1(167.03,98.27) v1(167.53,15.78) v1(167.68,84.44) v1(167.68,83.17) v1(167.68,81.9) v1(167.8,107.59) v1(167.8,107.01) v1(167.98,14.99) v1(168.2,13.92) v1(168.38,17.19) v1(169.35,17.04) v1(169.86,84.44) v1(169.86,83.17) v1(169.86,81.9) v1(169.86,15.37) v1(169.86,13.85) v1(170.05,112.67) v1(170.01,95.73) v1(170.01,95.14) v1(170.01,94.56) v1(170.21,103.4) v1(170.35,9.13) v1(170.41,100.69) v1(170.79,98.14) v1(170.79,97.19) v1(170.92,96.59) v1(171.39,98.12) v1(171.39,97.16) v1(171.71,17.7) v1(171.89,16.02) v1(172.14,63.17) v1(172.2,99.68) v1(172.36,13.97) v1(172.52,54.33) v1(172.52,53.72) v1(172.52,53.13) v1(172.68,100.12) v1(172.68,99.23) v1(172.88,17.7) v1(173.16,99.68) v1(173.86,112.67) v1(173.84,109.8) v1(173.84,109.17) v1(173.94,49.15) v1(173.94,48.56) v1(174.08,13.08) v1(174.16,9.13) v1(174.43,109.77) v1(174.43,109.17) v1(174.61,16.39) v1(174.74,50.47) v1(175.22,50.91) v1(175.22,50.02) v1(175.7,50.47) v1(175.68,18.6) v1(175.68,16.93) v1(175.68,15.4) v1(175.73,13.13) v1(175.85,61.8) v1(176.38,85.64) v1(176.36,80.67) v1(176.41,97.1) v1(176.87,14.56) v1(176.92,13.03) v1(177.02,97.13) v1(177.67,112.67) v1(177.75,97.94) v1(177.92,13.43) v1(177.97,9.13) v1(178.02,17.99) v1(178.02,15.55) v1(178.65,13.34) v1(179.83,21.66) v1(179.9,13.87) v1(179.99,47.68) v1(179.99,47.09) v1(179.97,18.75) v1(179.97,17.22) v1(180.4,15.83) v1(180.41,15.2) v1(181.17,10.47) v1(181.32,111.64) v1(181.53,91.72) v1(181.78,9.13) v1(182.1,18.53) v1(182.11,91.93) v1(182.11,17) v1(182.38,14.08) v1(182.62,108.45) v1(182.62,104.64) v1(182.66,100.83) v1(182.74,91.93) v1(183.35,97.07) v1(183.68,17.22) v1(183.62,15.7) v1(183.73,18.75) v1(184.12,92.86) v1(184.46,15.74) v1(184.43,13.22) v1(184.73,89.54) v1(185.27,86.64) v1(185.59,9.13) v1(185.74,84.06) v1(186.19,81.58) v1(186.17,18.68) v1(186.15,17.15) v1(186.12,15.4) v1(186.15,13.85) v1(187.51,15.67) v1(187.67,13.93) v1(187.74,73.25) v1(188.18,18.75) v1(188.13,16.41) v1(188.27,70.38) v1(188.71,13.11) v1(188.93,67.79) v1(189.4,9.13) v1(189.52,14.71) v1(190.02,64.72) v1(190.89,13.7) v1(191.09,62.43) v1(191.2,17.86) v1(191.17,16.33) v1(192.24,15.37) v1(192.37,13.85) v1(192.54,59.89) v1(193.15,38.5) v1(193.26,15.7) v1(193.21,9.13) v1(193.61,17.2) v1(193.98,57.81) v1(194.37,15.54) v1(194.63,13.11) v1(194.75,16.56) v1(194.85,27.99) v1(194.85,27.4) v1(195.38,15.44) v1(195.43,27.43) v1(195.43,26.84) v1(195.42,13.88) v1(195.66,55.77) v1(196.47,46.33) v1(196.86,18.78) v1(196.86,18.16) v1(197.02,9.13) v1(197.51,53.89) v1(197.69,45.06) v1(198.96,43.84) v1(198.98,31.16) v1(199.57,31.16) v1(199.9,51.86) v1(200.16,31.14) v1(200.66,30.63) v1(200.83,9.13) v1(201.02,25.24) v1(201.63,25.24) v1(202.59,50.01) v1(204.17,33.88) v1(204.64,9.13) v1(205.01,10.59) v1(205.59,10.59) v1(206.2,48.1) v1(207.22,39.42) v1(207.8,39.42) v1(208.39,39.42) v1(208.45,9.13) v1(209.61,46.81) v1(209.66,10.59) v1(210.09,17.95) v1(210.24,10.59) v1(210.67,17.95) v1(210.82,10.59) v1(211.26,17.95) v1(211.41,10.59) v1(212.26,9.13) v1(213.87,45.79) v1(214.81,36.17) v1(215.42,36.17) v1(216.07,9.13) v1(216.59,18.59) v1(216.72,19.86) v1(216.74,19.17) v1(217.69,14.12) v1(217.69,12.32) v1(218.16,45.36) v1(218.42,16.68) v1(218.73,14.12) v1(218.73,12.32) v1(218.93,17.19) v1(219.88,9.13) v1(221.51,11.72) v1(221.86,12.23) v1(222.18,45.51) v1(222.81,39.67) v1(223.07,14.49) v1(223.4,12.37) v1(224.72,39.67) v1(224.97,21.26) v1(224.97,19.6) v1(225.86,26.87) v1(226.57,46.27) v1(226.74,14.49) v1(228.5,14.49) v1(228.66,36.75) v1(228.68,12.36) v1(230.15,47.39) v1(230.46,23.95) v1(232.16,36.75) v1(232.21,40.94) v1(232.45,9.13) v1(233.28,48.76) v1(234.01,37.13) v1(234.07,32.99) v1(235.02,23.2) v1(235.02,22.08) v1(235.02,20.96) v1(235.64,33.07) v1(236.16,36.67) v1(236.14,23.2) v1(236.14,22.08) v1(236.14,20.96) v1(236.26,9.13) v1(236.73,32.98) v1(236.86,50.9) v1(237.25,23.2) v1(237.25,22.08) v1(237.25,20.96) v1(240.01,53.36) v1(240.07,9.13) v1(241.02,18.46) v1(242.03,6.13) v1(242.03,2.32) v1(243.4,14.69) v1(244.53,2.08) v1(244.66,0.43) v1(245.42,2.08) v1(246.28,98.32) v1(246.73,24.55) v1(246.73,23.44) v1(246.97,95.42) v1(247.5,39.61) v1(247.59,9.04) v1(247.73,92.22) v1(247.85,24.55) v1(247.85,23.44) v1(247.85,22.32) v1(247.96,64.44) v1(248.18,9.04) v1(248.28,5.47) v1(248.47,89.1) v1(248.47,0.43) v1(248.92,67) v1(248.97,24.55) v1(248.97,23.44) v1(248.97,22.32) v1(249.03,86.71) v1(249.61,84.2) v1(249.76,70.1) v1(250.12,81.66) v1(250.22,72.61) v1(250.42,79.09) v1(250.5,76.48) v1(250.52,40.15) v1(251.46,29.33) v1(251.58,45.13) v1(251.83,78.09) v1(251.83,45.7) v1(252.09,77.52) v1(252.28,0.43) v1(252.49,89.2) v1(252.73,102.87) v1(252.91,35.89) v1(253.5,35.89) v1(254.04,95.3) v1(254.06,2.21) v1(254.44,27.86) v1(254.69,2.21) v1(254.84,96.29) v1(254.94,29.38) v1(255.2,92.2) v1(255.12,39.01) v1(255.37,74.59) v1(255.37,73.32) v1(255.37,72.05) v1(255.33,2.21) v1(256.09,0.43) v1(256.23,101.89) v1(256.64,74.59) v1(256.64,73.32) v1(256.64,72.05) v1(257.46,62.99) v1(257.91,74.59) v1(257.91,73.32) v1(257.91,72.05) v1(258.91,8.02) v1(259.9,0.43) v1(260.51,8.05) v1(261.95,102.87) v1(262.56,8.15) v1(263.01,22.02) v1(263.01,20.05) v1(263.01,18.08) v1(263.17,8.15) v1(263.71,0.43) v1(264.98,22.02) v1(264.98,20.05) v1(264.98,18.08) v1(265.49,66.72) v1(265.64,33.73) v1(265.76,102.87) v1(266.12,66.72) v1(266.76,66.72) v1(266.95,22.02) v1(266.95,20.05) v1(266.95,18.08) v1(267.11,6.02) v1(267.52,0.43) v1(267.72,6.02) v1(268.32,6.02) v1(269.47,11.26) v1(269.57,102.87) v1(269.6,30.61) v1(270.67,99.75) v1(271.12,96.25) v1(271.33,0.43) v1(271.76,13.76) v1(273.61,14.02) v1(274.9,95.87) v1(275.04,6.02) v1(275.14,0.43) v1(275.34,13.86) v1(276.76,6.02) v1(277.42,8.68) v1(277.42,8.1) v1(277.42,7.51) v1(277.94,15.3) v1(278.71,95.87) v1(278.97,19.45) v1(279,17.13) v1(279,13.47) v1(279.23,21.94) v1(279.23,21.36) v1(279.23,20.77) v1(280.8,42.97) v1(281.1,17.13) v1(281.17,13.51) v1(282.16,15.3) v1(282.25,35.1) v1(282.25,34.46) v1(282.66,49.93) v1(282.66,47.7) v1(282.88,34.84) v1(282.95,63.99) v1(283.01,28.34) v1(283.01,27.76) v1(283.01,27.17) v1(283.49,41.42) v1(283.65,18.33) v1(283.77,48.81) v1(284.79,65.55) v1(284.79,41.35) v1(284.89,49.93) v1(284.89,47.7) v1(285.77,41.67) v1(285.93,32.3) v1(286.04,36.75) v1(286.53,15.78) v1(287,42.64) v1(287.05,38.49) v1(287.05,35.01) v1(287.33,65.55) v1(287.33,64.18) v1(287.33,62.91) v1(287.35,28.85) v1(287.33,18.36) v1(288.63,85.68) v1(289.05,38.49) v1(289.05,35.01) v1(289.11,14.86) v1(289.62,67.94) v1(289.87,65.55) v1(289.87,64.18) v1(289.87,62.91) v1(290.06,36.75) v1(290.14,95.87) v1(290.38,16.22) v1(290.91,40.69) v1(291.04,30.68) v1(292.41,65.55) v1(292.41,64.18) v1(292.41,62.91) v1(292.56,40.61) v1(292.71,45.87) v1(292.89,36.75) v1(293.95,95.87) v1(294.19,92.25) v1(294.32,46.09) v1(294.34,38.4) v1(294.34,35.1) v1(294.95,65.55) v1(294.95,64.18) v1(294.94,40.55) v1(295.21,43.27) v1(295.46,61.16) v1(296.02,32.51) v1(296.07,30.72) v1(296.26,38.4) v1(296.26,35.1) v1(296.79,85.69) v1(296.94,63.17) v1(297.21,40.64) v1(297.45,68.22) v1(297.76,95.87) v1(297.71,36.75) v1(298,38.78) v1(298,16.22) v1(298.48,14.78) v1(298.67,36.57) v1(298.66,30.68) v1(299.46,93.9) v1(299.9,88.03) v1(300.49,63.89) v1(300.49,33.14) v1(300.67,94.81) v1(300.67,91) v1(300.67,67.69) v1(300.67,39.74) v1(300.67,15.4) v3(12.32,59.31) v3(14.69,16.13) v3(16.13,16.25) v3(19.23,30.59) v3(21.4,78.56) v3(22.12,81.78) v3(30.03,34.53) v3(35.4,80.31) v3(35.6,53.49) v3(39.7,80.26) v3(42.14,46.26) v3(63.59,19.73) v3(67,109.98) v3(67.61,67.56) v3(96.16,19.36) v3(96.56,90.22) v3(107.09,110.09) v3(129.15,15.82) v3(129.82,11.43) v3(140.36,18.94) v3(143.43,107.07) v3(173.96,17.48) v3(177.65,19.15) v3(181.13,12.1) v3(184.61,11.43) v3(191.23,12.43) v3(208.09,40.08) v3(246.65,40.78) v3(277.85,89.67) v3(278.73,89.66) v3(281.84,67.64) v3(282.08,28.25) v3(282.87,34.26) v3(284.59,14.92) v3(286.43,63.93) v3(286.45,60.75)
